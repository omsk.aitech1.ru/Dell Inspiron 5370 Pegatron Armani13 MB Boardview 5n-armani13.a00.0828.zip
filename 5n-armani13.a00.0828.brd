# Allegro board 5n-armani13.a00.0828.brd (continued)
## Nets (continued)
PCH_JTAG_TMS: R0402.1 T0402.1 U0400.C59(PCH_JTAG_TMS) U0400.C60(PROC_TMS)
PCH_JTAGX: R0420.2 U0400.A59(JTAGX) U0400.B61(PROC_TCK)
PCH_OPIRCOMP: R0405.2 U0400.AU16(PCH_OPIRCOMP)
PCH_PLTRST#: D2500.2(CATHODE) R1201.1 R3905.2 U0400.AN10(GPP_B13/PLTRST#) U1200.2(INA)
PCH_RSMRST#: R2322.1 R2323.2 U2300.27(GPIO123/SHD_CS#[BSS_STRAP])
PCH_RSMRST#_EC: R1217.2 R2323.1 U1202.2(INA)
PCH_TRST: T0403.1 U0400.B59(PROC_TRST#) U0400.C61(PCH_TRST#)
PCIE1_GPU_RXN: C6003.2 U0400.H13(PCIE1_RXN/USB3_5_RXN)
PCIE1_GPU_RXN_C: C6003.1 U6000.AG31(PCIE_TX0N)
PCIE1_GPU_RXP: C6002.2 U0400.G13(PCIE1_RXP/USB3_5_RXP)
PCIE1_GPU_RXP_C: C6002.1 U6000.AH30(PCIE_TX0P)
PCIE1_GPU_TXN: C6009.2 U0400.B17(PCIE1_TXN/USB3_5_TXN)
PCIE1_GPU_TXN_C: C6009.1 U6000.AE31(PCIE_RX0N)
PCIE1_GPU_TXP: C6008.2 U0400.A17(PCIE1_TXP/USB3_5_TXP)
PCIE1_GPU_TXP_C: C6008.1 U6000.AF30(PCIE_RX0P)
PCIE2_GPU_RXN: C6005.2 U0400.G11(PCIE2_RXN/USB3_6_RXN)
PCIE2_GPU_RXN_C: C6005.1 U6000.AF28(PCIE_TX1N)
PCIE2_GPU_RXP: C6004.2 U0400.F11(PCIE2_RXP/USB3_6_RXP)
PCIE2_GPU_RXP_C: C6004.1 U6000.AG29(PCIE_TX1P)
PCIE2_GPU_TXN: C6011.2 U0400.D16(PCIE2_TXN/USB3_6_TXN)
PCIE2_GPU_TXN_C: C6011.1 U6000.AD28(PCIE_RX1N)
PCIE2_GPU_TXP: C6010.2 U0400.C16(PCIE2_TXP/USB3_6_TXP)
PCIE2_GPU_TXP_C: C6010.1 U6000.AE29(PCIE_RX1P)
PCIE3_GPU_RXN: C6001.2 U0400.H16(PCIE3_RXN)
PCIE3_GPU_RXN_C: C6001.1 U6000.AF26(PCIE_TX2N)
PCIE3_GPU_RXP: C6000.2 U0400.G16(PCIE3_RXP)
PCIE3_GPU_RXP_C: C6000.1 U6000.AF27(PCIE_TX2P)
PCIE3_GPU_TXN: C6013.2 U0400.D17(PCIE3_TXN)
PCIE3_GPU_TXN_C: C6013.1 U6000.AC31(PCIE_RX2N)
PCIE3_GPU_TXP: C6012.2 U0400.C17(PCIE3_TXP)
PCIE3_GPU_TXP_C: C6012.1 U6000.AD30(PCIE_RX2P)
PCIE4_GPU_RXN: C6007.2 U0400.G15(PCIE4_RXN)
PCIE4_GPU_RXN_C: C6007.1 U6000.AD26(PCIE_TX3N)
PCIE4_GPU_RXP: C6006.2 U0400.F15(PCIE4_RXP)
PCIE4_GPU_RXP_C: C6006.1 U6000.AD27(PCIE_TX3P)
PCIE4_GPU_TXN: C6015.2 U0400.B19(PCIE4_TXN)
PCIE4_GPU_TXN_C: C6015.1 U6000.AB28(PCIE_RX3N)
PCIE4_GPU_TXP: C6014.2 U0400.A19(PCIE4_TXP)
PCIE4_GPU_TXP_C: C6014.1 U6000.AC29(PCIE_RX3P)
PCIE5_LAN_RXN: CON5104.5 U0400.F16(PCIE5_RXN)
PCIE5_LAN_RXP: CON5104.6 U0400.E16(PCIE5_RXP)
PCIE5_LAN_TXN: C5136.2 U0400.C19(PCIE5_TXN)
PCIE5_LAN_TXN_C: C5136.1 CON5104.7
PCIE5_LAN_TXP: C5135.2 U0400.D19(PCIE5_TXP)
PCIE5_LAN_TXP_C: C5135.1 CON5104.8
PCIE6_WLAN_RXN: CON5103.18 U0400.G18(PCIE6_RXN)
PCIE6_WLAN_RXP: CON5103.17 U0400.F18(PCIE6_RXP)
PCIE6_WLAN_TXN: C5134.2 U0400.D20(PCIE6_TXN)
PCIE6_WLAN_TXN_C: C5134.1 CON5103.20
PCIE6_WLAN_TXP: C5133.2 U0400.C20(PCIE6_TXP)
PCIE6_WLAN_TXP_C: C5133.1 CON5103.19
PCIE9_SSD1_RXN: CON3100.5 U0400.E22(PCIE9_RXN)
PCIE9_SSD1_RXP: CON3100.7 U0400.E23(PCIE9_RXP)
PCIE9_SSD1_TXN: C3104.1 U0400.B23(PCIE9_TXN)
PCIE9_SSD1_TXN_C: C3104.2 CON3100.11
PCIE9_SSD1_TXP: C3105.1 U0400.A23(PCIE9_TXP)
PCIE9_SSD1_TXP_C: C3105.2 CON3100.13
PCIE10_SSD1_RXN: CON3100.17 U0400.F25(PCIE10_RXN)
PCIE10_SSD1_RXP: CON3100.19 U0400.E25(PCIE10_RXP)
PCIE10_SSD1_TXN: C3106.1 U0400.D23(PCIE10_TXN)
PCIE10_SSD1_TXN_C: C3106.2 CON3100.23
PCIE10_SSD1_TXP: C3107.1 U0400.C23(PCIE10_TXP)
PCIE10_SSD1_TXP_C: C3107.2 CON3100.25
PCIE11_SSD1_RXN: CON3100.29 U0400.E28(PCIE11_RXN/SATA1B_RXN)
PCIE11_SSD1_RXP: CON3100.31 U0400.E27(PCIE11_RXP/SATA1B_RXP)
PCIE11_SSD1_TXN: C3111.1 U0400.D24(PCIE11_TXN/SATA1B_TXN)
PCIE11_SSD1_TXN_C: C3111.2 CON3100.35
PCIE11_SSD1_TXP: C3112.1 U0400.C24(PCIE11_TXP/SATA1B_TXP)
PCIE11_SSD1_TXP_C: C3112.2 CON3100.37
PCIE12_SATA_SSD1_RXN: R3112.2 U0400.E30(PCIE12_RXN/SATA2_RXN)
PCIE12_SATA_SSD1_RXN_R: CON3100.43 R3112.1
PCIE12_SATA_SSD1_RXP: R3111.2 U0400.F30(PCIE12_RXP/SATA2_RXP)
PCIE12_SATA_SSD1_RXP_R: CON3100.41 R3111.1
PCIE12_SATA_SSD1_TXN: C3113.1 U0400.A25(PCIE12_TXN/SATA2_TXN)
PCIE12_SATA_SSD1_TXN_C: C3113.2 CON3100.47
PCIE12_SATA_SSD1_TXP: C3114.1 U0400.B25(PCIE12_TXP/SATA2_TXP)
PCIE12_SATA_SSD1_TXP_C: C3114.2 CON3100.49
PCIE_RCOMPN: R1401.2 U0400.F5(PCIE_RCOMPN)
PCIE_RCOMPP: R1401.1 U0400.E5(PCIE_RCOMPP)
PCIE_WAKE#: CON5104.3 Q3102.3(DRAIN) R1214.2 U0400.BB15(WAKE#) U2300.4(GPIO002/PWM7)
PCIE_WAKE#_R: CON3100.54 Q3102.2(SOURCE) R3113.2
PD_HPD: Q5801.3(DRAIN) R5719.2 R5806.1 R5825.1 U5800.18(HPD_P1/GPIO)
PD_HPD_R: R5719.1 U5703.23(CTL1/HPDIN)
PD_VBUS_C_CTRL1_A: PQ7608.6(DRAIN) PQ7612.5(GATE) PQ7612.6(DRAIN) PR7633.2
PECI_PCH: R2300.2 U0400.A54(PECI)
PERSTB_RST#: U6000.AL27(PERSTB) U6001.4(OUT_Y)
PGOOD_VCPU: PR7836.1 PU7800.39(VR_READY)
PLL_ANALOG_IN: T6905.1 U6000.AA1(PLL_ANALOG_IN)
PLL_ANALOG_OUT: R6907.2 U6000.AA3(PLL_ANALOG_OUT)
PLT_RST#_BUF: CON5103.36 R1201.2 R1225.2 R3103.1 U1200.4(OUT_Y) U6001.2(INA)
PLT_RST#_BUF_EMMC: D2500.1(ANODE) R2514.1 U2500.K5(RSTN)
PM_PCH_PWROK: R1213.1 R1227.1 R1228.2 U0400.BA20(PCH_PWROK)
PM_THRMTRIP#: D2401.3(ANODE) D3700.1(ANODE) Q2401.1(SOURCE)
POWER_SW_IN#: C2311.1 R2309.1 R2310.2 U2300.127(VCI_IN0#/GPIO163)
PQ7608B_3: PQ7608.3(DRAIN) PR7635.2
PQ7608B_4: PQ7608.4(SOURCE) PQ7612.3(DRAIN)
PRIM_PWRGD: R2346.2 U2300.30(GPIO135/SHD_IO2)
PRO_THM: U5900.18(SRC) U5900.19(SRC_1) U5900.20(SRC_2) U5900.21(SRC_3) U5900.22(SRC_4) U5900.23(SRC_5) U5900.24(SRC_6) U5900.25(SRC_7) U5900.26(SRC_8)
PROC_POPIRCOMP: R0404.2 U0400.AT16(PROC_POPIRCOMP)
PROC_SELECT#: R0902.1 U0400.C64(PROC_SELECT#)
PROCHOT: R0418.1 U2300.83(GPIO120/CMP_VOUT1)
PROCHOT#: PQ7603.3(DRAIN) PR7723.2 PR7834.2 Q3600.3(DRAIN) R0400.2 R0410.1 R0416.2
PROCHOT#_R: R0410.2 U0400.C65(PROCHOT#)
PROCPWRGD: T1202.1 U0400.A68(PROCPWRGD)
PROG1_VCPU: PR7832.1 PU7800.32(PROG1)
PROG2_VCPU: PR7833.1 PU7800.31(PROG2)
PROJECT_ID0: R1022.2 R1023.1 U0400.AK6(GPP_F0/I2S2_SCLK)
PROJECT_ID1: R1024.2 R1027.1 U0400.AK7(GPP_F1/I2S2_SFRM)
PROJECT_ID2: R1025.2 R1028.1 U0400.AK9(GPP_F2/I2S2_TXD)
PROJECT_ID3: R1026.2 R1029.1 U0400.AK10(GPP_F3/I2S2_RXD)
PS8743_SBU1: CON5700.A8(SBU1) D5704.1(ANODE) U5703.27(SBU1)
PS8743_SBU2: CON5700.B8(SBU2) D5705.1(ANODE) U5703.26(SBU2)
PS_ID: PD7601.3(ANODE2) PR7607.2 PR7619.2 U2300.36(GPIO032/BCM_CLK0/PWM6)
PSID_IN: CON7600.4 PL7605.1
PTP_DIS#: D2300.2(CATHODE) U2300.90(GPIO035/SB-TSI_CLK)
PTP_DIS#_R: CON5100.3 D2300.1(ANODE) R5108.2
PU5101_EN1: PR9000.1 PR9205.1 PU9000.4(OUT_Y)
PU5101_EN1_A: PR9000.2 PR9001.1 PU9001.3(EN1)
PU5101_SS1_A: PC9002.1 PU9001.12(SS1)
PU5101_SS2_A: PC9007.1 PU9001.10(SS2)
PU5101_VOUT1_S: PC9003.1 PR9002.2 PU9001.14(VOUT1)
PU5101_VOUT2_S: PC9811.1 PR9003.2 PU9001.8(VOUT2)
PU5102_EN1_A: PR9109.2 PR9110.1 PU9100.3(EN1)
PU5102_EN2_A: PR9106.2 PR9107.1 PU9100.5(EN2)
PU5102_SS1_A: PC9112.1 PU9100.12(SS1)
PU5102_SS2_A: PC9108.1 PU9100.10(SS2)
PU5102_VOUT1_S: PC9113.1 PR9111.2 PU9100.14(VOUT1)
PU5102_VOUT2_S: PC9109.1 PR9108.2 PU9100.8(VOUT2)
PU5104_EN1_A: PR9100.2 PR9101.1 PU9101.3(EN1)
PU5104_EN2_A: PR9103.2 PR9104.1 PU9101.5(EN2)
PU5104_SS1_A: PC9102.1 PU9101.12(SS1)
PU5104_SS2_A: PC9105.1 PU9101.10(SS2)
PU5104_VOUT1_S: PC9103.1 PR9102.2 PU9101.14(VOUT1)
PU5104_VOUT2_S: PC9114.1 PR9105.1 PU9101.8(VOUT2)
PU5106_EN1_A: PR9205.2 PR9207.1 PU9200.3(EN1)
PU5106_EN2_A: PR9200.2 PR9201.1 PU9200.5(EN2)
PU5106_SS1_A: PC9201.1 PU9200.12(SS1)
PU5106_SS2_A: PC9204.1 PU9200.10(SS2)
PU5106_VOUT1_S: PC9203.1 PR9206.2 PR9208.2 PU9200.14(VOUT1)
PU5106_VOUT2_S: PC9202.1 PR9202.2 PU9200.8(VOUT2)
PWM1_B: PR7918.1 PU7800.12(PWM1_B)
PWM1B_SW_OUT_S: PJP7901.2 PL7900.1 PQ7900.5(SW1) PQ7900.6(SW2) PQ7900.7(SW3) PR7903.1
PWM2_B: PR7920.1 PU7800.13(PWM2_B)
PWM2B_SW_OUT_S: PJP7903.2 PL7901.1 PQ7901.5(SW1) PQ7901.6(SW2) PQ7901.7(SW3) PR7909.1
PWM_A: PR8016.1 PU7800.22(PWM_A)
PWM_C: PR8014.1 PU7800.30(PWM_C)
PWMA_SW_OUT_S: PJP8002.2 PL8001.1 PQ8001.5(SW1) PQ8001.6(SW2) PQ8001.7(SW3) PR8008.1
PWR_BTN#: CON5103.44 R2309.2
PX_MODE: T6947.1 U6000.AB16(PX_EN)
R: C3809.1 R3828.1
R_HPOUT_L: C3812.1 D3802.2(CATHODE) J3800.2 L3801.2
R_HPOUT_R: C3810.1 D3800.2(CATHODE) J3800.3 L3804.2
RASA0#: U6000.G22(RASA0B) U6800.G3(RAS#/CAS#) U6801.L3(CAS#/RAS#)
RASA1#: U6000.G17(RASA1B) U6802.L3(CAS#/RAS#) U6803.G3(RAS#/CAS#)
RESET_OUT#: R1228.1 U2300.73(GPIO107/NRESET_OUT)
RING2: C3841.1 L3803.1 R3801.2 U3800.30(MIC2_L/RING2)
RR_HPOUT_L: L3801.1 R3802.2
RR_HPOUT_R: L3804.1 R3803.2
RSMRST#: C1203.1 R1216.1 R1217.1 R1226.1 U0400.AY17(RSMRST#) U1202.4(OUT_Y)
RTC_DET#: Q3601.3(DRAIN) R1503.2 U0400.P1(GPP_D12)
RTC_RST#: C1005.1 Q1000.3(DRAIN) R1011.2 U0400.AM16(RTCRST#)
RTC_X1: C1003.1 R1007.2 R1008.2 U0400.AM18(RTCX1)
RTC_X2: C1002.1 R1007.1 U0400.AM20(RTCX2) X1001.1
RTCRST_ON: Q1000.1(GATE) R1019.1 R2425.2 U2300.31(GPIO136/SHD_IO3)
RUNPWROK: R1805.2 U1800.2(INA) U2300.48(GPIO057/VCC_PWRGD)
RX1N_P1: CON5700.B10(SSRXN1) L5702.4 RN5702.3(X) U5700.2(CH2) U5700.9(N.C.3)
RX1N_P1_MUX: L5702.3 RN5702.4(Y) U5703.31(RX1N)
RX1P_P1: CON5700.B11(SSRXP1) L5702.1 RN5702.1(X) U5700.1(CH1) U5700.10(N.C.4)
RX1P_P1_MUX: L5702.2 RN5702.2(Y) U5703.30(RX1P)
RX2N_P1: CON5700.A10(SSRXN2) L5703.1 RN5703.1(X) U5701.2(CH2) U5701.9(N.C.3)
RX2N_P1_MUX: L5703.2 RN5703.2(Y) U5703.39(RX2N)
RX2P_P1: CON5700.A11(SSRXP2) L5703.4 RN5703.3(X) U5701.1(CH1) U5701.10(N.C.4)
RX2P_P1_MUX: L5703.3 RN5703.4(Y) U5703.40(RX2P)
SATA0_RXN_HDD: C3122.1 U0400.F20(PCIE7_RXN/SATA0_RXN)
SATA0_RXN_HDD_C: C3122.2 CON3101.5
SATA0_RXP_HDD: C3123.1 U0400.E20(PCIE7_RXP/SATA0_RXP)
SATA0_RXP_HDD_C: C3123.2 CON3101.6
SATA0_TXN_HDD: C3121.1 U0400.B21(PCIE7_TXN/SATA0_TXN)
SATA0_TXN_HDD_C: C3121.2 CON3101.3
SATA0_TXP_HDD: C3120.1 U0400.A21(PCIE7_TXP/SATA0_TXP)
SATA0_TXP_HDD_C: C3120.2 CON3101.2
SATA_LED#: Q5002.2(GATE) R1409.2 R3116.1 U0400.H1(GPP_E8/SATALED#)
SATA_LED_Q: Q5002.5(GATE) Q5002.6(DRAIN) R5002.2
SCS#_TPM: R3908.1 R3913.1 U3901.20(LFRAME#/SCS#)
SD_READ_MODE: R1517.1 U0400.AN5(GPP_B22/GSPI1_MOSI)
SDATA_IN_R: R3805.2 U3800.16(SDATA_IN)
SERIRQ_TPM: R3911.1 U3901.27(SERIRQ)
SIO_EXT_SCI#: T1402.1 U0400.J2(GPP_E5/DEVSLP1)
SIO_EXT_SMI#: T0409.1 U0400.L6(GPP_E15/DDPD_HPD2)
SIO_EXT_WAKE#: R1506.2 U0400.AD3(GPP_C22/UART2_RTS#) U2300.116(GPIO022/ADC5)
SIO_PWRBTN#: R1200.2 U0400.BA15(GPD3/PWRBTN#) U2300.52(GPIO026/PS2_CLK1B)
SIO_SLP_A#: T1203.1 U0400.AN16(GPD6/SLP_A#)
SIO_SLP_S0#: CON5103.35 PU9000.2(INA) R3903.2 R3914.2 U0400.AT11(GPP_B12/SLP_S0#)
SIO_SLP_S3#: PR8604.1 PR9004.1 PR9100.1 PR9109.1 PU9000.1(INB) U0400.AP15(GPD4/SLP_S3#) U1800.1(INB)
SIO_SLP_S4#: PCE8601.2(CATHODE) PD8800.1(ANODE) PR8615.1 PR8813.1 PR9200.1 U0400.BA16(GPD5/SLP_S4#)
SIO_SLP_S5#: T1201.1 U0400.AY16(GPD10/SLP_S5#)
SLEEVE: C3842.1 L3802.1 R3800.2 U3800.31(MIC2_R/SLEEVE)
SLP_SUS#: T1207.1 U0400.AN15(SLP_SUS#)
SM_RCOMP_0: R0500.1 U0400.AR18(DDR_RCOMP[0])
SM_RCOMP_1: R0501.1 U0400.AT18(DDR_RCOMP[1])
SM_RCOMP_2: R0502.1 U0400.AU18(DDR_RCOMP[2])
SMB_ALERT#: R1114.2 U0400.R10(GPP_C2/SMBALERT#)
SMB_THERMAL_CLK: C1901.1 Q1900.1(SOURCE) R1911.2 U3700.8(SCL)
SMB_THERMAL_DATA: C1902.1 Q1900.4(SOURCE) R1912.2 U3700.7(SDA)
SML0_ALERT#: R1109.2 U0400.W1(GPP_C5/SML0ALERT#)
SML0_SMBCLK: R1102.2 T1103.1 U0400.R9(GPP_C3/SML0CLK)
SML0_SMBDATA: R1103.2 T1104.1 U0400.W2(GPP_C4/SML0DATA)
SML1_SMBCLK: R1104.2 R1910.1 U0400.W3(GPP_C6/SML1CLK)
SML1_SMBDATA: R1105.2 R1909.1 U0400.V3(GPP_C7/SML1DATA)
SML1ALERT#: R1106.2 U0400.AM7(GPP_B23/SML1ALERT#/PCHHOT#)
SPI_CLK: J5301.7 R1906.1 R3907.2 U0400.AV2(SPI0_CLK)
SPI_CLK_R: R1906.2 U1900.6(CLK)
SPI_CS0#: J5301.2 J5301.5 R1902.2 U0400.AU3(SPI0_CS0#) U1900.1(CS#)
SPI_CS1#: T1101.1 U0400.AU2(SPI0_CS1#)
SPI_CS2#: R3908.2 U0400.AU1(SPI0_CS2#)
SPI_HOLD#_IO3: J5301.10 J5301.12 R1904.2 U0400.AU4(SPI0_IO3) U1900.7(HOLD#/RESET#(IO3))
SPI_SI: J5301.8 R1900.1 R3909.2 U0400.AV3(SPI0_MOSI)
SPI_SI_R: R1900.2 U1900.5(DI(IO0))
SPI_SO: J5301.6 R1905.2 R3910.2 U0400.AW3(SPI0_MISO)
SPI_SO_R: R1905.1 U1900.2(DO(IO1))
SPI_WP_IO2: R1903.2 U0400.AW2(SPI0_IO2) U1900.3(WP#(IO2))
SPK_ID: R3825.2 R3826.2 U0400.AB1(GPP_C8/UART0_RXD)
SPK_ID_R: CON3800.6 R3825.1
SPK_L+: R3813.2 U3800.42(SPK_OUT_L+)
SPK_L+_R: C3838.2 CON3800.4 R3813.1
SPK_L-: R3812.2 U3800.43(SPK_OUT_L-)
SPK_L-_R: C3837.2 CON3800.3 R3812.1
SPK_R+: R3806.2 U3800.45(SPK_OUT_R+)
SPK_R+_R: C3835.2 CON3800.1 R3806.1
SPK_R-: R3807.2 U3800.44(SPK_OUT_R-)
SPK_R-_R: C3836.2 CON3800.2 R3807.1
SPKR: D3805.2(ANODE2) R1021.2 U0400.AW5(GPP_B14/SPKR)
SRTC_RST#: C1006.1 R1009.2 T1000.1 U0400.AN18(SRTCRST#)
SSD1_PEDET_R: CON3100.69 Q3100.1(GATE) R3106.1 R3107.1 R3114.2
SSD_DEVSLP: R1408.1 U0400.J3(GPP_E6/DEVSLP2)
SUS_PWRGD: PR8702.1 PU8900.7(PGOOD) R1220.2 R1221.2 R2404.1 U1201.2(INA)
SUSACK#: R1229.1 U0400.AP11(GPP_A15/SUSACK#)
SUSCLK: R2329.2 U0400.BA17(GPD8/SUSCLK)
SYS_PWROK: R1211.1 R1212.1 U2300.28(GPIO133/SHD_IO0)
SYS_PWROK_R: R1211.2 U0400.B6(SYS_PWROK)
SYS_RESET#: R1205.2 U0400.B5(SYS_RESET#)
SYSPWR_PRES: R2306.1 R2332.1 U2300.120(SYSPWR_PRES/GPIO003)
THERMAL_D+: C3706.1 Q3700.1(BASE) Q3700.3(COLLECTOR) U3700.2(D+)
THERMAL_D-: C3706.2 Q3700.2(EMITTER) U3700.3(D-)
THRMTRIP#: R0417.2 U0400.C63(THERMTRIP#)
TOUCHPAD_INTR#_CON: CON5100.4 Q5102.4(SOURCE) R5102.2
TP_CATERR#_R: T0410.1 U0400.D63(CATERR#)
TP_EN#: C5131.2 Q5101.1(GATE) Q5102.2(GATE) R2335.2 U2300.49(GPIO060/KBRST)
TP_WAKE_KBC#: Q5102.3(DRAIN) R2334.2 U0400.BA5(GPP_B3/CPU_GP2) U2300.33(GPIO062/SPI_IO3)
TPM_GPIO2: R3903.1 U3901.29(GPIO0/SDA)
TPM_ID: R1017.2 R1018.1 U0400.D8(GPP_D17/DMIC_CLK1)
TPM_PP: R3904.1 U3901.4(PP)
TPM_RST#: R3905.1 U3901.17(SRESET#/LRESET#/SPI_RST#)
TPM_SPI_CLK: R3907.1 U3901.19(LCLK/SCLK)
TPM_SPI_IRQ#: R3916.2 U0400.M2(GPP_D1/SPI1_CLK) U3901.18(LDA2/SPI_IRQ#)
TUSB546_A0: R5717.2 R5720.1 U5703.11(SSEQ0/A0)
TUSB546_A1: R5716.1 R5718.2 U5703.14(DPEQ0/A1)
TUSB546_DPEQ1: R5704.1 R5705.2 U5703.2(DPEQ1)
TUSB546_EQ0: R5700.1 R5702.2 U5703.38(EQ0)
TUSB546_EQ1: R5701.1 R5703.2 U5703.35(EQ1)
TUSB546_SSEQ1: R5706.1 R5707.2 U5703.3(SSEQ1)
TX1N_P1: C5720.2 L5704.4 RN5704.3(X)
TX1N_P1_C: C5720.1 CON5700.A3(SSTXN1) U5700.5(CH4) U5700.6(N.C.1)
TX1N_P1_MUX: L5704.3 RN5704.4(Y) U5703.34(TX1N)
TX1P_P1: C5719.2 L5704.1 RN5704.1(X)
TX1P_P1_C: C5719.1 CON5700.A2(SSTXP1) U5700.4(CH3) U5700.7(N.C.2)
TX1P_P1_MUX: L5704.2 RN5704.2(Y) U5703.33(TX1P)
TX2N_P1: C5722.2 L5705.1 RN5705.1(X)
TX2N_P1_C: C5722.1 CON5700.B3(SSTXN2) U5701.5(CH4) U5701.6(N.C.1)
TX2N_P1_MUX: L5705.2 RN5705.2(Y) U5703.36(TX2N)
TX2P_P1: C5721.2 L5705.4 RN5705.3(X)
TX2P_P1_C: C5721.1 CON5700.B2(SSTXP2) U5701.4(CH3) U5701.7(N.C.2)
TX2P_P1_MUX: L5705.3 RN5705.4(Y) U5703.37(TX2P)
TYPEC_SMBCLK: C1906.1 Q1901.6(DRAIN) R1916.2 R1918.2 U2300.91(GPIO131/SMB03_CLK/SMB03_CLK18)
TYPEC_SMBDA: C1905.1 Q1901.3(DRAIN) R1914.2 R1917.2 U2300.89(GPIO130/SMB03_DATA/SMB03_DATA18)
UART1_CTS#: T1505.1 U0400.AB4(GPP_C15/UART1_CTS#/ISH_UART1_CT)
UART1_RTS#: T1506.1 U0400.AC3(GPP_C14/UART1_RTS#/ISH_UART1_RT)
UART_2_CRXD_DTXD: R1513.2 T1502.1 U0400.AD1(GPP_C20/UART2_RXD)
UART_2_CTXD_DRXD: R1514.2 T1503.1 U0400.AD2(GPP_C21/UART2_TXD)
USB2_COMP: R1400.1 U0400.AB6(USB2_COMP)
USB3_RX_N1: CON5103.30 U0400.H8(USB3_1_RXN)
USB3_RX_N3: C5708.1 U0400.J10(USB3_3_RXN)
USB3_RX_N3_C: C5708.2 U5703.4(SSRXN)
USB3_RX_N4: CON5103.25 U0400.E10(USB3_4_RXN)
USB3_RX_P1: CON5103.29 U0400.G8(USB3_1_RXP)
USB3_RX_P3: C5707.1 U0400.H10(USB3_3_RXP)
USB3_RX_P3_C: C5707.2 U5703.5(SSRXP)
USB3_RX_P4: CON5103.24 U0400.F10(USB3_4_RXP)
USB3_TX_N1: CON5103.28 U0400.C13(USB3_1_TXN)
USB3_TX_N3: C5706.1 U0400.B15(USB3_3_TXN)
USB3_TX_N3_C: C5706.2 U5703.7(SSTXN)
USB3_TX_N4: CON5103.23 U0400.C15(USB3_4_TXN)
USB3_TX_P1: CON5103.27 U0400.D13(USB3_1_TXP)
USB3_TX_P3: C5705.1 U0400.A15(USB3_3_TXP)
USB3_TX_P3_C: C5705.2 U5703.8(SSTXP)
USB3_TX_P4: CON5103.22 U0400.D15(USB3_4_TXP)
USB_ADT: PQ7613.5(DRAIN) PQ7614.5(DRAIN) PR7641.1 PR7645.1
USB_EN#: R2326.2 U2300.13(NRESET_IN/GPIO014) U5101.4(EN/EN#)
USB_OC0#: CON5103.33 R1402.2 U0400.A9(GPP_E9/USB2_OC0#)
USB_OC1#: R1403.2 U0400.C9(GPP_E10/USB2_OC1#) U5101.3(FLAG) U5900.10(FAULTB)
USB_OC2#: R1404.2 U0400.D9(GPP_E11/USB2_OC2#)
USB_OC3#: R1405.2 U0400.B9(GPP_E12/USB2_OC3#)
USB_POWERSHARE_VBUS_EN: CON5103.32 U2300.71(GPIO105/SPI_IO1)
USB_PWR_SHR_EN_L#: CON5103.31 R2324.2 R2325.1 U2300.118(GPIO024/ADC7)
USBN1: CON5103.4 U0400.AB9(USB2N_1)
USBN3_TYPEC: U0400.AH3(USB2N_3) U5702.2(INA-)
USBN4: CON5103.2 U0400.AD9(USB2N_4)
USBN5_CAM: L3000.2 RN3000.3(X) U0400.AJ1(USB2N_5)
USBN6_SD: CON5103.9 U0400.AF6(USB2N_6)
USBN7_BT: CON5103.14 U0400.AH1(USB2N_7)
USBN9_FP: CON5103.12 U0400.AG1(USB2N_9)
USBP1: CON5103.5 U0400.AB10(USB2P_1)
USBP3_TYPEC: U0400.AJ3(USB2P_3) U5702.1(INA+)
USBP4: CON5103.3 U0400.AD10(USB2P_4)
USBP5+_CAM: CON3000.7 D3002.1(ANODE) L3000.4 RN3000.2(Y)
USBP5-_CAM: CON3000.6 D3001.1(ANODE) L3000.1 RN3000.4(Y)
USBP5_CAM: L3000.3 RN3000.1(X) U0400.AJ2(USB2P_5)
USBP6_SD: CON5103.10 U0400.AF7(USB2P_6)
USBP7_BT: CON5103.15 U0400.AH2(USB2P_7)
USBP9_FP: CON5103.13 U0400.AG2(USB2P_9)
VA_RTC: D3604.1(ANODE) R3613.2 R3614.1
VCONN_VMON_P1: T5801.1 U5800.19(VCONN_MON_P1/GPIO)
VCREF0: C2401.1 R2412.2 R2413.1 U2300.25(GPIO165/CMP_VREF0)
VDC_IN_SN: PC7601.1 PR7600.2 PR7602.2 PR7603.2 PR7604.2
VGA_SVID_ALERT#: PC9422.1 PR9401.2 PR9450.2 PR9459.1 U6000.AL11(GPIO_SVT)
VGA_SVID_CLK: PR9451.2 U6000.AJ11(GPIO_SVC)
VGA_SVID_DATA: PR9449.2 U6000.AK12(GPIO_SVD)
VHG_VSYS_R: PR7711.1 PU7700.3(VSYS)
VHIO: C3903.1 C3905.1 C3907.1 C3913.1 C3914.1 R3912.2 R3915.2 U3901.14(VHIO_1) U3901.22(VHIO_2)
VIDALERT#: PR7840.2 R0601.1 R0603.2
VIDALERT#_VCPU: PR7840.1 PU7800.36(ALERT#)
VIDSCLK: PR7843.2 PR7846.1 R0604.1
VIDSCLK_VCPU: PR7843.1 PU7800.37(SCLK)
VIDSOUT: PR7839.2 PR7847.1 R0602.1 R0605.1
VIDSOUT_VCPU: PR7839.1 PU7800.35(SDA)
VR_CAP: C2310.1 U2300.18(VR_CAP)
VR_HOT#_VCPU: PR7834.1 PU7800.38(VR_HOT#)
VRALERT#: R1210.2 U0400.AM11(GPP_B2/VRALERT#)
VRAM_ID1: R1507.2 R1508.1 U0400.AP8(GPP_B17/GSPI0_MISO)
VRAM_ID2: R1504.2 R1505.1 U0400.U2(GPP_D14/ISH_UART0_TXD/SML0BCLK/)
VRAM_RST#: R6301.1 U6800.J2(RESET#) U6801.J2(RESET#) U6802.J2(RESET#) U6803.J2(RESET#)
VREF_CPU: C2315.1 R2321.1 U2300.95(VREF_CPU)
VREF_PINSET_RC: PC9420.1 PR9448.2
VRM_PWRGD: PR7836.2 R1222.2 U1203.1(INB)
WCKA0_0: U6000.E32(WCKA0_0) U6800.D4(WCK01/WCK23) U6801.P4(WCK23/WCK01)
WCKA0_1: U6000.A21(WCKA0_1) U6800.P4(WCK23/WCK01) U6801.D4(WCK01/WCK23)
WCKA0B_0: U6000.E30(WCKA0B_0) U6800.D5(WCK01#/WCK23#) U6801.P5(WCK23#/WCK01#)
WCKA0B_1: U6000.C21(WCKA0B_1) U6800.P5(WCK23#/WCK01#) U6801.D5(WCK01#/WCK23#)
WCKA1_0: U6000.E13(WCKA1_0) U6802.P4(WCK23/WCK01) U6803.D4(WCK01/WCK23)
WCKA1_1: U6000.E3(WCKA1_1) U6802.D4(WCK01/WCK23) U6803.P4(WCK23/WCK01)
WCKA1B_0: U6000.D12(WCKA1B_0) U6802.P5(WCK23#/WCK01#) U6803.D5(WCK01#/WCK23#)
WCKA1B_1: U6000.F4(WCKA1B_1) U6802.D5(WCK01#/WCK23#) U6803.P5(WCK23#/WCK01#)
WEA0#: U6000.G25(WEA0B) U6800.L12(WE#/CS#) U6801.G12(CS#/WE#)
WEA1#: U6000.H10(WEA1B) U6802.G12(CS#/WE#) U6803.L12(WE#/CS#)
WHITE_LED_ON#: Q5000.6(DRAIN) Q5002.3(DRAIN) R5000.2
WIFI_RF_EN: CON5103.38 U0400.B7(GPP_D4/FLASHTRIG)
XCLK_BIASREF: R1005.2 R1006.1 U0400.E42(XCLK_BIASREF)
XDP_PRDY#: T1400.1 U0400.D56(PROC_PRDY#)
XDP_PREQ#: T1401.1 U0400.D61(PROC_PREQ#)
XRES: C5807.1 R5802.1 T5802.1 U5800.10(XRES)
XTAL_24M_IN: R1001.1 U0400.E37(XTAL24_IN)
XTAL_24M_IN_R: C1001.2 R1000.2 R1001.2 X1000.3
XTAL_24M_IN_R_U42: C0900.2 R0903.2 R0904.2 X0900.3
XTAL_24M_IN_U42: R0904.1 U0400.E3(RSVD_31)
XTAL_24M_OUT: R1020.1 U0400.E35(XTAL24_OUT)
XTAL_24M_OUT_R: C1000.2 R1000.1 R1020.2 X1000.1
XTAL_24M_OUT_R_U42: C0901.2 R0903.1 R0905.2 X0900.1
XTAL_24M_OUT_U42: R0905.1 U0400.C7(RSVD_41)
XTALIN: C6900.1 R6900.1 R6942.1 U6000.AM28(XTALIN)
XTALIN_GR: R6900.2 X6900.1
XTALOUT: C6901.1 R6942.2 U6000.AK28(XTALOUT) X6900.3
ZVM#: T0905.1 U0400.AR56(ZVM#)
N50493: Q5102.6(DRAIN) R5107.2
N64175: CON5101.4 Q5100.3(DRAIN)
N16940974: R5907.1 U5900.14(NC)
N16941233: R5905.2 U5900.8(DISC1)
N16941314: C2109.2 R2104.1
N17285432: C3115.1 CON3100.50 R3103.2
N19673410: T1206.1 U0400.AM10(GPP_B11/EXT_PWR_GATE#)
N31955539: R1410.1 U0400.AG3(USB2_ID)
N42937574: R0414.2 U0400.N8(GPP_E21/DDPC_CTRLDATA)
N144273293: C2008.2 R2006.1
N144773302: PC8909.1 PCE8901.1 PJP8900.1 PJP8902.1 PL8900.2
N144773400: PC8919.1 PCE8902.1 PJP8901.1 PJP8903.1 PL8901.2
N145129059: PC8804.1 PC8805.1 PC8806.1 PJP8800.2 PJP8802.2 PL8800.2 PR8800.1
N145246305: PJP8002.1 PR8009.1
N145248377: PJP7901.1 PR7904.1 PR7906.1
N145248379: PJP7902.1 PR7905.1 PR7921.1
N145785510: C5804.1 R5803.2 R5804.2 U5800.13(VBUS_MON_P1/GPIO)
N146310019: PJP8003.1 PR8010.1
N146862019: R3701.2 R3703.1 U3701.3(SDO/SAO)
N146862127: R3700.2 U3701.2(CS)
N146967179: R1227.2 U1203.4(OUT_Y)
N146992205: PQ7600.5(DRAIN) PQ7607.5(DRAIN) PR7601.1 PR7646.1
N146992240: PQ7606.1(EMITTER1) PR7601.2
N147117574: Q2400.3(DRAIN) R2407.2
N147117610: Q2400.5(GATE) Q2400.6(DRAIN) R2406.2 R2408.1
N147136954: Q5101.3(DRAIN) R5109.1
N147156627: CON3601.6 R3607.2
N147808873: T5805.1 U5800.14(OVP_TRIP_P1)
N147968556: PQ7603.2(GATE) PR7615.2 PR7616.1
N147968560: PC7604.1 PQ7603.6(DRAIN) PR7617.2
N147968575: PC7604.2 PQ7603.5(GATE) PR7618.1
N148388543: C2400.1 Q2401.6(DRAIN) R2409.2 R2410.2 R2411.2 R2414.1
N148505031: D2401.1(CATHODE1) R2400.2
N148505032: D2401.2(CATHODE2) R2403.2 R2424.2
N148738573: C5809.1 Q5800.1(GATE) R5813.1
N148738591: Q5800.3(DRAIN) R5815.2 U5802.3(EN)
N148740165: R5819.2 R5820.1 U5802.4(NC/ADJ)
N148743428: R5721.2 R5723.2 U5702.3(INB+)
N148743430: R5722.2 R5724.2 U5702.4(INB-)
N148861333: Q1901.2(GATE) Q1901.5(GATE) R1915.2
N148862035: Q1900.2(GATE) Q1900.5(GATE) R1913.2
N151615972: Q3101.5(GATE) Q3101.6(DRAIN) R3109.2
N151647275: Q1902.2(GATE) Q1902.5(GATE) R1920.2
N151759903: T2308.1 U2300.63(GPIO067/CLKRUN#)
N151878978: R5709.2 U5703.17(I2C_EN)
N151977162: T1500.1 U0400.AY8(GPP_A18/ISH_GP0)
N151977628: PQ7601.5(GATE) PQ7602.3(COLLECTOR) PR7609.2
N152024780: PD8800.2(CATHODE) PR8812.1
N152371418: C0400.1 Q0400.1(GATE) R0418.2
N152371714: Q0400.3(DRAIN) R0416.1
N152454489: PC8705.1 PR8711.2 PU8700.3(3V3)
N152454517: PR8705.1 PU8700.11(OTW)
N152454563: PR8706.1 PU8700.14(MODE)
N152454665: PC8704.2 PR8709.1 PR8710.2
N152619359: PJP7903.1 PR7910.1 PR7911.1
N152619365: PJP7904.1 PR7912.1 PR7922.1
N152623996: PJP8001.1 PR8005.1
N152624000: PJP8000.1 PR8004.1
N152659585: R1411.1 U0400.AG4(USB2_VBUSSENSE)
N152732906: T2300.1 U2300.96(GPIO141/SMB04_DATA/SMB04_DATA18)
N152732920: T2303.1 U2300.97(GPIO142/SMB04_CLK/SMB04_CLK18)
N152732948: T2302.1 U2300.41(GPIO051/TACH1)
N152733148: T2301.1 U2300.34(GPIO030/BCM_INT0#/PWM4)
N152789464: PQ7605.2(BASE1) PQ7605.5(BASSE2) PQ7606.3(COLLECTOR2) PR7620.2 PR7621.1
N152790013: PQ7600.4(GATE) PQ7605.1(EMITTER1) PQ7605.4(EMITTER2) PR7620.1
N152790825: PQ7606.2(BASE1) PR7622.2
N152790828: PQ7606.6(COLLECTOR1) PR7622.1 PR7623.1 PR7624.2
N152790848: PQ7606.5(BASE2) PR7624.1
N152895939: PD9400.2(CATHODE) PR9421.2 PR9426.2 PR9427.1 PR9456.2
N152902736: PQ7609.2(BASE1) PR7627.2
N152903262: PQ7609.6(COLLECTOR1) PR7628.1
N152903293: PQ7609.3(COLLECTOR2) PR7643.2
N152903306: PQ7609.5(BASSE2) PR7628.2
N152920482: PC8614.1 PC8615.1 PJP8602.1 PR8612.2 PU8600.20(VTT)
N152920502: PR8606.1 PR8614.2 PU8600.8(S5)
N152921519: PC8621.1 PCE8601.1(ANODE) PR8614.1 PR8615.2 PR8616.2
N152947604: PQ7610.2(BASE1) PQ7610.5(BASSE2) PQ7611.3(COLLECTOR2) PR7636.2 PR7637.1
N152947630: PQ7610.1(EMITTER1) PQ7610.4(EMITTER2) PQ7614.4(GATE) PR7636.1
N152947648: PQ7611.1(EMITTER1) PR7641.2
N152947658: PQ7611.2(BASE1) PR7639.2
N152947660: PQ7611.6(COLLECTOR1) PR7638.1 PR7639.1 PR7640.2
N152947670: PQ7611.5(BASE2) PR7640.1
N152947720: PC7610.1 PC7612.1 PL7603.2 PL7604.2 PL7606.2 PQ7613.1(SOURCE1) PQ7613.2(SOURCE2) PQ7613.3(SOURCE3) PR7629.1 PR7633.1 PR7634.1
N152947898: PC7609.1 PR7629.2
N152947961: PC7610.2 PQ7613.4(GATE) PR7634.2 PR7635.1
N152961167: PD9800.2(CATHODE) PR9814.1 PR9815.2
N152966694: PT9800.1 PU9800.13(PG)
N152966704: PR9803.1 PR9807.2 PU9800.4(C0)
N152966719: PR9802.1 PR9806.2 PU9800.3(C1)
N152966728: PC9805.1 PC9806.1 PC9807.1 PJP9800.1 PJP9801.1 PL9800.2
N152966831: PR9804.1 PR9808.2 PU9800.6(LP#)
N153167341: PR7800.2 PRT7800.1
N153167503: PR7827.2 PRT7802.1
N153167530: PC7838.1 PR7851.1
N153167553: PR7828.1 PR7830.2
N153167897: PR7850.1 PU7800.1(PSYS)
N153242757: R5100.1 U5100.6
N153309287: D3605.1(ANODE) R3612.2
N153331695: D1800.1(ANODE) R1803.2 R1804.2 R1805.1 R1806.1 R1807.1
N153332052: D1800.2(CATHODE) R1800.2 R1801.2 R1802.2
N153370228: R6006.1 U6000.N10(TEST_PG)
N153370348: R6007.1 U6000.AA22(PCIE_CALR_RX)
N153370365: R6008.1 U6000.Y22(PCIE_CALR_TX)
N153375577: C6718.1 C6719.1 C6732.1 L6702.2 U6000.L8(MPLL_PVDD)
N153377480: C6720.1 C6733.1 L6700.2 U6000.H7(SPLL_PVDD)
N153378830: C6721.1 C6734.1 L6701.2 U6000.H8(SPLL_VDDC)
N153448899: Q2901.6(DRAIN) R2903.1 R2904.1 R2905.1 R2906.1 R2907.1 R2908.1 R2909.1 R2910.1
N153451943: D2902.1(CATHODE1) R2912.1
N153451944: D2902.2(CATHODE2) R2911.1
N153459790: Q2601.1(GATE) R2600.2
N153474772: T1507.1 U0400.BA8(GPP_A19/ISH_GP1)
N153474794: T1508.1 U0400.BB7(GPP_A20/ISH_GP2)
N153501862: R5800.1 U5801.4(EN/EN#)
N153576006: LED5000.3 R5000.1
N153576010: LED5000.1 R5001.1
N153576018: Q5000.2(GATE) Q5000.5(GATE) R5004.2
N153635028: C5800.1 U5800.33(VCCD)
N153741862: T1105.1 U0400.AW11(GPP_A8/CLKRUN#)
N153741882: T1106.1 U0400.AW13(GPP_A0/RCIN#)
N153936087: CON5102.4 R5100.2
N153936404: U5100.2 U5100.3
N154179123: C6305.1 R6300.1 R6302.2 U6000.L10(DRAM_RST)
N154179127: C6300.1 R6301.2 R6302.1
N154179258: R6303.2 U6000.K25(MEM_CALRP0)
N154184479: PC9409.1 PR9417.2
N154195714: PR9423.2 PU9400.24(ISENN_NB) PU9400.25(ISENP_NB)
N154204989: PC9604.1 PJP9600.1 PL9600.1 PQ9600.5(SW1) PQ9600.6(SW2) PQ9600.7(SW3)
N154205542: PC9625.1 PJP9602.1 PL9601.1 PQ9601.5(SW1) PQ9601.6(SW2) PQ9601.7(SW3)
N154207336: PC9403.2 PR9408.1 PU9400.28(VIN)
N154222504: C3604.2 Q3600.1(GATE) R3606.1
N154254785: PC9407.1 PR9410.2
N154814546: R3914.1 U3901.3(GPX/GPIO2)
N154880295: R6939.2 U6000.AC22(XO_IN)
N154880298: R6940.2 U6000.AB22(XO_IN2)
N155049432: PQ7612.2(GATE) PR7644.2
N155063423: Q2403.1(GATE) Q2406.1(GATE) R2416.1 R2425.1
N155063559: Q2403.3(DRAIN) R2415.1
N155160901: D3000.3(CATHODE) R3005.1 U3000.3(EN)
N155161413: R3003.1 U3000.4(DSG)
N155370962: PR9004.2 PR9005.1 PU9001.5(EN2)
N155800180: T1005.1 U0400.F43(CLKOUT_ITPXDP_N)
N155800183: T1006.1 U0400.E43(CLKOUT_ITPXDP_P)
N155975447: Q3701.2(GATE) Q3701.5(GATE) R3714.2
N156027460: T2310.1 U2300.21(GPIO021/CMP_VIN1)
N156094743: Q5801.1(GATE) R5824.2
N156159587: C6304.2 R6309.1
N156159590: C6303.2 R6308.1
N156222059: T1512.1 U0400.U3(GPP_D15/ISH_UART0_RTS#)
N156222073: T1513.1 U0400.U4(GPP_D16/ISH_UART0_CTS#/SML0BALE)
N157340852: R5903.2 U5900.5(FRS)
N157340858: C5912.1 R5904.1 U5900.11(IMON)
N157340892: C5905.1 U5900.7(VREG)
N157340898: R5906.1 U5900.13(ILIM)
N157340900: C5906.1 U5900.12(DV/DT)
N157341108: R5902.2 U5900.4(EN)
N157462563: R3715.2 U3700.6(ALERT#)

Pads without a net: CON2000 87 88 91 92 95 97 100 101 104 105 162 165; CON2100 87 88 91 92 95 97 100 101 104 105 162 165; CON2600 13 14; CON3000 3 27; CON3100 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 56 58 67 68; CON5101 3; CON5102 2 3; CON5104 13 14 15 16 17 18 19 20; J5300 2; J5301 4; NOREF#6 1; NOREF#16 1; NOREF#21 1; NOREF#28 1; NOREF#31 1; NOREF#32 1; PQ7601 1 2 6; PU7600 5; PU7700 13; PU8700 5 7 8; PU8800 7; PU8801 7; PU9400 16 23 26 27 30 31 32 33; PU9500 5; PU9501 7; U0400 A3 A4 A7 A11 A13 A26 A27 A29 A31 A33 A36 A38 A45 A47 A52 A69 AB7 AB11 AB12 AB13 AB62 AC63 AD6 AD7 AD11 AD12 AE62 AE63 AF8 AF9 AF11 AF12 AF13 AG62 AH7 AH8 AH9 AH10 AH11 AH12 AJ62 AK12 AK13 AK32 AK52 AK53 AK55 AK56 AK58 AK60 AK62 AK70 AL25 AL27 AL53 AL56 AL60 AL61 AL63 AM22 AM23 AM53 AM56 AM58 AN7 AN55 AP5 AP13 AP53 AT5 AT10 AT15 AU5 AU7 AU11 AU56 AU58 AU63 AW1 AW7 AW15 AW17 AW48 AW56 AW68 AW69 AW70 AW71 AY1 AY2 AY3 AY4 AY5 AY7 AY9 AY56 AY68 AY71 B2 B3 B11 B13 B26 B27 B29 B31 B33 B36 B38 B45 B47 B69 B70 BA3 BA4 BA7 BA9 BA68 BA70 BB2 BB3 BB4 BB5 BB9 BB11 BB57 BB66 BB68 BB69 C2 C4 C11 C12 C21 C27 C28 C29 C31 C32 C33 C36 C37 C38 C40 C54 C70 C71 D1 D3 D4 D5 D7 D12 D21 D27 D28 D29 D31 D32 D33 D36 D37 D38 D40 D54 D71 E1 E2 E38 E40 E61 F6 F21 F46 F50 F52 F60 F61 F65 G1 G2 G3 G21 G46 G50 G61 G65 H2 H3 H5 H6 H11 H63 J5 J6 J68 J71 K32 K45 K46 K52 N1 N2 N7 N9 N11 N12 P2 P62 U8 U9 U11 U12 V2 V62 W7 W10 W11 W12; U0500 1; U1204 1; U2500 A1 A2 A7 A8 A9 A10 A11 A12 A13 A14 B1 B7 B8 B9 B10 B11 B12 B13 B14 C1 C3 C5 C7 C8 C9 C10 C11 C12 C13 C14 D1 D2 D3 D4 D12 D13 D14 E1 E2 E3 E5 E8 E9 E10 E12 E13 E14 F1 F2 F3 F10 F12 F13 F14 G1 G2 G3 G10 G12 G13 G14 H1 H2 H3 H12 H13 H14 J1 J2 J3 J12 J13 J14 K1 K2 K3 K6 K7 K10 K12 K13 K14 L1 L2 L3 L12 L13 L14 M1 M2 M3 M7 M8 M9 M10 M11 M12 M13 M14 N1 N3 N6 N7 N8 N9 N10 N11 N12 N13 N14 P1 P2 P7 P8 P9 P10 P11 P12 P13 P14; U3100 3; U3702 3; U3800 1 6 7 8 9 10 11 12 13; U3901 2 5 6 7 10 11 12 13 15 25 26 28 30 31; U5702 6 7 19 20; U5800 3 4 6 21 22 23 24 30 34 35 37 38 39 40; U5801 3; U6000 A32 AA5 AA6 AA29 AA31 AB23 AB25 AB26 AB27 AB30 AC1 AC3 AC5 AC6 AC16 AC23 AC25 AD2 AD4 AD10 AD11 AD13 AD16 AD22 AD23 AD24 AE1 AE3 AE5 AE6 AE10 AE11 AE13 AE16 AE22 AE23 AE24 AE25 AE26 AF2 AF4 AF6 AF7 AF8 AF9 AF10 AF11 AF13 AF16 AF17 AF19 AF20 AF22 AF23 AF24 AF25 AG1 AG3 AG5 AG6 AG7 AG8 AG9 AG10 AG11 AG13 AG14 AG15 AG16 AG17 AG18 AG19 AG20 AG21 AG22 AG23 AG24 AG25 AG26 AH1 AH3 AH5 AH6 AH8 AH12 AH14 AH16 AH18 AH20 AH22 AH24 AH26 AJ7 AJ9 AJ13 AJ15 AJ17 AJ19 AJ21 AJ23 AJ25 AK1 AK3 AK5 AK6 AK8 AK14 AK16 AK18 AK20 AK22 AK24 AK26 AL7 AL9 AL13 AL15 AL17 AL19 AL21 AL23 AL25 AM1 AM3 AM5 AM6 AM8 AM12 AM14 AM16 AM18 AM20 AM22 AM24 AM32 J8 J25 K30 L16 L17 L29 L31 M27 M28 M30 N26 N29 N31 P23 P24 P26 P27 P28 P30 R29 R31 T7 T23 T24 T26 T27 T28 T30 U5 U6 U12 U23 U24 U26 U29 U31 V2 V4 V6 V12 V27 V28 V30 W1 W3 W5 W6 W7 W8 W23 W24 W29 W31 Y2 Y4 Y6 Y12 Y23 Y24 Y26 Y27 Y28 Y30; U6800 A5 A10 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5 U10; U6801 A5 A10 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5 U10; U6802 A5 A10 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5 U10; U6803 A5 A10 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5 U10; U7000 1 3 12 14

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 4203 vias
v2: diameter 0.559, hole 0.279, TOP to BOTTOM, 1197 vias
v3: diameter 0.457, hole 0.254, TOP to BOTTOM, 906 vias
v4: diameter 0.762, hole 0.457, TOP to BOTTOM, 586 vias
v5: diameter 0.66, hole 0.254, TOP to BOTTOM, 56 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.0VO_+1P8VSB_EN: length 135.5
  TOP w0.102: v1(172.57,41.02) 172.69,40.9 PT8704.1
  IN1 w0.254: v1(175.74,39.92) 175.74,40.39 175.11,41.02 v1(172.57,41.02)
  IN2 w0.254: v1(165.71,60.12) 164.85,60.99 164.85,66.89 161.45,70.28 159.92,70.28 156.29,73.92 154.27,73.92 151.98,76.2 149.48,76.2 148.46,77.22 148.46,78.62 147.4,79.68 146.66,79.68 145.54,80.8 145.54,82.53 143.26,84.81 143.26,86.55 139.77,90.04 135.87,90.04 134.01,91.9 134.01,92.13 133.65,92.48 132.95,92.48 132.69,92.74 132.66,92.74 132.41,92.99 131.06,92.99 130.02,94.03 v1(130.02,94.8)
  IN3 w0.254: v1(113.79,109.91) 114.07,109.63 114.07,108.44 114.76,107.75 115.95,107.75 116.44,107.27 121.41,107.27 122.05,106.63 122.07,106.63 122.71,106 122.71,105.95 122.89,105.77 122.89,103.89 123.57,103.2 126.39,103.2 126.75,102.85 126.75,102.82 130.02,99.55 v1(130.02,94.8) ; v1(175.74,39.92) 175.74,40.52 174.36,41.9 174.36,43.8 176.07,45.52 176.07,45.85 177.55,47.32 177.55,48.06 177.88,48.39 178.14,48.39 179.27,49.52 179.27,52.3 178.71,52.86 178.71,55.09 177.85,55.96 169.88,55.96 v1(165.71,60.12)
  BOTTOM w0.254: PU8700.15 175.88,38.42 175.72,38.59 PC8713.1 176.31,39.6 PR8712.2 v1(175.74,39.92) ; PR8701.2 PR8702.2 172.64,40.95 v1(172.57,41.02) ; v1(113.79,109.91) 113.79,113.72 113.01,114.51 110.16,114.51 109.96,114.3 PR8811.1
1.0VO_FB: length 13.6
  TOP w0.254: v1(174.9,38.5) v2(175.54,38.5)
  IN1 w0.254: v1(177.32,31.4) 177.04,31.68 176.69,31.68 175.62,32.74 174.63,32.74 173.91,33.46 173.91,36.55 174.9,37.54 v1(174.9,38.5)
  BOTTOM w0.254: v1(174.9,38.5) 174.88,38.47 PU8700.13 ; v1(177.32,31.4) 177.19,31.27 PR8707.2 176.81,30.74 176.73,30.66 PR8708.1 175.95,30.66 175.87,30.74 PR8709.2
1.0VO_FB_R: length 36
  IN1 w0.254: v1(163.86,49.25) 167.08,49.25 168.17,48.16 171.81,48.16 172.95,47.02 173.18,47.02 174.27,45.93 174.27,45.01 173.91,44.66 173.25,44.66 172.89,44.3 172.42,44.3 171.53,43.41 171.53,40.8 173.35,38.98 175.12,38.98 175.39,38.71 175.39,37.52 174.27,36.4 174.27,33.61 174.78,33.1 175.77,33.1 176.83,32.03 177.37,32.03 177.95,31.44 v1(177.95,31.4)
  BOTTOM w0.203: v1(163.86,49.25) 163.91,49.2 PJP8700.1
  BOTTOM w0.229: v1(177.95,31.4) 178.05,31.3 PR8707.1
  BOTTOM w0.254: v2(178,29.77) 178.05,29.82 PR8707.1
1.0VO_LX: length 3.1
  TOP w0.508: PT8700.1 171.53,38.48 v1(171.53,37.16)
  BOTTOM w0.432: 172.62,30.58 172.06,30.03 PR8710.1
1.8VO_VGA_EN: length 8.5
  TOP w0.102: v1(164.82,68.25) 164.49,68.25 163.04,66.8 163.04,65.79 PC9507.1 163.19,65.22 163.19,65.21 PR9503.2 163.5,64.9 163.5,64.25 162.95,63.71 162.53,63.71 162.23,64.01 v2(161.67,64.01)
  BOTTOM w0.102: PU9500.7 164.36,68.1 164.52,68.25 v1(164.82,68.25)
1.8VO_VGA_FB: length 5.4
  BOTTOM w0.254: PR9502.1 PR9504.1 PC9508.1 166.68,64.62 165.41,64.62 v2(165.12,64.91) 164.86,65.17 PU9500.1
1.8VO_VGA_FB_R: length 14.3
  IN3 w0.203: v1(160.43,72.14) 162.66,69.9 165.68,69.9 167.74,67.85 v1(168.33,67.85)
  BOTTOM w0.203: v1(160.43,72.14) 160.48,72.09 PJP9502.2
  BOTTOM w0.254: PC9508.2 PR9504.2 168.66,66.14 168.99,66.47 v2(168.99,66.88) 168.99,67.19 v1(168.33,67.85)
1.8VO_VGA_LX: length 7.2
  TOP w0.254: PT9501.1 160.63,67.16 163.4,69.93 164.64,69.93 v1(165.1,70.39)
1.8VO_VGA_RC: length 1.9
  BOTTOM w0.508: PC9506.1 166.24,67.77 v2(166.31,67.83) 166.4,67.92 PR9501.1
1.8VO_VGA_VIN: length 1.8
  BOTTOM w0.102: v2(165.23,60.63) 164.53,61.33 164.53,62.13
1.35VO_EN: length 7
  TOP w0.102: v1(192.43,61.66) 192.43,61.77 v2(191.92,62.28) 191.85,62.36 191.85,63.63 PR9814.2 PC9809.1 191.36,64.54 191.5,64.68 191.71,64.68 v1(191.93,64.9)
  BOTTOM w0.102: PD9800.1 192.05,62.07 192.43,61.68 v1(192.43,61.66) ; PU9800.5 v1(191.93,64.9)
5VSB_EN1: length 223.7
  TOP w0.102: R2410.1 29.11,23.29 29.97,22.43 32.28,22.43 33.15,21.57 35.18,21.57 36.27,20.47 v2(37.11,20.47) 38.56,21.92 v1(38.56,22.02)
  IN2 w0.102: v1(38.56,22.02) 39.56,22.02 43.07,18.52 46.6,18.52 46.95,18.16 54.11,18.16 55.17,17.1 61.29,17.1 61.9,16.49 63.49,16.49 64.51,15.47 67.23,15.47 69.52,13.19 74.47,13.19 75.57,14.28 78.92,14.28 81.94,17.3 103.99,17.3 104.5,17.82 106.67,17.82 107.04,18.18 109.86,18.18 110.37,17.67 112.64,17.67 113.21,17.1 115.21,17.1 115.82,17.71 118.06,17.71 118.9,18.54 121.87,18.54 122.28,18.95 128.26,18.95 129.51,20.2 130.21,20.2 132.82,22.8 132.82,24.56 134.26,26.01 135.7,26.01 135.75,25.96 139.19,25.96 141.88,28.65 146.94,28.65 149.17,30.89 157.02,30.89 159.74,33.61 159.74,40.88 154.79,45.83 154.79,49.5 155.33,50.04 159.45,50.04 159.78,49.71 164.16,49.71 165.33,48.54 167.74,48.54 168.28,48.01 171.24,48.01 171.34,47.91 171.99,47.91 172.36,47.54 172.36,47.4 175.47,44.3 178.09,44.3 182.33,48.54 182.96,48.54 185.17,50.75 191.19,50.75 195.89,55.45 196.88,55.45 197.59,56.16 201.14,56.16 v1(202.24,57.25)
  BOTTOM w0.102: PU8900.20 202.76,58.41 203.07,58.09 PC8917.1 202.82,57.61 202.46,57.25 v1(202.24,57.25)
+0.95V_GPU: length 57.2
  TOP w0.457: L6701.1 156.51,108.22 156.98,107.75 160.79,107.75 163.32,110.29 v1(163.32,110.47)
  IN1 w0.254: v1(156.46,87.63) 156.46,89.26 158.45,91.24 158.45,92.15 159.82,93.53 160.86,93.53
  IN1 w0.508: 164.9,105.34 168.71,109.15 175.74,109.15 178.11,111.51 180.62,111.51 183.77,108.36 185.8,108.36 186.28,108.84 188.52,108.84 189.89,107.47 195.17,107.47 v1(196.16,108.46)
  BOTTOM w0.305: U6000.AD14 156.46,87.38 v1(156.46,87.63)
  BOTTOM w0.432: R7201.2 196.19,108.49 v1(196.16,108.46)
  BOTTOM w0.457: R6007.2 161.9,104.93 ; R6008.2 162.84,104.83
  vias: v1(161.6,105.16) v1(161.65,94.11) v1(162.2,105.16) v1(162.81,105.16) v1(163.42,105.16) v1(165.25,93.83) v1(166.4,95.1) v1(166.42,94.47) v1(166.42,93.83) v2(164.41,96.07)
+0.95V_GPU_DISCH_A: length 7
  BOTTOM w0.254: Q7201.3 201.8,112.16 201.14,111.51 201.14,110.98 v2(200.58,110.42) 199.9,109.73 R7201.1
+0.95VO_VGA_PWRGD: length 64.9
  TOP w0.432: 165.81,110.04 PR9505.2 165.07,110.98 164.62,111.43 163.17,111.43 162.72,110.98 162.72,110.47 160.56,108.3 157.2,108.3 155.72,109.78 148.09,109.78 145.38,107.06 134.39,107.06 132.13,104.8 v1(131.5,104.8)
  TOP w0.508: 165.81,110.04 166.09,109.76 PT9508.1 167.92,109.76 168.63,109.04 169.75,109.04 170.1,109.4 v1(170.1,109.76)
  IN3 w0.508: v1(114.55,108.64) 116.51,108.64 116.59,108.56 120.98,108.56 122.81,106.73 129.57,106.73 v1(131.5,104.8)
  BOTTOM w0.279: v1(170.1,109.76) 169.96,109.9 PU9501.4
  BOTTOM w0.432: PR9456.1 114.61,108.69 v1(114.55,108.64)
+1.0VO: length 33
  TOP w0.254: v1(174.88,34.16) 174.88,32.08 171.91,29.11 169.85,29.11 169.55,28.81 161.21,28.81 160.33,29.69 v2(160.33,30.81) 160.33,31.13 163.07,33.88 v1(163.07,36.88)
  BOTTOM w0.254: PU8700.6 174.88,34.17 v1(174.88,34.16)
  BOTTOM w0.432: PC8704.1 173.71,30.07 173.44,30.34 173.44,31.31 PC8701.1
  BOTTOM w0.508: PC8701.1 174.27,32.62 174.07,32.82 PC8710.1 174.07,33.35 v1(174.88,34.16)
+1.8VALW_EC: length 9.7
  TOP w0.203: U2300.54 24.98,33.9 24.87,33.78
  TOP w0.381: 24.87,33.78 C2309.1 25.3,32.79 v1(25.43,32.79)
  TOP w0.432: v1(22.99,35.64) 23.47,35.64 R2336.2 23.69,35.4 R2331.1
  IN1 w0.381: v1(22.99,35.64) 23.9,35.64 24.69,34.85 24.69,33.49 25.39,32.79 v1(25.43,32.79)
+1.8VO_VGA: length 6.5
  TOP w0.508: PT9504.1 157.68,66.42 158.04,66.42 PT9502.1 159.06,67.44 159.44,67.44 PT9503.1 161.21,69.22 v1(161.21,69.5)
  BOTTOM w0.508: v1(161.21,69.5) PL9500.2
+1.8VO_VGA_PWRGD: length 140.5
  TOP w0.089: PR9508.1 163.07,111.84 162.36,111.13 162.36,110.62 160.41,108.66 157.35,108.66 155.87,110.14 147.94,110.14 145.23,107.43 133.94,107.43 v1(131.95,105.44)
  TOP w0.102: v1(164.36,65.18) 164.11,64.93 164.11,64.32 PR9500.2 164.82,63.6 PT9500.1
  IN2 w0.102: v1(114.07,107.72) 116.31,107.72 118.19,105.84 118.19,102.82 119.2,101.81 119.2,93.72 121.4,91.52 125.35,91.52 126.52,92.69 132.27,92.69 132.95,92 v1(133.45,92) 134.16,91.29 134.19,91.29 135.75,89.73 139.65,89.73 142.95,86.43 142.95,84.66 145.24,82.37 145.24,80.67 146.53,79.38 147.27,79.38 148.16,78.49 148.16,77.09 149.81,75.44 151.32,75.44 153.45,73.31 156.46,73.31 159.87,69.9 161.4,69.9 164.36,66.94 v1(164.36,65.18)
  IN3 w0.089: v1(131.95,105.44) 131.95,104.57 133.45,103.08 v1(133.45,92)
  BOTTOM w0.102: PR9421.1 114.2,107.85 v1(114.07,107.72) ; v1(164.36,65.18) PU9500.2
+1.8VS_VGA: length 275.9
  TOP w0.254: R6200.1 155.88,94.49 155.25,94.49 R6203.1 154.28,94.29 v1(153.82,94.29) 152.4,94.29 151.94,93.83 151.67,93.83 150.88,93.04 150.88,92.25 151.28,91.85 R6207.1 R6205.1 150.93,90.5 150.85,90.58 L6700.1
  TOP w0.381: L6702.1 169.31,82.33 170.64,81 170.64,79.81 170.84,79.61 170.84,73.87 v1(171.35,73.36)
  TOP w0.508: v1(158.07,68.42) 158.9,68.42 159.89,69.42 159.89,70.21 v1(162.56,72.88) 164.36,72.88 166.22,71.02 166.22,69.12 166.7,68.63 169.09,68.63 170.87,70.41 173.3,70.41 174.24,69.47 174.24,68.46 v1(174.69,68.01) ; v1(205.99,100.89) 205.99,100.41 203.86,98.28 203.86,72.8 202.21,71.15 197.43,71.15 195.78,69.5 v1(195.5,69.5) ; v1(132.85,93.27) 129.14,93.27 128.09,92.22 128.09,90.98 127.19,90.08 118.23,90.08 116.78,91.53 116.78,94.32 114.5,96.6 v2(113.11,96.6) 109.91,96.6 109.6,96.29 107.92,96.29 v1(107.85,96.22)
  TOP w0.762: v4(148.06,80.34) 148.06,81.81 150.77,84.52 153.18,84.52 154.89,86.24 154.89,86.62 155.52,87.25
  IN1 w0.254: v1(157.86,92.46) 157.48,92.84 155.27,92.84 v1(153.82,94.29)
  IN1 w0.432: v1(107.85,96.22) 107.93,96.3 107.93,103.12 v1(106.48,104.57)
  IN1 w0.508: v1(171.35,73.36) 163.04,73.36 v1(162.56,72.88) ; v1(132.85,93.27) 135.63,96.05 141.56,96.05 143.36,97.85 149.2,97.85 v1(149.9,98.54)
  IN2 w0.508: v1(132.85,93.27) 134.01,93.27 134.52,92.76 134.52,92.12 136.09,90.55 139.98,90.55 144.78,85.75 144.78,85.02 146.08,83.72 146.08,81.69 146.66,81.1 147.29,81.1 v4(148.06,80.34) 150.29,78.11 152.32,78.11 154.3,76.13 157.66,76.13 159.33,74.45 160.2,74.45 161.77,72.88 v1(162.56,72.88) ; v1(174.69,68.01) 175.09,67.61 179.74,67.61 180.99,66.35 180.99,64.31 182.03,63.28 188.62,63.28 189.54,62.36 190.83,62.36 191.29,62.82 191.29,66.8 192.71,68.23 194.23,68.23 v1(195.5,69.5) ; v1(208.74,110.77) 208.74,102.64 206.98,100.89 v1(205.99,100.89)
  BOTTOM w0.305: v1(149.9,98.54) 151.04,98.54 151.32,98.82 U6000.AM30 ; v1(156.31,90.07) 156.83,89.55 U6000.AD17 ; v1(155.68,87.61) 155.68,87.46 U6000.AF14
  BOTTOM w0.432: PC9402.1 104.93,95.68 106.3,95.68 106.48,95.51 107.16,95.51 107.85,96.2 v1(107.85,96.22) 107.96,96.33 PR9416.1 ; R6911.1 163.64,73.4 ; PR9403.1 PR9401.1 ; PR9401.1 104.49,107.77 103.56,106.84 103.56,105.85 104.75,104.65 106.4,104.65 v1(106.48,104.57) PR9402.1 ; PR9401.1 107.59,108.36 107.77,108.54 108.69,108.54 109.4,107.83 PR9409.1 ; v1(208.74,110.77) 208.73,110.77 R7202.2
  BOTTOM w0.457: v1(162.56,72.88) R6910.1 163.64,73.4
  BOTTOM w0.508: v1(158.07,68.42) 158.07,68.92 158.5,69.35 PJP9501.2
  vias: v1(157.76,91.24)
+1.8VS_VGA_DISCH_A: length 3.6
  BOTTOM w0.432: Q7202.3 207.55,109.62 207.22,109.95 R7202.1 205.48,110.77 v2(205.21,110.49)
+1VSB: length 13.4
  TOP w0.254: R1612.1 129.61,26.09 129.77,26.25 129.77,27.1 129.97,27.31 v1(132.59,27.31)
  TOP w0.508: v4(166.32,56.34) v2(166.32,57.51)
  IN2 w0.254: v1(132.59,27.31) 132.66,27.23 135.56,27.23 136.06,26.72 138.13,26.72 139.14,27.74 v4(139.14,28.35)
  vias: v4(139.37,29.19) v4(140.01,28.35) v4(140.67,28.93) v4(165.43,56.31) v4(165.84,55.4) v4(166.78,55.37) v4(167.26,56.34)
+1VSB_PWRGD: length 134.9
  TOP w0.356: v1(71.32,13.59) 71.32,13.95 v2(71.69,14.32) 72.75,15.37 72.75,16.06 72.43,16.38 72.35,16.38 v1(72.26,16.46)
  TOP w0.432: v1(66.07,7.81) 65.98,7.72 65.98,7.65 65.85,7.52 R1800.1
  IN1 w0.356: v1(71.47,11.03) 71.32,11.17 v1(71.32,13.59) 71.96,13.59 72.19,13.36 72.87,13.36 73.43,13.92 73.43,14.24 74.3,15.12 74.99,15.12 75.47,14.63 78.85,14.63 80.78,16.56 90.17,16.56 90.42,16.31 v1(90.42,15.78)
  IN1 w0.508: v1(161.9,35.84) 156.97,30.91 152.55,30.91 151.73,30.09 v1(151.73,29.81)
  IN2 w0.508: v1(151.73,29.81) 150.14,28.22 142.09,28.22 139.4,25.53 135.57,25.53 135.52,25.58 134.44,25.58 133.35,24.49 133.35,21.3 130.57,18.52 122.46,18.52 122.05,18.11 119.08,18.11 118.24,17.27 116,17.27 115.39,16.66 113.03,16.66 112.46,17.24 110.1,17.24 109.87,17.46 106.92,17.46 106.33,16.87 91.52,16.87 v1(90.42,15.78)
  IN3 w0.508: v1(174.14,38.5) 173.71,38.93 171.08,38.93 169.7,37.54 166.83,37.54 165.13,35.84 v1(161.9,35.84)
  BOTTOM w0.254: PU8700.12 174.38,38.26 v1(174.14,38.5)
  BOTTOM w0.356: v1(72.26,16.46) 72.24,16.49 72.24,17.05 72.43,17.23 U1201.1 ; v1(66.07,7.81) 69.5,7.81 71.47,9.78 v1(71.47,11.03)
+1VSUS_ORG: length 38.9
  TOP w0.381: C1605.1 116.95,43.87 116.95,43.25 116.74,43.03 v3(116.41,43.03)
  IN1 w0.508: v1(135.78,28.72) 134.47,28.72 133.91,29.29 133.91,29.76 132.99,30.68 130.1,30.68 129.26,29.85 128.5,29.85 128.35,30 126.19,30 125.5,30.69 124.59,30.69 123.34,31.93 v3(122.07,31.93)
  IN2 w0.762: 137.57,31.4 138.38,31.4 139.21,32.23 139.21,33.54 138.1,34.65 135.54,34.65 135.06,34.17 132.74,34.17 131.04,35.87 131.04,39.73 130.76,40.01 130.76,40.36 130.35,40.77 128.78,40.77
  BOTTOM w0.254: v3(121.43,41.8) 121.52,41.8 U0400.K17 ; U0400.L1 121.94,32.89 121.94,32.07 v3(122.07,31.93)
  vias: v2(135.69,30.89) v4(135.59,32.18) v4(136.35,31.78) v4(136.83,31.04)
+3V_CCG4_TYPEC: length 43.7
  TOP w0.254: v1(34.75,75.82) 34.75,75.82 R5823.1
  TOP w0.432: v1(42.06,71.91) 42.06,71.82 41.75,71.5 41.71,71.5 R5816.1
  IN1 w0.254: v1(29.74,76.27) 29.8,76.33 32.54,76.33 33.07,75.8 33.07,75.16 33.6,74.63 34.3,74.63 34.75,75.08 v1(34.75,75.82)
  IN1 w0.508: v1(26.52,71.63) 27.36,72.47 31.65,72.47 34.42,69.7 37.16,69.7 38.2,70.74 40.89,70.74 v1(42.06,71.91)
  IN2 w0.254: v1(29.74,76.27) 29.74,75.23 28.09,73.59 28.09,72.44 27.28,71.63 26.52,71.63 v1(26.52,71.63)
  IN2 w0.508: v1(26.52,71.63) 26.52,72.61 24.32,74.81 23.63,74.81 v1(22.76,75.68)
  BOTTOM w0.432: v1(22.76,75.68) 22.76,75.17 v2(22.53,74.93) 22.02,74.93 21.72,75.24 D5800.3
+3V_CCG4_TYPEC_LDO: length 8.6
  BOTTOM w0.254: D5800.2 20.24,73.27 20.24,71.11 20.45,70.91 U5802.5 21.92,70.23 C5810.1 R5819.1 23.14,71.02 v2(23.8,70.36)
+3V_CCG4_VDDD: length 14.4
  TOP w0.432: v1(46.51,80.93) 45.87,80.93
  IN3 w0.508: v1(39.03,72.11) 39.36,71.78 40.11,71.78 40.5,72.18 40.5,74.92 v1(46.51,80.93)
  BOTTOM w0.508: v1(46.51,80.93) v2(45.75,80.93)
+3VALW_EC: length 261
  TOP w0.178: v1(25.55,38.51) 25.77,38.3 U2300.43
  TOP w0.191: C2301.1 38.86,46.1 38.86,45.33 39.3,44.89 U2300.5 ; R2343.1 44.3,31.52 43.76,31.52 43.5,31.79 43.5,32.09 43.3,32.3 U2300.103 41.55,32.3 40.37,31.12 v1(38.58,31.12)
  TOP w0.203: U2300.115 43.44,37.1 43.48,37.14 44.48,37.14 C2304.1 ; v1(34.21,30.51) 34.39,30.51 35.23,29.67 35.23,29.31 35.3,29.25 U2300.82
  TOP w0.229: U2300.22 32.5,44.96 ; U2300.19 33.7,44.82 ; U2300.82 35.3,27.19 ; U2300.65 28.5,27.28
  TOP w0.254: R2334.1 23.67,44.63 23.96,44.92 v1(24.23,44.92) 24.33,45.02 C2316.1 ; v1(43.91,48.67) 43.93,48.64 R2342.1 ; C2303.1 35.46,27.03 35.3,27.19 ; v1(25.55,38.51) 25.2,38.51 24.74,38.97 C2305.1 24.09,38.55 24.09,38.47 R2347.1 ; C2304.1 45.82,37.42 45.92,37.52 46.37,37.52 R2324.1 46.72,37.16 46.72,37.12 47.17,36.68 v1(47.37,36.68) 47.42,36.68 47.9,37.16 47.98,37.16 R2301.2 ; R2314.1 46.81,35.08 v1(46.15,35.74) ; R2348.1 43.35,55.92 v1(43.36,55.93) ; 33.7,44.82 33.55,44.96 33.55,45.57 33.3,45.82 v1(32.18,45.82) 32.18,45.28 32.5,44.96
  TOP w0.356: R1917.1 75.05,18.16 74.58,18.63 72.94,18.63 v1(72.19,19.38)
  TOP w0.381: R1918.1 75.13,19.05 75.77,18.41 R1917.1 ; R3709.1 94.18,45.27 v1(94.67,44.78) ; 28.5,27.28 28.37,27.16
  TOP w0.432: R2343.1 44.77,31.05 R2312.2 C2302.1 45.69,30.05 v1(45.11,29.47) 45.97,29.47 46.48,28.96 R2351.2 ; R2412.1 33.3,49.61 33.82,49.09 v1(34.54,48.36) 33.82,47.64 33.82,47.06 33.35,46.59 C2300.1 C2306.1 32.18,46.54 v1(32.18,45.82) ; R2333.1 37.31,24.39 v1(36.88,23.95) 35.87,22.94 R2337.1 R2338.1 33.96,22.94 33.95,22.95 33.12,22.95 v1(31.93,24.13) 31.93,24.92 R2349.1 ; v1(35.85,45.88) 35.76,45.96 R2326.1 ; v1(22.94,37.19) 23.33,37.19 R2335.1 ; R2320.1 29.59,25.07 29.05,24.53 v1(29.05,24.39) ; v1(39.4,50.01) 39.39,50 R2319.1 38.73,50.98 R2318.1 ; v1(40.01,46.15) 39.75,46.41 39.75,46.43 C2301.1 ; 28.37,27.16 C2307.1
  TOP w0.508: v1(27.76,27.89) 27.36,27.49 C2307.1
  IN1 w0.381: v1(29.05,24.39) 29.74,23.7 31.72,23.7 31.93,23.9 v1(31.93,24.13)
  IN2 w0.254: v1(47.37,36.68) 47.09,36.68 v1(46.15,35.74)
  IN2 w0.508: v1(29.05,24.39) 29.05,24.39 27.36,26.09 27.36,27.49 v1(27.76,27.89) 27.76,29.82 26.52,31.07 26.52,34.9 26.11,35.31 v1(25.53,35.31) ; v1(32.18,45.82) 32.64,45.37 32.64,37.26 33.45,36.45 33.45,31.27 v1(34.21,30.51) 35.79,28.93 35.79,25.05 v1(36.88,23.95) ; v1(25.55,38.51) 25.07,38.51 24.66,38.92 24.66,40.14 24.26,40.54 24.26,44.89 v1(24.23,44.92) ; v1(39.4,50.01) 39.34,49.96 39.34,46.81 v1(40.01,46.15)
  IN3 w0.254: v1(38.58,31.12) 39.73,31.12 43.98,26.86 44.31,26.86 45.36,25.81 48.54,25.81 54.15,20.2 54.15,19.87 55.42,18.6 64,18.6 64.96,19.56 69.75,19.56 70.27,19.04 71.85,19.04 v1(72.19,19.38) 72.34,19.53 72.34,19.82 76.22,23.7 83.27,23.7 86,26.43 v1(86,27.31) ; v1(39.4,50.01) 41.28,51.89 41.75,51.89 43.36,53.51 v1(43.36,55.93)
  IN3 w0.508: v1(45.11,29.47) 46.15,30.51 v1(46.15,35.74) 45.64,35.74 44.69,36.69 44.69,40.42 44.35,40.77 44.35,43.12 44.5,43.27 44.5,48.07 v1(43.91,48.67) 43.5,48.67 42.16,50.01 v1(39.4,50.01)
  BOTTOM w0.254: v1(22.94,37.19) 23.65,37.19 v1(25.53,35.31) ; v1(94.67,44.78) 94.29,44.4 93.58,44.4 92.8,43.63 92.8,43.63 T2309.1 84.18,35 84.18,29.29 86,27.46 v1(86,27.31)
  BOTTOM w0.432: v1(34.54,48.36) 36.19,50.01 v1(39.4,50.01)
  BOTTOM w0.457: v1(40.01,46.15) 39.27,46.15 v2(38.99,45.88) v1(35.85,45.88) 32.23,45.88 v1(32.18,45.82)
  BOTTOM w0.508: v1(25.53,35.31) 26.14,35.31 26.24,35.41 26.24,37.82 v1(25.55,38.51)
+3VS_VGA: length 107.8
  TOP w0.356: v1(171.68,105.08) 170.57,106.19 161.81,106.19 161.04,105.41 161.04,102.78 159.5,101.24 159.5,99.88 161.36,98.01 161.36,97.41 160.99,97.03 160.99,95.43 v2(160.63,95.07) 160.63,94.5 158.97,92.84 158.62,92.84 158.47,92.69 158.47,90.99 158.8,90.66 v1(159,90.66)
  TOP w0.432: v1(161.49,83.21) 161.49,82.86 R6935.1 R6934.1
  TOP w0.508: v1(154.38,77.29) 154.38,76.3 151.89,73.81 R6938.1 ; v1(160.83,75.21) 160.83,76.13 160.07,76.89 160.07,81.44 R6934.1
  TOP w0.762: 155.22,84.1 153.29,82.17 149.64,82.17 148.92,81.45 v1(148.92,81.41)
  IN1 w0.508: v1(157.86,88.85) 157.86,87.71 156.64,86.49 156.64,85.14 157.23,84.56 158.37,84.56 158.7,84.23 160.48,84.23 v1(161.49,83.21)
  IN2 w0.508: v1(154.38,77.29) 154.51,77.17 159.74,77.17 160.83,76.08 v1(160.83,75.21) 161.26,74.78 163.91,74.78 v1(166.21,72.48)
  BOTTOM w0.356: U6001.5 139.56,86.93 139.57,86.95 C6016.1 140.26,87.15 140.9,87.15 141.1,86.94 U6903.5 141.1,86.36 141.36,86.11 ; 148.24,84.41 147.57,84.41 147.37,84.61 Q6900.5 Q6900.2 143.28,84.61
  BOTTOM w0.432: R6943.1 166.62,72.06 v1(166.21,72.48) 166.33,72.61 R6913.1 R6912.1 ; v1(158.98,89.66) 159.43,89.22 U6000.AA17 ; U6000.AA18 159.43,90.23 v1(159,90.66) 158.57,90.22 U6000.AB18 ; v1(157.86,88.85) 158.06,88.85 U6000.AB17 ; 141.36,86.11 142.86,84.61 143.28,84.61
  BOTTOM w0.508: 148.24,84.41 148.92,83.72 v1(148.92,81.41) ; v1(171.68,105.08) 180.37,105.08 183.52,108.23 R7005.1
+3VS_VGA__CT: length 2.9
  BOTTOM w0.203: U7000.10 186.71,109.56 186.22,110.05
  BOTTOM w0.432: v2(185.57,111.25) 185.57,110.31 185.95,110.31 186.22,110.05
+3VS_VGA_EN: length 4
  BOTTOM w0.203: U7000.5 190.12,109.56 190.13,109.55 190.45,109.55
  BOTTOM w0.432: 190.45,109.55 R7003.1 R7004.2 v2(193.24,109.55)
+3VS_VGA_OUT: length 1
  BOTTOM w0.432: R7005.2 186.21,108.23 v2(186.41,108.03)
+3VSUS_ORG: length 157
  TOP w0.432: v3(118.08,43.82) 118.26,44 C1614.1 ; 120.8,28.08 120.8,26.51 120.66,26.37 R1604.1 ; R1604.1 120.17,25.28 v1(120.04,25.15) 120.04,24.77 120.33,24.48 120.33,24.07 119.56,23.29 R1503.1 118.26,23.29 117.83,22.86 ; R1604.1 119.66,26.37 119.46,26.57 119.46,26.8 119.29,26.96 R1519.1 ; R1622.1 v3(113.01,43.11)
  TOP w0.508: 117.83,22.86 116.71,22.86 115.77,21.92 114.25,21.92 113.54,21.21 113.54,20.5 v2(112.65,19.61) 112.09,19.61 111.46,20.25 109.56,20.25 108.61,19.3 108.61,16.3 107.59,15.28 107.59,12.5 107.87,12.22 v1(107.87,9.98) ; v1(174.55,10.32) 174.55,10.57 174.22,10.9 173.28,10.9 172.47,10.09 164.47,10.09 163.83,10.72 155.3,10.72 v1(154.66,10.09)
  IN1 w0.254: v1(128.78,30.46) 127.25,31.98 124.61,31.98 123.88,32.72 121.36,32.72
  IN1 w0.508: v1(115.8,27.52) 116.61,26.71 116.61,26.09 117.34,25.36 119.82,25.36 v1(120.04,25.15)
  IN2 w0.305: v1(136.42,33.28) 136,33.28 135.59,32.87 133.77,32.87 132.32,31.42 130.48,31.42 129.51,30.46 v1(128.78,30.46)
  IN3 w0.254: v3(113.03,44.4) 113.51,44.88 117.04,44.88 118.08,43.84 v3(118.08,43.82)
  IN3 w0.508: v1(107.87,9.98) 108.51,10.62 109.3,10.62 109.93,9.98 117.96,9.98 118.8,9.15 151.18,9.15 152.73,10.7 154.05,10.7 v1(154.66,10.09)
  BOTTOM w0.254: v3(118.08,43.82) 118.05,43.82 U0400.V19 ; U0400.AK17 112.12,41.81 112.31,41.81 U0400.AJ16 112.94,41.79 v3(113.03,41.79) ; v3(113.03,44.4) 112.97,44.4 U0400.AJ21 ; R1402.1 R1403.1 133.83,42.22 134.26,42.65 R1405.1 R1404.1 135.36,42.65 135.89,42.12 135.89,38.81 136.58,38.13 136.58,33.43 v1(136.42,33.28)
  BOTTOM w0.432: v1(115.8,27.52) 115.7,27.63 R1506.1 R1514.1 R1513.1
  BOTTOM w0.508: 176.28,17.71 175.79,17.22 175.79,13.39 174.55,12.14 v1(174.55,10.32)
  vias: v1(120.45,30.46) v1(120.45,29.85) v3(120.42,31.63) v3(120.42,31.04)
