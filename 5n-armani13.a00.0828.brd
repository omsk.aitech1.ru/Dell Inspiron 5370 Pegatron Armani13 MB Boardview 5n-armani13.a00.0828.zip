# Allegro board 5n-armani13.a00.0828.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3P3VSB on BOTTOM (solid shape): 190.5,109.02 193.01,109.02 193.03,109.01 193.61,109.01 193.78,108.84 193.78,107.85 193.65,107.72 192.48,107.72 192.35,107.85 192.35,108.46 192.33,108.49 189.94,108.49 189.76,108.66 189.05,108.66 188.93,108.79 188.93,109.1 189.08,109.25 190.27,109.25
+3P3VSB on BOTTOM (solid shape): 178.97,13.64 178.97,12.83 178.59,12.45 177.65,12.45 177.52,12.32 177.52,12.14 177.44,12.07 176.63,12.07 176.53,12.17 176.53,12.77 176.63,12.87 177.58,12.87 178.05,13.34 178.21,13.34 178.41,13.54 178.41,13.67 178.46,13.72 178.89,13.72
+3P3VSB on BOTTOM (solid shape): 46.58,100.74 46.58,99.85 45.9,99.16 45.52,99.16 45.31,98.96 45.31,97.64 46.89,96.07 46.89,94.44 46.66,94.21 45.24,94.21 45.01,94.44 45.01,95.74 44.17,96.57 44.17,99.39 44.25,99.47 44.55,99.47 45.01,99.93 45.01,100.69 45.15,100.83 46.49,100.83
+3P3VSB on BOTTOM (solid shape): 186.02,13.78 186.02,12.56 185.45,11.99 183.67,11.99 183.27,12.39 182.63,12.39 182.49,12.52 181,12.52 180.71,12.82 180.68,12.84 180.42,13.11 180.42,13.59 180.52,13.69 180.87,13.69 181,13.57 181,13.21 181.08,13.13 182.4,13.13 182.52,13.26 182.55,13.26 182.74,13.45 182.74,14.01 182.83,14.1 185.7,14.1
+3P3VSB on BOTTOM (solid shape): 198.77,54.85 198.77,53.62 198.86,53.53 198.86,52.38 198.76,52.28 198.14,52.28 198,52.42 198.01,52.45 198.02,52.57 198,52.69 197.99,52.7 197.99,52.83 197.66,53.16 197.66,53.16 197.41,53.42 197.41,54.33 197.61,54.53 197.62,54.54 197.75,54.62 197.83,54.75 197.83,54.76 198.09,55.02 198.6,55.02
+3P3VSB on BOTTOM (solid shape): 67.77,18.93 67.77,18.11 67.67,18.01 67.44,18.01 67.31,18.14 67.31,18.65 67.23,18.72 67.13,18.72 67.06,18.65 67.06,18.11 67.01,18.06 66.88,18.06 66.8,18.14 66.8,18.65 66.73,18.72 66.62,18.72 66.55,18.65 66.55,18.11 66.47,18.04 66.37,18.04 66.32,18.09 66.32,18.62 66.24,18.7 66.12,18.7 66.04,18.62 66.04,18.06 65.96,17.99 65.71,17.99 65.61,18.09 65.61,18.98 65.81,19.18 67.51,19.18
+3P3VSB on BOTTOM (solid shape): 71.2,18.62 71.2,18.09 71.09,17.99 70.84,17.99 70.76,18.06 70.76,18.65 70.71,18.7 70.56,18.7 70.51,18.65 70.51,18.09 70.46,18.04 70.31,18.04 70.26,18.09 70.26,18.67 70.21,18.72 70.08,18.72 70.03,18.67 70.03,18.09 69.98,18.04 69.8,18.04 69.75,18.09 69.75,18.62 69.67,18.7 69.55,18.7 69.49,18.65 69.49,18.04 69.44,17.99 69.06,17.99 68.96,18.09 68.96,19.13 69.04,19.2 70.61,19.2
+3P3VSB on BOTTOM (solid shape): 178.25,64.57 178.25,61.91 178.26,61.9 178.26,60.45 178,60.2 176,60.2 175.62,60.48 175.23,60.2 172.57,60.2 172.16,59.79 167.21,59.79 166.52,60.48 166.52,61.14 166.93,61.55 166.93,64.05 169.27,64.05 170.77,62.89 172.65,63.12 172.67,63.13 173.44,63.81 173.87,64.75 178.08,64.75
+3P3VSB on VCC (solid shape): outline of 969 points within 28.88,3.56 219.48,114.02
+3P3VSB on IN2 (solid shape): 153.52,105.44 153.52,104.24 153.44,104.17 152.35,104.17 152.2,104.32 152.2,105.39 152.35,105.54 153.42,105.54
+3P3VSB on IN2 (solid shape): 167.49,108.61 167.49,107.77 167.26,107.55 166.34,107.55 166.22,107.67 166.22,108.66 166.34,108.79 167.31,108.79
+3P3VSB on IN3 (solid shape): 184.95,111.29 184.95,110.89 184.57,110.51 183.3,110.51 182.99,110.81 182.99,111.8 184.44,111.8
+3P3VSB on IN3 (solid shape): 153.52,105.44 153.52,104.24 153.44,104.17 152.35,104.17 152.2,104.32 152.2,105.39 152.35,105.54 153.42,105.54
+3P3VSB on IN3 (solid shape): 167.49,108.61 167.49,107.77 167.26,107.55 166.34,107.55 166.22,107.67 166.22,108.66 166.34,108.79 167.31,108.79
+3P3VSB on IN3 (solid shape): 193.45,108.15 193.45,107.75 193.07,107.37 191.26,107.37 191.06,107.57 191.06,108.69 191.29,108.92 192.68,108.92
+3P3VSB on IN3 (solid shape): outline of 313 points within 110.67,38.92 113.26,43.51
+3P3VSB_BST1_C on BOTTOM (solid shape): 195.85,58.09 195.73,57.97 195.27,57.97 195.07,58.17 195.07,60.43 195.85,60.43
+3P3VSB_BST_C on BOTTOM (solid shape): 197.67,60.26 197.69,60.25 197.97,59.83 198.47,59.86 198.61,59.72 199.23,59.72 199.25,59.71 199.25,59.53 199.22,59.51 198.52,59.51 198.47,59.45 198.2,59.19 198.2,59.19 198.17,59.16 197.84,59.16 197.61,58.93 197.05,58.93 196.82,59.16 196.82,60.25 196.88,60.3 197.67,60.3
+3P3VSB_HGR_D on BOTTOM (solid shape): 193.49,52.56 194.68,52.56 194.69,52.55 194.95,52.55 195.07,52.43 195.07,52.05 195.01,51.95 194.97,51.84 194.24,51.11 192.08,51.11 191.9,51.29 191.9,52.28 192.17,52.56 192.17,52.98 192.28,53.09 192.96,53.09
+3P3VSB_PHASE2_S on BOTTOM (solid shape): 188.19,57.58 192.51,57.58 192.66,57.43 192.66,56.85 192.51,56.7 189.45,56.7 189.13,56.38 189.13,55.82 189.25,55.69 189.33,55.6 189.42,55.52 189.65,55.3 189.82,55.3 189.84,55.27 192.63,55.27 192.68,55.22 192.68,55.04 193.35,54.38 194.95,54.38 195.1,54.23 195.1,53.13 194.95,52.97 193.56,52.97 193.04,53.49 193.04,53.84 192.76,54.12 189.35,54.12 188.58,53.36 187.95,53.36 187.58,52.99 187.58,52.1 187.4,51.92 185.04,51.92 184.86,52.1 184.86,57.89 185.09,58.12 187.66,58.12
+3P3VSB_SN_S on BOTTOM (solid shape): 193.01,61.04 193.01,60 192.81,59.79 192.81,59.44 192.68,59.31 191.08,59.31 190.93,59.46 190.93,60.07 191.11,60.25 191.54,60.25 191.74,60.45 191.74,61.17 191.85,61.27 192.79,61.27
+AC_BAT_SYS on TOP (solid shape): 77.83,103.89 77.83,102.72 77.75,102.64 76.38,102.64 76.23,102.8 76.23,103.71 76.56,104.04 77.67,104.04
+AC_BAT_SYS on TOP (solid shape): 155.07,69.73 155.07,69.71 155.16,69.4 155.35,69.14 155.37,69.13 155.37,69.08 155.35,69.06 155.07,68.42 155.37,67.78 155.37,67.44 156.21,66.6 156.21,62.12 156.11,61.7 156.21,61.28 156.21,57.82 156.21,57.76 156.21,57.57 156.21,57.51 156.21,57.45 156.21,55.7 156.21,55.7 156.17,55.5 156.21,55.31 156.21,55.3 156.21,48.7 156.01,48.14 156.21,47.57 156.21,44.96 156.85,44.33 156.85,40.85 157.23,40.47 157.23,38.9 156.69,38.36 154.38,38.36 153.93,38.81 153.93,41.84 153.32,42.45 153.32,54.17 153.43,54.49 153.32,54.8 153.32,70.46 153.55,70.69 154.1,70.69
+AC_BAT_SYS on TOP (solid shape): 122.48,113.69 122.48,107.17 123.52,106.12 123.52,103.99 123.27,103.74 122.4,102.87 119.89,102.87 119.88,102.91 119.8,103.05 119.66,103.14 119.4,103.81 118.72,104.07 118.7,104.06 118.44,104.32 118.44,107.4 118.57,107.82 118.45,108.23 118.44,108.25 118.44,108.51 118.78,108.92 118.77,109.45 118.63,110.31 117.77,110.47 117.46,110.54 117.15,110.48 116.56,110.49 116.14,110.09 114.61,110.09 114.5,110.19 114.4,110.37 114.25,110.52 114.25,113.72 114.96,114.43 121.74,114.43
+AC_BAT_SYS on TOP (solid shape): outline of 1849 points within 183.44,35.13 210.55,67.26
+AC_BAT_SYS on BOTTOM (solid shape): 121.74,105.36 121.74,100.41 121.06,100.41 120.96,100.51 120.96,101.42 120.14,102.24 120.14,105.26 120.37,105.49 121.62,105.49
+AC_BAT_SYS on BOTTOM (solid shape): 79.39,103.27 79.39,102.33 78.31,101.25 75.18,101.25 75.18,102.69 75.95,102.69 76.2,102.95 76.2,103.46 76.44,103.69 78.97,103.69
+AC_BAT_SYS on BOTTOM (solid shape): 201.02,66.37 201.02,65.08 201.02,65.08 201.02,64.82 200.61,64.42 198.45,64.42 198.27,64.59 198.27,65.25 198.25,65.28 198.02,65.51 198.02,66.42 198.11,66.51 199.15,66.51 199.21,66.58 200.82,66.58
+AC_BAT_SYS on BOTTOM (solid shape): 183.86,38.1 185.12,38.1 186.41,36.81 186.41,32.62 186.28,32.49 183.57,32.49 183.26,32.79 183.26,35.21 183.41,35.36 183.41,36.63 183.24,36.81 177.77,36.81 177.65,36.93 177.65,37.52 177.7,37.57 182.77,37.57 183.44,38.24 183.72,38.24
+AC_BAT_SYS on BOTTOM (solid shape): outline of 120 points within 151.54,27.25 164.87,73.59
+AC_BAT_SYS on IN1 (solid shape): 201.83,44.38 201.83,40.82 201.47,40.46 200.2,40.46 199.85,40.82 199.85,44.15 199.36,44.63 199.36,45.37 199.72,45.72 200.48,45.72
+AC_BAT_SYS on IN1 (solid shape): 203.05,66.86 203.05,65.28 202.57,64.8 199.57,64.8 199.2,65.17 199.2,66.87 199.42,67.08 201.02,67.08 201.45,67.52 202.39,67.52
+AC_BAT_SYS on IN1 (solid shape): outline of 256 points within 114.25,102.87 123.48,114.43
+AC_BAT_SYS on IN1 (solid shape): outline of 287 points within 166.78,109.98 174.55,114.63
+AC_BAT_SYS on IN1 (solid shape): 188.19,38.13 188.19,38 188.39,37.8 188.39,33.1 188.18,33.07 187.97,32.98 186.64,32.21 187.97,31.44 188.18,31.35 188.39,31.32 188.39,30.5 184.69,26.8 178.36,26.8 178.36,26.85 177.9,27.58 177.04,27.58 176.94,27.58 176.89,27.67 176.89,28.17 170.23,28.17 170.23,26.8 166.16,26.8 165.38,27.26 164.6,26.8 162.66,26.8 160.1,29.36 160.1,31.22 160.58,31.7 165.33,31.7 167.9,30.01 170.85,30.89 172.64,30.89 172.8,31.04 176.4,31.04 176.58,30.86 176.77,30.86 176.79,30.85 177.19,30.65 177.64,30.7 178.09,30.65 178.49,30.86 178.8,30.76 179.1,30.86 179.4,30.86 179.71,30.76 180.01,30.86 180.31,30.86 180.65,30.74 180.98,30.86 181.2,30.86 181.29,30.79 181.4,30.74 181.46,30.68 181.46,30.59 181.65,29.52 182.73,29.44 184.12,29.93 183.14,31.03 183.06,31.06 183.03,31.15 182.94,31.52 182.62,31.72 182.55,31.76 182.54,31.84 182.55,31.92 182.55,32.01 182.55,32.03 183.29,32.77 183.29,38.1 183.47,38.29 183.5,38.29 183.77,38.29 184.03,38.38 187.93,38.38
+AC_BAT_SYS on VCC (solid shape): outline of 83 points within 114.2,64.59 205.28,114.51
+AC_BAT_SYS on IN2 (solid shape): 185.6,37.59 185.6,36.6 186.11,36.1 186.11,34.6 185.62,34.11 177.51,34.11 177.09,34.24 176.67,34.11 175.87,34.11 175.87,34.16 175.78,34.41 175.55,34.53 174.37,34.73 174.45,33.53 174.45,30.46 172.16,28.17 170.23,28.17 170.23,27.71 162.51,27.71 161.16,29.06 161.16,31.17 162.08,32.08 164.54,32.08 165.76,30.86 166.04,30.86 166.05,30.85 170.88,30.91 171.43,35.71 171.4,35.74 173.38,37.72 176.38,37.72 176.94,38.28 184.91,38.28
+AC_BAT_SYS on IN3 (solid shape): 181.9,38.27 184.94,38.27 184.94,38.25 185.6,37.59 185.6,36.6 186.11,36.1 186.11,34.6 185.62,34.11 177.51,34.11 177.09,34.24 176.67,34.11 175.99,34.11 175.99,34.12 175.87,34.12 175.87,34.17 175.77,34.41 175.55,34.53 174.37,34.73 174.45,33.53 174.45,30.43 172.19,28.17 170.23,28.17 170.23,27.79 162.41,27.79 161.16,29.03 161.16,31.17 162.08,32.08 164.54,32.08 165.79,30.84 166.07,30.84 166.08,30.83 166.62,30.45 167.22,30.18 171.31,31.37 171.48,35.62 171.47,35.64 171.47,35.82 173.43,37.77 173.89,37.77 174.14,37.73 174.38,37.77 174.38,37.77 174.66,37.77 174.9,37.73 175.14,37.77 175.15,37.77 176.33,37.77 176.84,38.28 181.89,38.28
+BL_PWR on TOP (solid shape): 57.2,101.68 57.51,101.25 57.95,101.53 58.37,101.5 58.56,101.88 59.06,101.88 59.06,100.66 58.97,100.57 58.64,100.57 58.37,100.64 58.12,100.51 56.49,100.51 56.11,100.89 56.11,101.83 56.16,101.88 57,101.88
+BL_PWR_O on TOP (solid shape): 61.52,103.41 61.52,100.64 60.93,100.05 60.38,100.05 60,100.43 60,101.55 60.6,101.55 60.6,101.52 60.61,101.47 60.63,101.42 60.65,101.36 60.68,101.32 60.72,101.28 60.76,101.24 60.81,101.21 60.86,101.19 60.92,101.18 60.97,101.17 61.03,101.17 61.08,101.18 61.14,101.2 61.18,101.23 61.23,101.26 61.27,101.3 61.3,101.34 61.33,101.39 61.35,101.44 61.36,101.5 61.37,101.55 61.36,101.61 61.35,101.66 61.33,101.71 61.3,101.76 61.27,101.81 61.23,101.85 61.18,101.88 61.14,101.9 61.08,101.92 61.03,101.93 60.97,101.93 60.92,101.93 60.86,101.91 60.81,101.89 60.76,101.86 60.72,101.83 60.68,101.79 60.65,101.74 60.63,101.69 60.61,101.63 60.6,101.58 60.6,101.55 60,101.55 60,102.61 60.43,103.04 60.43,103.63 60.53,103.74 61.19,103.74
+BL_PWR_O on BOTTOM (solid shape): outline of 89 points within 74.9,103.33 78.16,107.37
+DCIN_IN on TOP (solid shape): 72.58,106.52 71.69,106.52 71.69,108.19 72.58,108.19
+DCIN_IN on TOP (solid shape): 45.34,110.31 45.34,108.23 45.12,108.02 40.86,108.02 40.78,108.09 40.78,109.13 40.59,109.32 38.99,109.32 38.86,109.45 38.86,110.42 39.22,110.77 44.88,110.77
+DCIN_IN on BOTTOM (solid shape): 190.34,33.75 190.87,33.75 191.06,33.56 191.06,31.45 190.88,31.27 188.49,31.27 187.93,30.71 184.53,30.71 184.33,30.91 184.33,31.85 184.42,31.94 187.13,31.94 187.2,32.01 187.2,33.63 187.33,33.76 190.32,33.76
+DCIN_IN on IN2 (solid shape): 46.13,110.31 46.13,108.97 45.54,108.38 39.01,108.38 38.66,108.74 38.66,110.54 38.91,110.8 45.64,110.8
+DCIN_IN on IN2 (solid shape): 191.97,33.35 191.97,31.73 191.52,31.27 187.78,31.27 187.27,31.78 187.27,33.35 187.66,33.73 191.59,33.73
+DCIN_IN on IN2 (solid shape): 70.18,109.9 70.48,109.79 70.8,109.81 70.9,109.83 70.99,109.86 71.23,109.84 71.46,109.9 71.46,109.9 71.58,109.78 71.58,107.93 71.48,107.83 68.48,107.83 68.38,107.93 68.38,109.51 68.42,109.51 68.72,109.65 68.94,109.9
+DCIN_IN on IN2 (solid shape): outline of 273 points within 167.49,109.83 173.51,114.63
+DCIN_IN on IN3 (solid shape): 46.13,110.31 46.13,108.97 45.54,108.38 39.01,108.38 38.66,108.74 38.66,110.54 38.91,110.8 45.64,110.8
+DCIN_IN on IN3 (solid shape): 191.97,33.35 191.97,31.73 191.96,31.71 190.74,31.71 190.3,31.27 187.78,31.27 187.27,31.78 187.27,33.35 187.66,33.73 191.59,33.73
+DCIN_IN on IN3 (solid shape): 70.18,109.9 70.48,109.79 70.8,109.81 70.93,109.84 71.06,109.89 71.17,109.88 71.29,109.9 71.46,109.9 71.58,109.78 71.58,107.93 71.48,107.83 68.5,107.83 68.38,107.95 68.38,109.51 68.42,109.51 68.72,109.65 68.94,109.9
+DCIN_IN on IN3 (solid shape): outline of 273 points within 167.49,109.83 173.51,114.63
+FBVDDQ on TOP (solid shape): 167.23,91.44 167.23,90.32 167.39,90.17 167.39,86.87 167.54,86.72 167.54,86.68 167.47,86.54 167.46,86.39 167.46,86.37 167.39,86.29 167.39,85.02 167.18,84.81 167.2,84.78 167.11,84.69 166.42,84.69 166.27,84.84 166.27,86.11 166.47,86.31 166.78,86.31 166.98,86.51 166.98,87.48 167.08,87.58 167.08,87.65 167.13,87.7 167.13,88.08 167.08,88.13 167.08,88.55 166.93,88.7 166.93,89.79 166.52,90.2 166.52,91.75 166.56,91.79 166.89,91.79
+FBVDDQ on TOP (solid shape): outline of 93 points within 171.07,97.26 173.81,99.37
+FBVDDQ on TOP (solid shape): 190.56,74.97 190.64,74.94 190.72,74.86 190.72,74.71 191.35,74.08 191.35,73.14 190.73,72.52 189.71,72.52 189.63,72.56 189.61,72.64 189.61,72.71 189.6,72.78 189.63,72.87 189.72,72.9 189.95,72.95 190.07,73.15 190.11,73.21 190.17,73.24 190.21,73.24 190.26,73.19 190.26,73.17 190.77,72.97 190.63,73.5 190.61,73.5 190.56,73.55 190.57,73.61 190.68,73.71 190.69,73.72 190.87,74 190.69,74.28 190.68,74.28 190.3,74.66 190.27,74.76 190.34,74.83 190.42,74.87 190.49,74.94
+FBVDDQ on TOP (solid shape): 169.42,96.7 169.42,96.49 169.38,96.41 169.3,96.39 168.91,96.2 168.94,95.77 168.95,95.76 168.97,95.72 168.76,95.51 168.76,93.98 168.64,93.87 168.61,93.89 168.22,93.87 168.05,93.53 168.02,93.46 167.95,93.42 167.54,93.42 167.21,93.75 167.21,94.41 167.24,94.42 167.41,94.55 167.49,94.75 167.52,94.81 167.59,94.84 167.65,94.84 167.77,94.85 167.89,94.95 167.95,95.03 168,95.07 168,95.22 168,95.28 168,95.94 168,96.01 168,96.07 168,96.27 168.01,96.28 168.07,96.28 168.07,96.34 168.2,96.47 168.23,96.46 168.61,96.48 168.78,96.82 168.81,96.9 168.88,96.93 169.19,96.93
+FBVDDQ on TOP (solid shape): 196.56,98.58 196.6,98.58 196.64,98.57 196.66,98.53 196.75,98.35 196.94,98.27 196.98,98.26 196.99,98.2 196.86,98.07 196.85,98.07 196.72,97.98 196.66,97.84 196.62,97.78 196.55,97.75 196.26,97.64 196.16,97.34 196.15,97.3 195.92,97.17 195.85,96.94 195.83,96.86 195.75,96.83 194.85,96.83 194.85,96.89 194.86,96.94 194.88,96.97 194.91,96.98 195.21,97.09 195.32,97.38 195.35,97.44 195.41,97.48 195.57,97.56 195.66,97.71 195.69,97.77 195.76,97.79 196.06,97.91 196.16,98.22 196.17,98.26 196.2,98.28 196.38,98.37 196.46,98.54 196.48,98.57 196.52,98.58
+FBVDDQ on TOP (solid shape): 187.76,93.76 187.8,93.76 187.84,93.75 187.86,93.72 187.94,93.57 188.08,93.48 188.1,93.48 188.13,93.45 188.99,93.45 189.02,93.48 189.08,93.5 189.63,93.5 189.65,93.49 189.7,93.44 189.73,93.34 189.66,93.27 189.53,93.18 189.46,93.04 189.42,92.98 189.36,92.96 189.18,92.92 189.05,92.8 188.96,92.76 188.88,92.8 188.74,92.93 188.56,92.97 188.49,92.99 188.46,93.05 188.14,93.29 187.85,93.01 187.84,92.98 187.8,92.97 187.52,92.86 187.4,92.58 187.38,92.52 187.31,92.48 187.28,92.47 187.23,92.46 186.55,92.46 186.44,92.57 186.44,92.81 186.42,92.84 186.41,92.92 186.42,93 186.44,93.03 186.44,93.5 187.23,93.5 187.24,93.5 187.5,93.51 187.66,93.72 187.68,93.75 187.71,93.76
+FBVDDQ on TOP (solid shape): 196.49,84.37 196.55,84.38 196.81,84.12 196.84,84.12 196.89,84.1 196.93,84.1 196.96,84.08 196.97,84.04 197,83.84 197.13,83.68 197.17,83.6 197.13,83.52 197.02,83.38 196.98,83.2 196.96,83.14 196.9,83.1 196.74,83 196.66,82.83 196.65,82.79 196.59,82.78 196.45,82.92 196.44,82.93 196.38,83.02 196.3,83.08 196.24,83.1 196.18,83.14 196.16,83.2 195.78,83.61 195.4,83.21 195.37,83.14 195.31,83.1 195.06,82.81 195.3,82.5 195.36,82.46 195.38,82.4 195.38,82.36 195.37,82.32 195.33,82.3 195.11,82.17 195.08,81.91 195.06,81.82 194.98,81.78 194.96,81.78 194.88,81.82 194.86,81.91 194.77,82.22 194.45,82.28 194.44,82.28 194.4,82.28 193.98,82.69 193.98,82.71 193.9,82.91 193.73,83.04 193.73,83.32 193.83,83.42 194.32,83.42 194.63,83.3 194.87,83.54 194.89,83.57 194.92,83.58 195.21,83.66 195.34,83.93 195.35,83.94 195.65,84.25 195.65,84.25 195.76,84.37 196.01,84.12 196.04,84.12 196.05,84.12 196.31,84.13 196.47,84.34
+FBVDDQ on TOP (solid shape): 190.56,82.98 190.63,82.95 190.73,82.86 190.73,82.5 190.53,82.3 190.3,82.15 190.28,81.89 190.29,81.88 190.29,81.32 190.27,81.27 190.26,81.23 190.25,81.2 190.21,81.19 189.92,81.09 189.8,80.8 189.78,80.74 189.72,80.7 189.46,80.39 189.74,80.09 189.78,80.08 189.79,80.04 189.79,80 189.77,79.94 189.71,79.9 189.54,79.8 189.46,79.62 189.45,79.58 189.41,79.57 189.38,79.57 189.31,79.59 189.27,79.65 189.19,79.81 189.03,79.9 188.97,79.94 188.95,80 188.9,80.21 188.76,80.36 188.76,80.57 188.34,80.98 186.73,80.98 186.69,81.03 186.69,81.27 186.79,81.37 188.23,81.37 188.39,81.22 188.61,81.18 188.65,81.17 188.67,81.14 189.19,80.99 188.99,81.5 188.96,81.52 188.95,81.56 188.9,81.75 188.75,81.9 188.7,81.99 188.75,82.07 188.81,82.12 188.86,82.17 188.94,82.21 189.02,82.17 189.17,82.05 189.36,82.01 189.43,81.99 189.47,81.93 189.99,81.79 189.8,82.3 189.74,82.34 189.72,82.4 189.71,82.44 189.73,82.48 189.76,82.49 189.96,82.56 190.07,82.74 190.11,82.8 190.17,82.82 190.34,82.84 190.49,82.94
+FBVDDQ on TOP (solid shape): outline of 230 points within 184.53,79.83 192.53,87.68
+FBVDDQ on TOP (solid shape): outline of 892 points within 183.19,72.52 191.82,81.17
+FBVDDQ on TOP (solid shape): outline of 1871 points within 181.71,91.2 195.09,106.04
+FBVDDQ on TOP (solid shape): outline of 3933 points within 192.02,70.41 203.25,107.7
+FBVDDQ on BOTTOM (solid shape): 175.71,72.68 175.72,72.68 175.98,72.42 180.39,72.42 180.72,72.09 180.72,70.64 180.37,70.28 174.91,70.28 172.81,72.39 172.81,73.9 173.07,74.16 174.24,74.16
+FBVDDQ on BOTTOM (solid shape): 186.08,76.31 186.08,76.17 186.44,75.81 187.53,75.81 187.56,75.75 187.54,75.73 187.54,75.56 187.43,75.45 186.29,75.45 185.66,76.08 184.68,76.08 184.61,76.15 184.61,76.65 184.66,76.7 185.7,76.7
+FBVDDQ on BOTTOM (solid shape): 186.06,74.8 186.06,74.55 186.41,74.19 187.51,74.19 187.53,74.21 187.59,74.22 187.62,74.17 187.62,74.04 187.32,73.73 185.63,73.73 185.48,73.58 184.99,73.58 184.81,73.76 184.81,74.98 184.89,75.06 185.8,75.06
+FBVDDQ on BOTTOM (solid shape): 186.54,78.22 188.26,78.22 188.33,78.15 188.68,78.15 188.68,78.09 188.67,78.06 188.65,78.02 188.61,78.01 188.33,77.94 188.18,77.69 188.12,77.6 188.01,77.63 187.9,77.74 186.71,77.74 186.56,77.89 186.56,77.91 186.18,78.29 186.16,78.4 186.26,78.46 186.3,78.46
+FBVDDQ on BOTTOM (solid shape): 187.39,97.37 187.43,97.2 187.54,97.07 187.58,96.99 187.53,96.91 187.39,96.46 187.8,96.21 187.83,96.2 187.85,96.16 187.86,96.13 187.83,96.05 187.76,96.02 187.65,96.02 187.32,95.68 187.3,95.68 187.15,95.6 187.06,95.45 187.1,95.21 187.3,95.08 187.32,95.08 187.36,95.03 187.36,95.01 187.41,94.8 187.57,94.65 187.62,94.56 187.57,94.47 187.43,94.33 187.38,94.14 187.37,94.1 187.33,94.08 187.23,94.06 186.46,94.06 186.46,95.04 185.71,95.79 185.6,95.79 185.6,96.93 185.66,97.03 185.77,97 186.17,96.92 186.42,97.24 186.42,97.26 186.58,97.42 187.39,97.42
+FBVDDQ on BOTTOM (solid shape): 188.6,93.8 188.64,93.79 188.65,93.76 188.8,93.52 189.07,93.5 189.08,93.5 189.63,93.5 189.65,93.49 189.7,93.44 189.73,93.34 189.66,93.27 189.53,93.18 189.46,93.04 189.42,92.98 189.36,92.96 189.18,92.92 189.05,92.8 188.96,92.76 188.88,92.8 188.74,92.93 188.56,92.97 188.49,92.99 188.46,93.05 188.14,93.29 187.85,93.01 187.84,92.98 187.8,92.97 187.52,92.86 187.4,92.58 187.38,92.52 187.33,92.49 187.28,92.48 187.23,92.46 186.58,92.46 186.46,92.57 186.46,93.5 187.22,93.5 187.24,93.5 187.5,93.51 187.66,93.72 187.68,93.75 187.71,93.76 187.76,93.76 187.8,93.76 187.84,93.75 187.86,93.72 188.16,93.47 188.46,93.72 188.49,93.78 188.56,93.8
+FBVDDQ on BOTTOM (solid shape): 168.56,96.27 168.58,96.24 168.63,96.19 168.68,96.15 168.68,95.88 168.54,95.7 168.56,95.47 168.77,95.32 169.03,95.38 169.14,95.4 169.2,95.31 169.2,94.79 169.16,94.78 168.95,94.65 168.87,94.41 168.87,94.36 168.92,94.21 169.01,94.1 169.01,93.95 168.91,93.85 168.67,93.85 168.58,93.9 168.48,93.93 168.37,93.93 168.27,93.9 168.02,93.72 167.99,93.41 168,93.38 167.96,93.34 167.95,93.34 167.75,93.2 167.7,92.97 167.71,92.92 167.73,92.88 167.74,92.8 167.69,92.74 167.49,92.45 167.61,92.12 167.61,91.21 167.36,90.95 167.09,90.95 166.94,91.08 166.75,91.11 166.71,91.11 166.64,91.14 166.61,91.22 166.6,91.29 166.57,91.38 166.57,91.42 166.42,91.57 166.42,91.89 166.56,92.03 166.61,92.67 166.88,92.94 166.88,93.56 167.01,93.69 167.03,93.69 167.3,93.83 167.34,94.14 167.34,94.15 167.34,94.66 167.37,94.74 167.37,94.82 167.42,94.86 167.49,94.86 167.83,94.9 168,95.21 168,95.24 168.08,95.32 168.09,95.32 168.22,95.38 168.31,95.49 168.32,95.71 168.18,95.89 168.15,95.9 168.15,96.13 168.17,96.15 168.25,96.2 168.3,96.27
+FBVDDQ on BOTTOM (solid shape): outline of 105 points within 166.2,82.31 169.46,87.45
+FBVDDQ on BOTTOM (solid shape): outline of 8059 points within 182.19,70.46 203.2,108.26
+FBVDDQ on IN1 (solid shape): 176.2,72.85 176.2,69.6 175.67,69.07 174.22,69.07 173.08,70.21 173.08,73.71 173.25,73.89 175.16,73.89
+FBVDDQ on IN1 (solid shape): outline of 1356 points within 165.81,82.96 172.39,96.34
+FBVDDQ on IN1 (solid shape): outline of 2185 points within 189,71.3 201.32,105.56
+FBVDDQ on VCC (solid shape): 184.57,109.34 184.61,109.31 184.66,109.3 190.35,109.3 192.75,106.9 192.79,106.87 192.84,106.86 200.51,106.86 202.64,104.75 202.64,70.31 202.41,70.08 195.25,70.08 194.35,70.98 194.31,71.01 194.26,71.02 172.57,71.02 172.52,71.01 172.48,70.98 172.19,70.69 169.75,70.69 169.74,70.7 169.46,70.98 169.42,71.01 169.37,71.02 168.45,71.02 168.21,71.26 168.17,71.29 168.12,71.3 167.41,71.3 167.36,71.29 167.32,71.26 167.08,71.02 165.05,71.02 156.23,79.84 156.23,80.8 161.06,80.8 161.11,80.81 161.15,80.84 163.21,82.9 163.24,82.94 163.25,82.99 163.25,83.57 167.5,87.82 167.53,87.86 167.54,87.91 167.54,90.27 168.01,90.74 168.04,90.78 168.05,90.83 168.05,91.77 168.04,91.82 168.01,91.86 166.62,93.25 166.62,93.63 166.61,93.68 166.59,93.72 163.6,96.7 163.6,97.49 163.59,97.54 163.56,97.58 163.09,98.05 163.09,100.61 165.34,102.86 165.37,102.9 165.38,102.95 165.38,105.64 169.24,109.5 174.9,109.5 174.95,109.51 174.99,109.54 177.4,111.94 181.96,111.94
+FBVDDQ_BOOT_D on BOTTOM (solid shape): 190.91,68.63 190.91,67.75 190.96,67.7 191.59,67.7 191.59,67.48 190.54,67.48 190.37,67.65 190.37,68.68 190.45,68.76 190.78,68.76
+FBVDDQ_PHASE on BOTTOM (solid shape): 190.14,68.52 190.14,67.16 190.2,67.09 190.46,67.09 190.58,67.21 192.3,67.21 192.35,67.16 192.35,67.03 192.3,66.98 190.88,66.98 189.99,66.09 189.99,65.48 189.83,65.31 186.8,65.31 186.73,65.39 186.73,68.89 189.77,68.89
+FBVDDQ_VIN on BOTTOM (solid shape): 199.14,68.91 199.14,67.59 198.95,67.4 197.65,67.4 197.48,67.58 193.85,67.58 193.73,67.46 191.9,67.46 191.88,67.48 191.88,67.71 193.4,67.71 194.8,69.1 198.95,69.1
+USB_TYPEC on TOP (solid shape): 33.58,99.72 33.58,99.21 33.73,99.06 36.39,99.06 36.44,99.03 36.43,98.98 36.42,98.97 36.42,97.11 36.32,97.01 35.71,97.01 35.56,97.16 35.56,98.1 35.31,98.35 34.16,98.35 34.04,98.22 34.04,97.61 33.6,97.18 33.6,96.83 33.33,96.55 32.26,96.55 31.95,96.85 31.95,98.68 31.97,98.69 31.97,99.46 32.39,99.88 33.43,99.88
+USB_TYPEC on BOTTOM (solid shape): 16.1,92.76 16.1,91.52 15.34,91.52 15.33,91.51 14.89,91.43 14.82,91 14.78,90.96 14.78,87.81 14.61,87.63 13.89,87.63 13.8,87.64 13.71,87.63 13.36,87.63 13.26,87.53 11.89,87.53 10.47,88.95 10.47,89.39 10.62,89.54 10.87,89.54 11.07,89.33 11.07,89.16 11.48,88.75 12.4,88.75 12.47,88.83 12.47,91.26 11.94,91.8 11.94,92.42 12.09,92.57 15.15,92.57 15.41,92.84 16.03,92.84
+USB_TYPEC on IN1 (solid shape): outline of 1215 points within 10.19,88.93 30.89,96.42
+USB_TYPEC on VCC (solid shape): 15.34,92.42 15.34,86.78 12.52,83.95 8.57,83.95 7.94,84.57 7.61,84.95 7.57,84.98 7.52,84.99 6.17,84.99 6.12,85.04 6.12,88.75 6.43,89.05 7.82,89.05 7.87,89.07 7.92,89.1 8,89.18 9.36,90.54 9.39,90.59 9.4,90.63 9.4,92.58 9.48,92.67 15.09,92.67
+USB_TYPEC on IN2 (solid shape): outline of 2037 points within 6.17,82.7 34.01,99.62
+USB_TYPEC on IN3 (solid shape): outline of 199 points within 24.56,90.73 34.04,99.55
+USB_TYPEC on IN3 (solid shape): outline of 611 points within 6.82,83.02 14.76,92.38
+VCORE on TOP (solid shape): outline of 1770 points within 111.51,42.85 146.69,64.29
+VCORE on BOTTOM (solid shape): 113.25,56.49 113.35,56.51 113.42,56.42 113.42,51.37 112.88,50.83 112.88,50.81 112.86,50.81 112.45,50.81 112.32,50.95 112.32,50.97 111.97,51.26 111.66,50.93 111.64,50.87 111.57,50.81 110.98,50.81 110.87,50.91 110.87,51.89 111.01,52.02 111.34,52.02 111.85,52.3 111.34,52.58 111.01,52.58 110.87,52.72 110.87,53.72 111.01,53.85 111.34,53.85 111.85,54.13 111.34,54.41 110.87,54.41 110.87,54.9 111.18,55.2 111.18,55.2 111.28,55.27 111.35,55.37 111.36,55.38 111.58,55.6 112.36,55.6 112.37,55.6 112.4,55.6 112.94,56.15 112.94,56.18
+VCORE on BOTTOM (solid shape): outline of 323 points within 126.82,44.12 143.69,65.08
+VCORE on BOTTOM (solid shape): outline of 382 points within 120.89,49.81 123.84,57.46
+VCORE on IN1 (solid shape): outline of 1336 points within 112.37,48.89 128.7,59.33
+VCORE on VCC (solid shape): 130.06,74.11 130.1,74.08 130.15,74.07 135.96,74.02 140.37,69.61 140.41,69.58 140.46,69.57 145.85,69.57 147.41,68 147.41,61.68 147.42,61.63 147.45,61.59 148.16,60.88 148.16,57.13 148.13,57.05 148.16,56.97 148.16,44.71 146.4,42.95 141.88,42.95 141.83,42.95 138.61,42.95 132.37,49.19 132.33,49.22 132.28,49.23 113.52,49.23 113.31,49.44 113.31,50.45 113.3,50.5 113.27,50.54 112.99,50.82 112.95,50.84 112.9,50.85 112.37,50.85 112.22,51.01 112.22,55.63 112.4,55.81 112.75,55.81 112.8,55.82 112.84,55.84 113.02,56.02 113.05,56.06 113.06,56.11 113.06,57.18 113.05,57.23 113.02,57.27 112.76,57.52 112.72,57.55 112.67,57.56 111.84,57.56 111.53,57.87 111.53,67.56 111.89,67.92 113.56,67.92 113.61,67.93 113.65,67.96 113.98,68.29 114.01,68.33 114.02,68.38 114.02,71.1 115.99,73.06 116.02,73.11 116.03,73.15 116.03,73.74 117.86,75.57 122.96,75.54 123.01,75.55 123.05,75.58 123.4,75.92 128.22,75.95
+VCORE on IN2 (solid shape): outline of 11116 points within 111.61,42.98 148.15,75.82
+VCORE on IN3 (solid shape): outline of 760 points within 111.35,49.36 125.46,57.36
+VCORE1_BT_D on BOTTOM (solid shape): 159.61,48.08 160.1,48.08 160.1,45.8 160.07,45.77 159.89,45.77 159.84,45.82 159.84,46.38 159.35,46.88 159.35,48.08 159.61,48.08
+VCORE1_HG_D on BOTTOM (solid shape): 159.59,46.28 159.59,45.8 159.56,45.77 159.18,45.77 159.18,45.75 158.9,45.47 158.57,45.47 158.46,45.58 158.46,45.81 158.45,45.82 158.45,46.15 158.7,46.41 159.46,46.41
+VCORE1_LG_D on BOTTOM (solid shape): 162.1,47.18 162.1,46.3 162.05,46.1 162.1,45.91 162.1,45.47 161.8,45.16 161.8,44.13 161.47,43.8 160.88,43.8 160.83,43.85 160.83,44.4 160.88,44.45 161.21,44.45 161.34,44.58 161.34,46.2 161.36,46.22 161.36,47.22 161.47,47.33 161.95,47.33
+VCORE1_PHASE_D on BOTTOM (solid shape): 157.48,49 157.48,48.67 157.28,48.46 157.28,48.06 157.02,47.81 156.08,47.81 155.73,48.16 154.89,48.16 154.81,48.24 154.81,48.87 154.84,48.9 155.93,48.9 156.11,49.08 157.41,49.08
+VCORE1_PHASE_D on BOTTOM (solid shape): 159.26,44.93 159.26,44.53 159.31,44.48 159.56,44.48 159.59,44.45 159.59,44 159.5,43.91 159.17,43.91 159.1,43.97 159.11,44.1 159.09,44.19 158.92,44.4 158.64,44.44 158.47,44.36 158.36,44.2 157.43,44.2 157.35,44.27 157.35,44.73 157.41,44.78 158.14,44.78 158.52,45.16 159.03,45.16
+VCORE1_R_BT_D on BOTTOM (solid shape): 158.21,48.02 158.21,45.76 158.12,45.67 157.35,45.67 157.35,46.15 157.51,46.31 157.51,48.01 157.53,48.03 158.19,48.03
+VCORE1_R_HG_D on BOTTOM (solid shape): 158.06,50.24 158.62,50.24 158.62,49.33 158.5,49.2 158.02,49.2 158.02,49.38 157.81,49.58 155.65,49.58 155.5,49.43 154.97,49.43 154.87,49.53 154.87,50.17 154.94,50.24 156.24,50.24 157,51.01 157.3,51.01
+VCORE1_R_LG_D on TOP (solid shape): 151.1,51.54 151.1,51.03 150.8,50.72 150.8,50.37 150.8,50.37 150.8,50.12 150.78,50.09 150.78,49.1 150.32,48.64 149.33,48.64 149.25,48.72 149.25,49.86 150.06,50.68 150.06,51.31 150.34,51.59 150.34,51.6 151.04,51.6
+VCORE1_R_LG_D on BOTTOM (solid shape): 151.1,51.39 151.1,51.03 151.05,50.81 151.1,50.59 151.1,50.58 151.1,50.44 150.86,50.19 150.86,49.38 149.1,49.38 149.06,49.43 149.06,50.15 149.08,50.17 149.87,50.17 150.11,50.41 150.11,51.4 150.29,51.59 150.9,51.59
+VCORE2_BT_D on BOTTOM (solid shape): 160.78,56.12 160.75,56.09 160.53,56.09 160.14,55.7 160.14,55.68 160.02,55.55 160.02,55.07 159.77,55.07 159.77,55.76 160.02,56.01 160.02,57.48 160.78,57.48
+VCORE2_LG_D on BOTTOM (solid shape): 162.81,55.07 162.81,54.63 161.44,53.25 160.8,53.25 160.8,53.72 160.82,53.73 160.84,53.83 161.08,53.83 161.08,54.52 161.47,54.92 161.49,54.92 161.85,55.27 162.61,55.27
+VCORE2_PHASE_D on BOTTOM (solid shape): 159.16,54.28 159.16,53.8 159.21,53.75 159.51,53.75 159.51,53.24 158.52,53.24 158.12,52.83 157.71,52.83 157.48,53.06 157.48,53.82 157.4,53.9 157.4,54.41 159.03,54.41
+VCORE2_PHASE_D on BOTTOM (solid shape): 155.3,62.87 156.85,62.87 156.92,62.79 156.92,62.31 157.38,61.85 157.37,61.66 157.37,61.54 157.37,61.52 157.15,61.29 156.06,61.29 155.09,62.26 154.15,62.26 154.01,62.4 154.01,63.07 155.09,63.07
+VCORE2_R_BT_D on BOTTOM (solid shape): 158.98,57.46 158.98,56.14 158.93,56.09 158.47,56.09 158.22,55.83 158.22,55.22 157.4,55.22 157.4,56.03 157.18,56.26 157.18,57.13 157.35,57.3 158.01,57.3 158.22,57.51 158.93,57.51
+VCORE2_R_HG_D on BOTTOM (solid shape): 157.2,63.73 158.7,63.73 158.85,63.58 158.85,63.15 158.7,62.99 157.1,62.99 156.87,63.22 155.19,63.22 154.84,63.58 154.03,63.58 154.03,64.26 154.08,64.32 155.73,64.32 155.93,64.52 156.41,64.52
+VCORE2_R_LG_D on TOP (solid shape): 148.26,65.2 148.26,63.78 148.62,63.43 148.62,62.82 148.49,62.69 147.23,62.69 147.08,62.84 147.08,65.09 147.35,65.36 148.11,65.36
+VCORE2_SN_C on BOTTOM (solid shape): 149.76,58.91 149.76,58.27 150.02,58.01 150.02,56.36 149.2,56.36 149.1,56.47 149.1,58.19 149.33,58.42 149.33,58.93 149.43,59.03 149.63,59.03
+VCORE/GT on TOP (solid shape): 120.73,60.3 122.2,60.3 122.48,60.02 122.48,58.91 122.33,58.75 122.3,58.75 122.17,58.63 122.15,58.63 122.15,57.81 121.87,57.53 120.96,57.53 120.68,57.81 120.68,58.8 120.65,58.83 119.18,58.83 119.02,58.98 119.02,60.38 119.18,60.53 120.5,60.53
+VCORE/GT on TOP (solid shape): 113.51,60.38 113.51,59.9 113.48,59.9 113.48,59.82 113.41,59.74 113.41,57.28 113.3,57.17 112.76,57.17 112.52,57.28 112.27,57.19 112.22,57.14 112.18,57.09 112.17,57.06 111.42,57.06 111.3,57.18 111.3,57.48 111.32,57.5 111.32,57.95 111.81,58.45 111.81,60.25 111.86,60.3 112.22,60.3 112.24,60.33 112.42,60.33 112.42,60.51 112.55,60.63 113.26,60.63
+VCORE/GT on BOTTOM (solid shape): outline of 96 points within 120.9,57.53 122.97,62.49
+VCORE/GT on BOTTOM (solid shape): 111.39,62.03 111.43,62.03 111.69,61.77 111.7,61.71 111.66,61.68 111.63,61.68 111.62,61.68 111.23,61.43 111.62,61.17 111.63,61.17 112.62,61.17 112.69,61.14 112.72,61.07 112.91,60.77 113.27,60.79 113.37,60.79 113.42,60.71 113.42,56.9 113.28,56.9 112.83,57.35 112.38,57.35 112.13,57.11 112.13,56.92 112.14,56.86 112.15,56.8 112.15,56.39 112.02,56.26 111.75,56.26 111.27,56.74 111.27,56.91 111.82,57.46 111.82,57.62 111.84,57.66 111.85,57.76 111.84,57.86 111.82,57.9 111.82,58.1 111.35,58.57 111.35,58.97 111.67,59.29 111.68,59.3 111.78,59.8 111.27,59.81 111.23,59.78 111.18,59.77 111.11,59.86 111.01,59.92 110.95,59.95 110.88,59.97 110.83,59.97 110.79,59.99 110.78,60.02 110.78,61.94 110.95,62.11 111.32,62.11
+VCORE/GT on IN1 (solid shape): outline of 546 points within 111.63,56.8 121.82,60.84
+VCORE/GT on IN3 (solid shape): outline of 880 points within 112.34,56.82 128.4,63.12
+VCORE_SN_C on BOTTOM (solid shape): 149.3,44.55 149.3,44.05 149.66,43.69 149.88,43.69 149.99,43.58 149.99,41.89 148.87,41.89 148.58,42.17 148.58,44.46 148.81,44.68 149.18,44.68
+VDC_IN on TOP (solid shape): outline of 205 points within 42.85,101.93 64.38,109.33
+VDC_IN on BOTTOM (solid shape): 47.17,110.67 47.17,108.49 48.08,107.57 51.82,107.57 52.3,107.09 52.3,101.98 51.49,101.17 45.64,101.17 45.52,101.3 45.52,101.86 45.64,101.98 47.65,101.98 47.78,102.11 47.78,103.48 47.09,104.17 47.09,106.25 46.81,106.53 46.81,107.47 46.76,107.52 46.76,107.58 46.3,108.04 46.3,108.2 46.27,108.23 45.54,108.23 45.31,108.46 45.31,109.48 45.47,109.63 45.8,109.63 45.92,109.76 45.92,110.8 45.95,110.82 47.02,110.82
+VSUS_ROM on BOTTOM (solid shape): 105.84,19.36 105.84,18.49 105.56,18.21 104.29,18.21 104.12,18.39 103.89,18.62 103.57,18.6 102.29,18.6 102.13,18.75 102.13,19.05 102.24,19.15 103.99,19.15 104.24,19.41 105.79,19.41
+VTT_DDR on BOTTOM (solid shape): 97.54,92.08 97.54,90.71 97.38,90.55 96.62,90.55 96.47,90.71 96.47,91.82 96.8,92.15 97.46,92.15
CHG_BGATE_R_C on BOTTOM (solid shape): 150.5,24.21 150.5,23.55 150.37,23.42 149.05,23.42 148.95,23.52 148.95,23.8 149.1,23.95 149.81,23.95 149.83,23.98 149.83,24.16 149.45,24.54 148.31,24.54 148.23,24.62 148.23,25 148.31,25.07 149.63,25.07
CHG_LG1_D on BOTTOM (solid shape): 182.61,30.38 182.61,29.81 182.46,29.66 181.35,29.66 181.29,29.72 181.29,30.6 181.36,30.68 182.31,30.68
CHG_LG2_D on BOTTOM (solid shape): 166.32,25.43 166.32,24.46 165.43,23.57 164.6,23.57 164.41,23.75 164.41,24.72 164.62,24.92 165.15,24.92 165.74,25.5 166.24,25.5
CHG_PH1_D on BOTTOM (solid shape): 182.19,28.7 182.19,25.05 181.94,24.79 178.13,24.79 177.93,24.59 177.93,23.5 177.65,23.22 175.34,23.22 175.05,23.5 175.05,28.37 175.74,29.06 181.84,29.06
CHG_PH2_D on BOTTOM (solid shape): 172.09,28.02 172.09,23.4 171.91,23.22 169.32,23.22 169.11,23.42 169.11,24.92 168.76,25.28 168.76,25.63 168.4,25.99 165.74,25.99 165.07,25.33 163.27,25.33 163.07,25.53 163.07,26.6 163.17,26.7 164.77,26.7 165.48,27.41 165.48,28.3 165.91,28.73 171.37,28.73
CHG_UG1_R_D on BOTTOM (solid shape): 184.48,27.03 184.48,26.22 184.1,25.83 183.64,25.83 183.46,25.66 183.46,25.1 183.31,24.95 182.83,24.95 182.6,25.17 182.6,27.33 182.7,27.43 184.07,27.43
CHG_UG2_R_D on BOTTOM (solid shape): 162.81,26.44 162.81,24.89 162.46,24.54 162.13,24.54 161.86,24.82 161.86,26.42 162.03,26.6 162.66,26.6
CSON_R on BOTTOM (solid shape): 149.63,26.82 151,26.82 151.59,26.24 155.15,26.24 155.33,26.06 155.33,25.33 154.08,25.33 153.77,25.02 153.77,23.78 153.49,23.5 151.87,23.5 150.72,24.65 151.98,24.65 151.99,24.6 152,24.54 152.02,24.49 152.05,24.44 152.09,24.4 152.13,24.36 152.18,24.33 152.23,24.31 152.28,24.29 152.33,24.28 152.39,24.28 152.45,24.29 152.5,24.31 152.55,24.33 152.6,24.36 152.64,24.4 152.67,24.44 152.7,24.49 152.72,24.54 152.74,24.6 152.74,24.65 152.74,24.71 152.73,24.76 152.71,24.82 152.69,24.87 152.66,24.91 152.62,24.95 152.57,24.98 152.52,25.01 152.47,25.03 152.42,25.04 152.36,25.05 152.31,25.04 152.25,25.03 152.2,25.01 152.15,24.98 152.11,24.95 152.07,24.91 152.04,24.87 152.01,24.82 151.99,24.76 151.98,24.71 151.98,24.65 150.72,24.65 150.29,25.08 149.88,25.08 149.63,25.33 148.39,25.33 148.26,25.45 148.26,27 148.31,27.05 149.4,27.05
DCIN_R on BOTTOM (solid shape): 187.91,29.39 187.91,22 187.43,21.52 186.51,21.52 185.93,20.93 185.52,20.93 183.9,19.31 179.86,19.31 179.25,19.92 179.25,23.75 179.63,24.13 183.39,24.13 184.11,24.86 184.11,25.63 184.79,26.3 184.79,28.06 184.24,28.6 184.24,29.38 184.51,29.64 187.66,29.64
HDMI_POWER on TOP (solid shape): 18.52,73.8 18.52,72.38 18.17,72.03 16.66,72.03 15.98,71.35 15.44,71.35 15.24,71.55 15.24,71.97 14.69,72.53 14.69,73.2 14.79,73.29 15,73.29 15.34,72.96 17,72.96 17.51,73.47 17.51,73.9 18.42,73.9
MIC2_L on BOTTOM (solid shape): 11.38,54.74 11.38,54.19 11.42,54.19 11.46,54.16 12.7,54.16 12.75,54.16 12.81,54.17 13.1,54.17 13.16,54.12 13.16,53.51 13.17,53.49 13.17,53.24 13.16,53.23 10.51,53.23 9.53,54.21 9.53,54.71 9.63,54.82 11.3,54.82
MIC2_L on IN1 (solid shape): 6.12,52.33 6.12,51.54 6.05,51.47 4.7,51.47 4.61,51.56 4.61,52.43 4.72,52.54 5.9,52.54
MIC2_L on IN1 (solid shape): 11.08,54.61 11.08,53.4 10.93,53.25 9.76,53.25 9.55,53.46 9.55,54.71 9.66,54.82 10.87,54.82
MIC2_R on BOTTOM (solid shape): 6.31,53.95 6.32,53.35 5.33,52.36 4.99,52.36 4.62,52.23 4.44,51.89 4.01,51.46 2.35,51.46 2.34,51.47 2.34,52.21 2.46,52.34 3.29,52.34 3.67,52.72 3.67,53.73 3.8,53.87 5.43,53.87 5.7,54.13 6.14,54.13
PRO_THM on TOP (solid shape): 19.43,92.18 19.43,90.76 18.75,90.07 16.84,90.07 16.26,90.66 16.26,92.15 16.83,92.73 18.89,92.73
PRO_THM on BOTTOM (solid shape): 18.92,92.51 18.92,90.12 18.72,89.92 16.59,89.92 16.38,90.12 16.38,92.51 16.69,92.81 18.62,92.81
PU5101_VOUT1_S on TOP (solid shape): 35.18,69.4 35.18,67.52 35.03,67.36 32.72,67.36 32.49,67.59 32.49,68.86 32.69,69.07 34.03,69.07 34.33,69.36 34.35,69.39 34.38,69.42 34.4,69.43 35.14,69.43
PU5101_VOUT2_S on TOP (solid shape): 33.86,72.95 34.29,72.95 34.47,72.77 34.47,71.76 34.67,71.55 35.05,71.55 35.15,71.45 35.15,70.97 35.05,70.87 34.37,70.87 34.04,71.2 33.43,71.2 33.3,71.33 33.3,72.95 33.43,73.08 33.73,73.08
PU5102_VOUT1_S on BOTTOM (solid shape): 202.29,51.26 202.29,49.08 202.2,48.99 201.71,48.99 201.6,49.1 201.6,50.12 201.47,50.25 200.69,50.25 200.69,50.25 200.33,50.25 200.2,50.38 200.2,50.75 200.33,50.88 200.89,50.88 200.99,50.98 201.47,50.98 201.85,51.36 202.18,51.36
PU5102_VOUT2_S on BOTTOM (solid shape): 202.01,54.33 202.2,53.92 202.65,53.98 203.86,53.98 204.04,53.8 204.04,53.04 203.96,52.96 203.63,52.96 203.26,53.33 203.26,53.37 202.58,53.37 202.58,53.33 202.4,53.33 202.4,53.37 201.74,53.37 201.71,53.39 201.71,53.34 201.3,53.34 201.02,53.06 201.02,52.45 200.86,52.3 200.2,52.3 200.15,52.35 200.15,53.35 200.6,53.8 200.6,54.27 200.66,54.33
PU5104_VOUT1_S on BOTTOM (solid shape): 182.91,16.74 182.91,15.42 182.65,15.17 181.53,15.17 181.43,15.06 180.49,15.06 180.42,15.14 180.42,15.73 180.49,15.8 180.49,17.02 182.63,17.02
PU5104_VOUT2_S on BOTTOM (solid shape): 177.77,17.02 177.77,15.93 177.9,15.8 178.87,15.8 178.99,15.67 178.99,15.06 178.94,15.01 176.35,15.01 176.23,15.14 176.23,16.66 176.45,16.89 176.48,16.89 176.66,17.07 177.72,17.07
PU5106_VOUT1_S on BOTTOM (solid shape): 137.92,26.52 137.92,24.51 137.87,24.46 137.01,24.46 136.54,24.93 135.12,24.93 135.05,25 135.02,25.09 134.98,25.18 134.98,26.49 135.05,26.57 135.97,26.57 136.02,26.52 137.34,26.52 137.47,26.65 137.8,26.65
PU5106_VOUT2_S on BOTTOM (solid shape): 137.9,22.02 137.62,21.74 137.62,21.01 136.98,20.37 136.32,20.37 136.03,20.67 136.03,22.11 136.17,22.25 137.01,22.25 137.16,22.41 137.16,22.96 137.26,23.07 137.9,23.07
PWM1B_SW_OUT_S on BOTTOM (solid shape): 148.8,48.94 149.79,48.94 149.83,48.9 149.83,45.72 149.63,45.52 148.67,45.52 147.83,44.68 147.83,42.32 147.45,41.94 146.27,41.94 146.03,42.18 146.03,46.98 146.05,47 146.05,48.21 146.03,48.24 146.03,49.45 146.08,49.51 148.23,49.51
PWM2B_SW_OUT_S on BOTTOM (solid shape): 148.16,63.07 149,63.07 149.12,62.94 149.12,59.64 148.87,59.39 148.39,59.39 148.18,59.18 148.18,58.17 148.21,58.14 148.21,56.54 147.98,56.31 146.76,56.31 146.48,56.59 146.48,58.27 145.47,59.28 145.47,62.05 145.53,62.11 145.53,63.46 145.8,63.73 147.5,63.73
PWMA_SW_OUT_S on TOP (solid shape): 149.23,68.76 149.23,67.49 149,67.26 145.97,67.26 145.47,67.77 145.47,68.79 145.77,69.09 148.9,69.09
PWMA_SW_OUT_S on BOTTOM (solid shape): 149.38,69.8 149.38,69.8 149.38,69.29 149.05,68.96 148.46,68.96 148.21,68.71 148.21,67.44 147.63,66.86 145.87,66.86 145.49,67.24 145.49,68.86 145.85,69.22 145.85,71.81 146.05,72.01 147.27,72.01 147.85,72.6 149.38,72.6
RING2 on TOP (solid shape): 14.2,29.24 14.2,28.84 14.07,28.72 12.43,28.72 12.28,28.87 12.28,29.21 12.4,29.34 14.1,29.34
RING2 on BOTTOM (solid shape): 14.72,54.98 14.72,53.23 13.79,53.23 13.41,53.61 13.41,55.1 13.52,55.21 14.49,55.21
RING2 on BOTTOM (solid shape): 13.39,29.19 13.84,29.19 13.89,29.14 14.45,29.14 14.48,29.11 14.48,28.96 14.45,28.93 13.81,28.93 13.76,28.88 13.65,28.88 13.58,28.81 12.94,28.81 12.84,28.71 12.33,28.71 12.32,28.73 12.28,28.75 12.28,29.17 12.41,29.3 13.28,29.3
RING2 on IN3 (solid shape): 14.71,54.92 14.71,52.43 14.61,52.33 13.56,52.33 13.26,52.63 13.26,55.1 13.39,55.22 14.41,55.22
RING2 on IN3 (solid shape): outline of 138 points within 11.09,28.57 13.84,31.82
SLEEVE on TOP (solid shape): 13.64,30.3 13.64,29.62 13.54,29.52 12.37,29.52 12.29,29.59 12.29,30.05 12.75,30.51 13.44,30.51
SLEEVE on BOTTOM (solid shape): 9.19,54.71 9.19,54.36 8.99,54.16 8.99,53.63 8.96,53.6 8.96,53.34 8.75,53.13 8.15,53.13 8.06,53.22 7.38,53.22 7.3,53.3 7.3,54.8 9.1,54.8
SLEEVE on BOTTOM (solid shape): 13.07,30.05 13.53,29.6 13.82,29.6 13.87,29.54 14.45,29.54 14.48,29.52 14.48,29.34 13.46,29.34 13.34,29.45 12.34,29.45 12.17,29.63 12.17,29.97 12.25,30.06 12.8,30.06 12.85,30.07 13.02,30.07
SLEEVE on IN2 (solid shape): 9.4,54.54 9.4,54.52 9.4,53.7 9.31,53.61 8.28,53.61 8.01,53.88 8.01,54.67 8.12,54.79 9.15,54.79
SLEEVE on IN2 (solid shape): 12.27,31.55 12.27,31.55 12.7,31.11 12.89,30.81 13.26,30.8 13.3,30.83 13.35,30.87 13.46,30.89 13.52,30.8 13.52,29.58 13.41,29.48 11.59,29.48 11.58,29.49 11.37,29.49 11.32,29.53 11.24,29.57 11.1,29.71 11.1,31.57 11.2,31.68 12.14,31.68
SPK_L+ on TOP (solid shape): 9.53,15.34 9.53,14.25 9.45,14.18 8.41,14.18 8.36,14.23 8.36,15.39 9.47,15.39
SPK_L+ on BOTTOM (solid shape): 16.03,34.41 16.4,34.41 16.48,34.33 16.59,34.22 16.59,34.21 16.97,33.83 16.97,33.72 16.97,33.72 16.97,32.91 16.94,32.88 16.94,31.8 16.92,31.78 16.76,31.78 16.74,31.8 16.74,32.51 16.69,32.57 16.69,33.03 16.64,33.08 16.52,33.64 15.95,33.73 15.9,33.73 15.29,34.34 15.29,34.52 15.52,34.75 15.69,34.75
SPK_L+ on IN3 (solid shape): 9.64,14.7 9.64,13.12 9.37,12.85 8.51,12.85 8.45,12.92 8.45,14.8 8.46,14.81 9.53,14.81
SPK_L+ on IN3 (solid shape): 16.41,34.44 16.78,34.07 16.78,34.01 16.85,33.98 16.89,33.95 16.93,33.92 16.95,33.88 16.97,33.85 16.99,33.8 16.99,33.72 17.7,33.01 17.7,31.89 17.61,31.8 16.66,31.8 16.55,31.9 16.55,32.94 16.58,33.57 15.98,33.75 15.91,33.81 15.91,34.18 16.18,34.44 16.4,34.44
SPK_L+_R on TOP (solid shape): 8.87,19.5 9.3,19.08 9.3,17.43 9.93,16.8 10.22,16.8 10.34,16.39 9.68,15.7 9.42,15.79 9.42,16.2 8.31,16.2 8.31,16.16 8.2,16.16 8.17,16.92 8.17,17.05 8.38,17.26 8.38,17.88 8.13,18.14 8.13,19.23 8.08,19.28 8.08,19.41 7.8,19.68 7.8,19.79 7.95,19.79 8.08,19.92 8.85,19.92 8.87,19.93
SPK_L+_R on BOTTOM (solid shape): 8.64,21.14 8.64,19.56 8.71,19.48 8.71,17.96 8.56,17.83 8.23,17.83 8,18.06 8,19.48 8.03,19.51 8.03,21.14 8.05,21.16 8.61,21.16
SPK_L- on TOP (solid shape): 8.1,15.34 8.1,14.2 8.03,14.12 7.04,14.12 6.99,14.18 6.99,15.39 8.05,15.39
SPK_L- on TOP (solid shape): 17.63,35.61 17.63,35.31 17.53,35.21 17.53,33.83 17.4,33.71 17.2,33.71 17.12,33.79 17.01,34.02 16.78,34.13 16.76,34.15 16.76,34.53 16.87,34.9 16.6,35.18 16.56,35.19 16.56,35.71 16.64,35.79 17.45,35.79
SPK_L- on BOTTOM (solid shape): 17.53,34.88 17.53,32.84 17.35,32.66 17.35,31.8 17.32,31.78 17.17,31.78 17.15,31.8 17.15,32.82 17.13,32.84 17.13,33.78 17.12,33.79 17.12,33.93 16.89,34.17 16.89,34.63 17.22,34.97 17.44,34.97
SPK_L- on IN3 (solid shape): 8.19,14.75 8.19,12.51 7.98,12.3 7.01,12.3 6.88,12.42 6.88,14.73 7.01,14.86 8.08,14.86
SPK_L- on IN3 (solid shape): 17.69,34.89 17.68,34.65 17.82,34.45 17.82,34.44 17.69,33.99 18.11,33.76 18.39,33.76 18.49,33.66 18.69,33.5 18.94,33.51 20.19,33.51 20.35,33.35 20.35,32.97 20.23,32.86 18.11,32.86 17.95,33.02 17.95,33.12 17.25,33.82 17.25,33.9 17.21,33.94 17.18,34 17.16,34.02 17.15,34.05 17.09,34.11 17.03,34.16 17.03,34.18 16.91,34.31 16.91,34.88 17.06,35.04 17.54,35.04
SPK_L-_R on TOP (solid shape): 7.55,19.58 7.62,19.51 7.62,19.46 7.67,19.46 7.82,19.3 7.82,19.18 7.87,19.12 7.87,18.03 8.13,17.78 8.13,17.37 7.91,17.15 7.91,16.91 7.95,16.2 7.09,16.2 7.09,19.66 7.55,19.66
SPK_L-_R on BOTTOM (solid shape): 7.65,21.14 7.65,19.54 7.75,19.43 7.75,18.04 7.67,17.86 7.14,17.86 6.99,18.01 6.99,19.46 7.04,19.51 7.04,21.11 7.09,21.16 7.62,21.16
SPK_R+ on TOP (solid shape): 5.33,14.3 5.23,14.2 4.34,14.2 4.19,14.35 4.19,15.42 4.22,15.45 5.33,15.45
SPK_R+ on BOTTOM (solid shape): 19.61,35.05 19.61,34.79 19.32,34.5 19.11,34.11 19.29,33.7 19.29,33.6 18.2,32.52 18.2,32.38 18.18,32.38 18.18,31.97 18.16,31.97 18.16,31.78 17.93,31.78 17.93,32.49 18.05,32.61 18.05,32.68 18.14,32.77 18.14,33.22 18.53,33.61 18.53,34.7 18.6,34.77 18.75,34.95 19.14,35.33 19.33,35.33
SPK_R+ on IN1 (solid shape): 5.36,14.63 5.36,12.19 5.23,12.07 4.29,12.07 4.01,12.35 4.01,14.66 4.14,14.79 5.21,14.79
SPK_R+ on IN1 (solid shape): 19.32,34.5 19.12,34.18 19.2,33.81 19.62,33.58 20.05,33.81 20.32,33.81 21.11,33.02 21.11,32.64 20.88,32.41 20.17,32.41 19.76,32.82 19.02,32.82 18.58,33.26 18.58,34.78 19.03,34.78
SPK_R+_R on TOP (solid shape): 5.41,19.45 5.41,19.36 5.41,16.08 5.37,16.1 5.36,16.13 5.36,16.23 4.17,16.23 4.17,19.51 4.29,19.64 5.41,19.64
SPK_R+_R on BOTTOM (solid shape): 5.66,20.63 5.66,18.39 5.49,18.21 4.62,18.21 4.55,18.29 4.55,20.96 4.6,21.01 5.28,21.01
SPK_R- on TOP (solid shape): 6.73,13.95 6.91,13.77 6.91,13.41 6.78,13.29 6.22,13.29 5.59,13.92 5.59,15.42 5.61,15.45 6.73,15.45
SPK_R- on BOTTOM (solid shape): 18.26,34.93 18.26,33.59 17.9,33.22 17.9,32.68 17.75,32.54 17.75,31.78 17.53,31.78 17.53,32.6 17.66,32.74 17.69,32.77 17.69,34.71 17.7,34.71 17.7,34.9 17.81,35.01 18.18,35.01
SPK_R- on IN1 (solid shape): 6.82,14.7 6.82,12.46 6.66,12.3 5.93,12.3 5.61,12.61 5.61,14.66 5.77,14.81 6.71,14.81
SPK_R- on IN1 (solid shape): 18.33,34.94 18.33,32.75 18.24,32.66 17.24,32.66 17.14,32.75 17.14,33.51 17.36,33.72 17.64,34 17.53,34.37 17.53,34.43 17.56,34.46 17.58,34.49 17.65,34.7 17.59,34.91 17.71,35.03 18.24,35.03
SPK_R-_R on TOP (solid shape): 6.83,19.59 6.83,16.23 5.66,16.23 5.66,19.34 5.67,19.41 5.66,19.59 5.77,19.69 6.73,19.69
SPK_R-_R on BOTTOM (solid shape): 6.66,21.08 6.66,19.51 6.73,19.43 6.73,18.42 6.66,18.34 6.07,18.34 5.97,18.44 5.97,19.46 6.07,19.56 6.07,21.06 6.12,21.11 6.63,21.11
USB_ADT on TOP (solid shape): 43.69,107.17 43.69,105.29 43.41,105.01 36.27,105.01 36.17,105.11 36.17,106.08 36.44,106.37 36.31,106.74 36.31,107.23 36.5,107.42 43.43,107.42
VDC_IN_SN on BOTTOM (solid shape): 45.52,110.71 45.52,110.09 45.14,109.71 45.14,108.23 45.31,108.05 46.08,108.05 46.61,107.52 46.61,106.48 46.91,106.17 46.91,103.94 47.42,103.43 47.42,102.24 47.32,102.14 46.71,102.14 46.53,102.31 45.64,102.31 44.86,101.53 44.86,100.13 44.35,99.62 43.97,99.62 43.87,99.72 43.87,102 45.17,103.3 45.17,103.39 45.24,103.46 45.24,105.64 45.69,105.64 45.7,105.59 45.71,105.53 45.73,105.48 45.76,105.43 45.79,105.39 45.83,105.35 45.88,105.31 45.93,105.29 45.98,105.27 46.03,105.26 46.09,105.26 46.15,105.27 46.2,105.28 46.25,105.3 46.3,105.33 46.34,105.37 46.38,105.41 46.41,105.45 46.43,105.5 46.45,105.56 46.46,105.61 46.46,105.67 46.45,105.72 46.43,105.78 46.41,105.83 46.38,105.87 46.34,105.92 46.3,105.95 46.25,105.98 46.2,106 46.15,106.02 46.09,106.02 46.03,106.02 45.98,106.01 45.93,105.99 45.88,105.97 45.83,105.93 45.79,105.9 45.76,105.85 45.73,105.8 45.71,105.75 45.7,105.7 45.69,105.64 45.24,105.64 45.24,107.04 45.11,107.17 44.07,107.17 43.74,107.5 43.74,110.64 43.9,110.8 45.42,110.8
N144773302 on BOTTOM (solid shape): 195.86,47.65 195.86,47.02 196.14,46.74 197.92,46.74 198.07,46.59 200.38,46.59 200.76,46.21 200.76,44.53 199.8,43.56 199.8,40.85 201.07,39.58 201.07,35.54 199.31,33.78 195.43,33.78 194.97,34.24 194.97,42.24 193.57,43.64 193.57,47.5 193.9,47.83 195.68,47.83
N144773400 on BOTTOM (solid shape): 181.93,64.4 181.93,63.65 183.52,62.07 183.52,59.82 183.91,59.42 183.91,54.02 183.3,53.41 179.57,53.41 179.57,57.39 179.4,57.56 179.07,57.56 178.91,57.6 178.57,57.61 178.45,57.72 178.42,57.78 178.38,57.83 178.36,57.86 178.49,58.17 178.37,58.44 178.36,58.45 178.36,58.5 178.25,58.61 178.25,59.68 178.44,59.87 178.44,60.32 178.64,60.52 178.64,64.59 178.72,64.67 178.97,64.67 181.66,64.67
N145129059 on BOTTOM (solid shape): 49.17,20.22 52.53,20.22 52.76,19.99 52.76,16.77 52.38,16.39 47.65,16.39 47.42,16.61 47.45,16.64 47.45,17.22 46.71,17.96 46.71,19.29 48.39,19.29 48.39,18.33 48.55,18.16 48.73,18.16 48.73,18.15 49.37,18.15 49.37,18.16 49.54,18.16 49.68,18.3 49.68,19.29 49.47,19.51 48.6,19.51 48.39,19.29 46.71,19.29 46.71,20.14 46.91,20.35 49.05,20.35
N146992205 on TOP (solid shape): 53.04,110.64 53.04,107.06 46.28,107.06 45.89,107.46 45.89,110.43 46.2,110.75 52.93,110.75
N152920482 on TOP (solid shape): 99.42,97.06 99.42,95.97 99.33,95.89 99.33,95.84 99.29,95.83 98.98,95.45 99.3,95.08 99.34,95.07 99.34,94.29 99.11,94.06 99.09,94.06 98.77,93.82 98.8,93.42 98.81,93.41 98.81,93.25 98.73,93.17 97.82,93.17 97.71,93.27 97.71,93.53 97.92,93.73 97.92,95.77 98.85,96.71 98.85,97.08 98.88,97.11 99.37,97.11
N152920482 on BOTTOM (solid shape): 98.83,93.53 98.83,93.15 98.6,92.92 98.6,91.67 98.48,91.54 98.12,91.54 97.99,91.67 97.99,92.56 97.61,92.94 97.61,93.55 97.76,93.7 98.65,93.7
N152947720 on TOP (solid shape): 35.43,104.4 36.88,104.4 36.91,104.37 36.91,103.36 36.93,103.33 37.19,103.33 37.21,103.36 37.21,104.32 37.26,104.37 37.54,104.37 37.57,104.35 37.57,103.36 37.59,103.33 37.85,103.33 37.87,103.36 37.87,104.32 37.9,104.35 38.23,104.35 38.25,104.32 38.25,99.88 37.85,99.47 34.24,99.47 33.99,99.72 33.99,100.18 33.76,100.41 32.49,100.41 32.39,100.51 32.39,101.3 32.49,101.4 33.5,101.4 33.86,101.75 33.86,104.96 33.99,105.08 34.75,105.08
N152947898 on TOP (solid shape): 33.2,103.18 33.2,101.73 33.05,101.58 32.36,101.58 31.65,100.87 31.65,100.24 31.59,100.18 30.76,100.18 30.63,100.31 30.63,101.83 30.74,101.95 30.8,102.1 30.91,102.21 31.6,102.21 32.11,102.72 32.11,103.18 32.18,103.25 33.12,103.25
N152966728 on BOTTOM (solid shape): 183.67,70.69 183.67,65.63 183.41,65.36 181.25,65.36 181.25,65.36 181.03,65.36 180.98,65.41 180.98,66.72 180.95,66.74 180.95,66.86 180.77,67.03 180.75,67.01 176.48,67.01 176.43,67.06 176.43,67.63 175.9,68.16 175.9,68.58 175.31,69.17 175.31,69.8 175.51,70 178.31,70 178.41,69.9 180.8,69.9 181.61,70.72 183.64,70.72
