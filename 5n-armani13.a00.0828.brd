# Allegro board 5n-armani13.a00.0828.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_D28: length 70.6
  TOP w0.102: v1(54.57,77.46) 53.8,76.69 v2(53.72,76.69)
  IN3 w0.097: v1(54.57,77.46) 54.28,77.17 54.28,76.54 54.75,76.07 57.4,76.07 58.57,74.91 70.01,74.91 70.26,75.15 70.52,75.15 70.76,74.91 71.03,74.91 71.27,75.15 71.54,75.15 71.78,74.91 72.05,74.91 72.29,75.15 72.55,75.15 72.8,74.91 73.25,74.91 73.38,75.03 73.38,75.53 73.5,75.65 73.73,75.65 73.88,75.5 74.48,75.5 74.65,75.67 84.39,75.67 84.74,75.67 86.28,77.21 96.83,77.21 99.82,77.21 102.5,77.21 103.81,75.9 103.81,74.9 106.26,72.44 106.26,72.26 106.26,72.26 106.26,70.3 107.39,69.17 109.42,69.17 109.7,68.89 109.7,68.12 v3(110.06,67.77)
  BOTTOM w0.089: U0400.AN61 110.06,67.7 v3(110.06,67.77)
  BOTTOM w0.102: v1(54.57,77.46) 55.2,76.82 CON2100.67
M_B_D29: length 69.2
  TOP w0.102: v2(55.68,74.66) v1(55.68,75.3)
  IN3 w0.097: v1(55.68,75.3) 55.68,75.42 55.98,75.73 56.71,75.73 56.84,75.6 56.84,75.4 56.97,75.27 57.37,75.27 58.08,74.56 74.76,74.56 74.88,74.69 74.88,75.17 75.01,75.29 75.26,75.29 75.39,75.17 75.39,74.73 75.52,74.6 75.77,74.6 75.9,74.73 75.9,75.17 76.03,75.29 76.28,75.29 76.41,75.17 76.41,74.69 76.53,74.56 76.79,74.56 76.91,74.69 76.91,75.17 77.04,75.29 77.3,75.29 77.42,75.17 77.42,74.69 77.55,74.56 77.8,74.56 77.93,74.69 77.93,75.17 78.06,75.29 78.31,75.29 78.44,75.17 78.44,74.73 78.57,74.6 78.82,74.6 78.95,74.73 78.95,75.2 79.07,75.33 84.53,75.33 84.88,75.33 86.42,76.87 96.97,76.87 99.56,76.87 99.56,76.87 99.96,76.87 102.35,76.87 103.57,75.65 103.57,74.82 104.62,73.76 104.76,73.63 104.76,73.63 106.04,72.35 106.04,70.2 107.91,68.33 108.9,68.33 v3(109.46,67.77)
  BOTTOM w0.089: U0400.AP61 109.46,67.65 v3(109.46,67.77)
  BOTTOM w0.102: v1(55.68,75.3) 55.68,75.42 56.08,75.82 CON2100.71
M_B_D30: length 69.8
  TOP w0.102: v2(55.68,71.72) v1(55.68,72.35)
  IN3 w0.097: v3(108.11,66.86) 107.71,66.46 106.94,66.46 105.81,67.59 105.81,68.44 104.65,69.61 104.65,69.74 103.18,71.21 103.18,71.48 103.18,71.52 103.18,71.6 103.18,71.61 103.18,72.14 103.18,72.15 103.18,72.44 101.3,74.32 101.02,74.32 98.51,74.32 98.51,74.32 98.22,74.32 97.22,73.32 97.16,73.26 88.79,73.26 88.66,73.13 88.66,72.24 88.53,72.11 88.28,72.11 88.15,72.24 88.15,73.13 88.02,73.26 87.77,73.26 87.64,73.13 87.64,72.06 87.52,71.94 87.26,71.94 87.13,72.06 87.13,73.13 87.01,73.26 86.75,73.26 86.63,73.13 86.63,72.06 86.5,71.94 86.05,71.94 85.92,72.06 85.92,72.61 85.79,72.74 85.54,72.74 85.41,72.61 85.41,72.06 85.29,71.94 85.03,71.94 84.9,72.06 84.9,72.61 84.78,72.74 84.52,72.74 84.4,72.61 84.4,72.06 84.27,71.94 73.24,71.94 72.44,71.14 66.42,71.14 65.98,71.58 62.13,71.58 62.07,71.64 60.74,71.64 60.74,71.63 57.15,71.63 56.95,71.83 56.95,71.83 56.86,71.93 56.1,71.93 v1(55.68,72.35)
  BOTTOM w0.089: v3(108.11,66.86) 108.11,66.78 U0400.AT60
  BOTTOM w0.102: CON2100.83 56.15,72.82 v1(55.68,72.35)
M_B_D31: length 68.9
  TOP w0.102: v2(54.43,72.96) v1(54.43,72.33)
  IN3 w0.097: v1(54.43,72.33) 54.43,72.55 54.77,72.89 56.57,72.89 57.11,72.36 57.11,72.36 57.48,71.98 62.21,71.98 62.22,71.97 66.55,71.97 66.71,72.13 72.19,72.13 72.34,72.28 80.45,72.28 80.57,72.41 80.57,72.95 80.7,73.08 80.95,73.08 81.08,72.95 81.08,72.41 81.21,72.28 81.46,72.28 81.59,72.41 81.59,72.95 81.72,73.08 81.97,73.08 82.1,72.95 82.1,72.41 82.22,72.28 82.48,72.28 82.6,72.41 82.6,72.95 82.73,73.08 82.99,73.08 83.11,72.95 83.11,72.41 83.24,72.28 83.49,72.28 83.62,72.41 83.62,72.95 83.75,73.08 85.78,73.08 86.3,73.6 96.82,73.6 96.88,73.66 97.46,74.24 97.88,74.67 98.65,74.67 98.65,74.67 100.87,74.67 100.87,74.67 101.44,74.67 103.52,72.58 103.52,72.3 103.52,72 103.52,72 103.52,71.67 104.02,71.17 104.33,71.17 104.88,70.63 104.88,69.77 104.88,69.7 106.6,67.97 106.6,67.44 107.19,66.86 v3(107.46,66.86)
  BOTTOM w0.089: U0400.AU60 107.46,66.78 v3(107.46,66.86)
  BOTTOM w0.102: CON2100.79 55.58,73.82 54.43,72.68 v1(54.43,72.33)
M_B_D32: length 69.1
  TOP w0.102: v1(53.62,46.11) 53.2,46.11 v2(52.71,46.61)
  IN3 w0.097: v3(108.1,55.93) 107.71,56.33 105.5,56.33 104.29,55.12 103.53,55.12 103.4,54.99 102.81,54.99 102.81,54.99 100.89,54.99 91.96,54.99 91.43,54.99 89.51,53.07 88.49,53.07 84.91,49.49 84.91,49.49 82.48,47.06 78.66,47.06 77.18,45.57 73.65,45.57 72.82,44.74 66.1,44.74 66.1,44.74 66.09,44.74 65.83,44.48 60.59,44.48 59.33,45.73 57.56,45.73 56.59,46.7 54.21,46.7 v1(53.62,46.11)
  BOTTOM w0.089: U0400.AU40 108.1,55.8 v3(108.1,55.93)
  BOTTOM w0.102: CON2100.169 55.98,49.32 55.78,49.12 55.78,48.8 55.48,48.5 54.21,48.5 53.34,47.63 53.34,46.39 v1(53.62,46.11)
M_B_D33: length 69.1
  TOP w0.102: v1(54.36,47.48) 54.36,48.08 v2(54.23,48.21)
  IN3 w0.097: v1(54.36,47.48) 53.93,47.91 53.39,47.91 53.06,47.58 53.06,46.87 53.19,46.74 53.75,46.74 54.05,47.04 56.74,47.04 57.7,46.07 59.47,46.07 60.73,44.82 65.69,44.82 65.94,45.08 65.95,45.08 65.96,45.09 72.68,45.09 73.82,46.23 75.81,46.23 76.37,46.23 77.54,47.4 81.27,47.4 82.36,48.48 82.63,48.76 83.7,48.76 84.57,49.63 84.57,49.63 88.35,53.41 89.36,53.41 91.29,55.33 93.31,55.33 101.03,55.33 102.67,55.33 103.3,55.33 103.89,55.93 104.54,55.93 105.17,56.56 108.1,56.56 v3(108.73,55.92)
  BOTTOM w0.089: v3(108.73,55.92) 108.73,55.78 U0400.AT40
  BOTTOM w0.102: v1(54.36,47.48) 55.14,48.27 55.63,48.27 55.68,48.32 CON2100.173
M_B_D34: length 70.5
  TOP w0.102: v2(50.76,44.59) 50.76,45.07 v1(51.27,45.58)
  IN3 w0.097: v3(108.09,54.05) 107.7,53.67 107.32,53.67 106.81,53.16 105,53.16 104.29,52.45 93.01,52.45 92.48,52.45 90.48,50.44 90.34,50.44 90.28,50.44 84.35,44.51 81.43,44.51 78.09,41.18 66.47,41.18 65.78,40.49 65.5,40.49 65.5,40.49 61.94,40.49 61.42,41.01 60.61,41.01 59.03,41.01 56.92,43.12 53.59,43.12 52.58,44.12 50.49,44.12 50.36,44.25 50.36,44.67 v1(51.27,45.58)
  BOTTOM w0.089: U0400.AT37 108.09,54 v3(108.09,54.05)
  BOTTOM w0.102: v1(51.27,45.58) 51.27,45.65 51.05,45.87 50.84,46.07 CON2100.182
M_B_D35: length 69.3
  TOP w0.102: v2(107.04,54.51) v3(107.49,54.07)
  IN3 w0.097: v1(54.39,44.38) 53.68,45.09 53.09,45.09 52.96,44.96 52.96,44.33 53.81,43.47 57.05,43.47 57.18,43.34 59.12,41.4 61.51,41.4 62.08,40.83 65.64,40.83 66.84,42.03 71.76,42.03 72.27,41.52 78,41.52 81.33,44.86 84.21,44.86 90.14,50.79 90.19,50.79 90.34,50.79 92.34,52.79 93.15,52.79 104.12,52.79 104.8,53.47 106.6,53.47 107.04,53.9 107.32,53.9 v3(107.49,54.07)
  BOTTOM w0.089: U0400.AU37 107.49,53.95 v3(107.49,54.07)
  BOTTOM w0.102: v1(54.39,44.38) 54.39,44.47 55.52,45.6 56.32,45.6 56.54,45.82 CON2100.183
M_B_D36: length 72.1
  IN3 w0.097: v1(52.58,47.55) 52.58,47.91 52.38,48.11 52.38,48.29 52.5,48.41 54.03,48.41 55.05,47.39 56.88,47.39 57.85,46.42 59.62,46.42 60.87,45.16 65.54,45.16 65.8,45.42 65.81,45.42 66.4,46.01 70.29,46.01 70.35,45.95 73.05,45.95 73.68,46.57 75.95,46.57 76.23,46.57 77.4,47.74 81.13,47.74 82.21,48.82 82.49,49.1 83.56,49.1 84.23,49.77 84.23,49.78 88.2,53.75 89.02,53.75 90.95,55.68 93.45,55.68 103.3,55.68 103.78,56.16 104.27,56.16 104.89,56.78 108.17,56.78 108.64,56.31 108.97,56.31 v3(109.36,55.92)
  BOTTOM w0.089: v3(109.36,55.92) 109.36,55.76 109.28,55.68 U0400.AR40
  BOTTOM w0.102: v1(52.58,47.55) 51.05,49.07 CON2100.170 47.55,49.07 v2(46.55,48.07)
M_B_D37: length 71.2
  TOP w0.102: v1(51.26,47.58) 51.26,48.31 v2(51,48.57)
  IN3 w0.076: 108.61,57.14 108.67,57.2 108.85,57.2 109.27,56.78 109.27,56.68 v3(110.03,55.92)
  IN3 w0.097: v1(51.26,47.58) 51.26,48.01 50.9,48.36 50.9,48.54 51.13,48.77 54.23,48.77 55.21,47.79 55.43,47.79 56.96,47.79 57.99,46.76 59.76,46.76 60.16,46.36 60.68,46.36 61.53,45.51 65.4,45.51 65.66,45.77 65.67,45.77 66.26,46.35 70.43,46.35 70.49,46.29 72.91,46.29 73.54,46.92 76.09,46.92 77.26,48.08 80.99,48.08 82.07,49.17 82.43,49.52 83.49,49.52 83.89,49.92 83.89,49.92 88.06,54.09 88.88,54.09 90.8,56.02 99.03,56.02 99.03,56.02 101.31,56.02 103.26,56.02 103.63,56.39 104.04,56.39 104.67,57.03 108.49,57.03 108.61,57.14
  BOTTOM w0.089: v3(110.03,55.92) 110.03,55.78 U0400.AP40
  BOTTOM w0.102: v1(51.26,47.58) 51.26,47.91 51.09,48.07 CON2100.174
M_B_D38: length 72
  TOP w0.102: v1(51.88,45.58) 51.32,46.14 51.15,46.31 v2(51,46.31)
  IN3 w0.076: v3(109.36,54.11) 108.83,54.64 106.99,54.64 106.5,54.16
  IN3 w0.097: v1(51.88,45.58) 51.32,46.14 51.21,46.25 51.21,46.65 51.55,46.99 52.15,46.99 53.01,46.13 53.01,45.57 53.15,45.43 53.82,45.43 54.46,44.79 56.35,44.79 56.4,44.74 56.41,44.74 56.94,44.22 58.71,44.22 59.96,42.96 62.05,42.96 62.59,42.43 62.96,42.05 65.89,42.05 66.78,42.94 66.96,42.94 78.53,42.94 81.13,45.54 83.93,45.54 89.86,51.47 89.91,51.47 89.91,51.47 90.05,51.47 92.06,53.48 100.26,53.48 103.8,53.48 104.48,54.16 106.5,54.16
  BOTTOM w0.089: v3(109.36,54.11) 109.36,54.03 U0400.AP37
  BOTTOM w0.102: v1(51.88,45.58) 51.88,45.55 51.4,45.07 CON2100.186
M_B_D39: length 71.2
  TOP w0.102: v2(55.61,43.72) v1(55.61,44.38)
  IN3 w0.076: v3(108.72,54.11) 108.39,54.44 107.09,54.44
  IN3 w0.097: v1(55.61,44.38) 55.61,44.03 55.83,43.81 58.62,43.81 59.21,43.23 59.21,41.98 59.44,41.75 59.78,41.75 59.91,41.87 59.91,42.42 60.03,42.55 60.29,42.55 60.41,42.42 60.41,41.87 60.54,41.75 60.8,41.75 60.92,41.87 60.92,42.42 61.05,42.55 61.3,42.55 61.43,42.42 61.43,41.87 61.56,41.75 62.55,41.75 63.12,41.18 65.5,41.18 66.92,42.6 72.49,42.6 72.61,42.47 72.61,41.99 72.74,41.86 72.99,41.86 73.12,41.99 73.12,42.47 73.25,42.6 73.5,42.6 73.63,42.47 73.63,41.99 73.76,41.86 74.01,41.86 74.14,41.99 74.14,42.47 74.26,42.6 74.52,42.6 74.65,42.47 74.65,41.99 74.77,41.86 75.03,41.86 75.15,41.99 75.15,42.47 75.28,42.6 75.53,42.6 75.66,42.47 75.66,42.24 75.79,42.12 76.04,42.12 76.17,42.24 76.17,42.47 76.3,42.6 78.63,42.6 81.23,45.2 84.07,45.2 90,51.13 90.05,51.13 90.2,51.13 92.2,53.13 93.3,53.13 93.3,53.13 103.98,53.13 104.7,53.85 106.5,53.85 107.09,54.44
  BOTTOM w0.089: U0400.AR37 108.72,54.02 v3(108.72,54.11)
  BOTTOM w0.102: v1(55.61,44.38) 56.06,44.82 CON2100.187
M_B_D40: length 70.4
  TOP w0.102: v1(55.61,42.63) v2(55.61,41.94)
  IN3 w0.097: v1(55.61,42.63) 55.61,42.3 55.74,42.18 56.96,42.18 58.76,40.38 60.87,40.38 61.16,40.38 61.98,39.55 63.14,39.55 63.15,39.54 63.5,39.54 63.51,39.55 65.66,39.55 65.96,39.86 66.13,39.86 66.63,40.36 66.64,40.36 66.81,40.54 69.62,40.54 69.75,40.41 69.75,40.01 69.88,39.88 70.13,39.88 70.26,40.01 70.26,40.41 70.39,40.54 70.64,40.54 70.77,40.41 70.77,39.74 70.86,39.64 71.18,39.64 71.27,39.74 71.27,40.41 71.4,40.54 71.66,40.54 71.78,40.41 71.78,39.74 71.88,39.64 72.19,39.64 72.29,39.74 72.29,40.41 72.42,40.54 72.67,40.54 72.8,40.41 72.8,39.74 72.9,39.64 73.21,39.64 73.31,39.74 73.31,40.41 73.43,40.54 73.69,40.54 73.81,40.41 73.81,39.83 73.91,39.73 74.22,39.73 74.32,39.83 74.32,40.41 74.45,40.54 78.31,40.54 81.65,43.88 84.62,43.88 90.55,49.81 90.6,49.81 90.6,49.81 90.74,49.81 92.75,51.81 98.79,51.81 99.22,51.38 104.21,51.38 105.44,52.61 107.09,52.61 107.21,52.73 107.69,52.73 108.07,52.35 v3(108.07,52.35)
  BOTTOM w0.089: U0400.AT33 108.07,52.19 108.07,52.35 v3(108.07,52.35)
  BOTTOM w0.102: v1(55.61,42.63) 56,43.01 56.44,43.01 56.63,42.82 CON2100.195
M_B_D41: length 71.7
  TOP w0.102: v1(54.39,42.63) 54.32,42.56 53.87,42.11 v2(53.87,41.94) ; v2(106.07,53.06) 106.43,53.06 106.88,52.61 107.1,52.61 v3(107.37,52.34)
  IN3 w0.097: v1(54.39,42.63) 54.39,42.48 54.05,42.14 54.05,41.96 54.18,41.83 54.8,41.83 54.92,41.96 55.08,42.11 55.31,42.11 55.6,41.83 56.82,41.83 58.62,40.03 61.01,40.03 62.38,38.67 65.13,38.67 65.13,38.67 65.39,38.67 66.23,39.51 66.27,39.51 66.46,39.7 69.47,39.7 69.88,39.3 74.67,39.3 74.8,39.43 74.8,40.07 74.93,40.2 75.18,40.2 75.31,40.07 75.31,39.43 75.44,39.3 75.69,39.3 75.82,39.43 75.82,40.07 75.94,40.2 76.2,40.2 76.33,40.07 76.33,39.73 76.45,39.6 76.71,39.6 76.83,39.73 76.83,40.07 76.96,40.2 78.41,40.2 81.75,43.54 84.76,43.54 90.69,49.47 90.74,49.47 90.89,49.47 92.8,51.38 93.09,51.38 98.2,51.38 98.4,51.18 104.32,51.18 105.54,52.4 107.31,52.4 v3(107.37,52.34)
  BOTTOM w0.089: U0400.AU33 107.37,52.24 v3(107.37,52.34)
  BOTTOM w0.102: CON2100.191 55.37,43.82 54.39,42.85 v1(54.39,42.63)
M_B_D42: length 68.7
  TOP w0.102: v1(55.65,39.36) 55.96,39.66 55.96,39.73 v2(56.21,39.98)
  IN3 w0.097: v3(107.46,50.46) 107.02,50.46 106.4,51.08 105.84,51.08 104.28,49.52 103.06,49.52 102.95,49.4 98.38,49.4 98.08,49.1 96.74,49.1 93.77,49.1 86,41.34 82.5,41.34 78.26,37.1 76.84,37.1 76.71,36.97 76.71,36.53 76.58,36.4 76.33,36.4 76.2,36.53 76.2,36.97 76.07,37.1 75.82,37.1 75.69,36.97 75.69,36.53 75.57,36.4 75.31,36.4 75.18,36.53 75.18,36.97 75.06,37.1 74.8,37.1 74.68,36.97 74.68,36.53 74.55,36.4 74.3,36.4 74.17,36.53 74.17,36.97 74.04,37.1 73.79,37.1 73.66,36.97 73.66,36.53 73.53,36.4 73.28,36.4 73.15,36.53 73.15,36.97 73.03,37.1 72.77,37.1 72.64,36.97 72.64,36.53 72.52,36.4 71.3,36.4 70.6,37.1 66.93,37.1 65.89,36.06 61.47,36.06 59.7,37.83 57.71,37.83 56.78,38.76 55.78,38.76 55.65,38.89 v1(55.65,39.36)
  BOTTOM w0.089: U0400.AU30 107.78,50.13 v3(107.46,50.46)
  BOTTOM w0.102: CON2100.207 56.12,39.82 v1(55.65,39.36)
M_B_D43: length 69.3
  TOP w0.102: v1(54.38,39.33) 54.38,39.91 v2(54.48,40.01)
  IN3 w0.076: 107.07,50.08 107.74,50.08 v3(108.09,50.43)
  IN3 w0.097: 107.07,50.08 106.32,50.83 105.89,50.83 104.38,49.32 103.24,49.32 103.1,49.18 102.82,49.18 102.82,49.17 98.48,49.17 98.06,48.76 96.6,48.76 93.91,48.76 86.05,40.9 82.5,40.9 77.65,36.05 71.17,36.05 70.46,36.76 67.07,36.76 66.03,35.72 61.33,35.72 59.55,37.49 57.56,37.49 56.64,38.42 55.55,38.42 55.23,38.74 54.92,38.74 54.59,38.42 54.42,38.42 53.83,39.01 53.83,39.2 53.96,39.33 v1(54.38,39.33)
  BOTTOM w0.089: v3(108.09,50.43) 108.09,50.34 U0400.AT30
  BOTTOM w0.102: CON2100.203 55.52,40.82 54.38,39.69 v1(54.38,39.33)
M_B_D44: length 71.1
  TOP w0.102: v2(53.19,43.57) v1(52.43,43.57)
  IN3 w0.076: 106.98,52.2 107.21,51.96 108.38,51.96 v3(108.72,52.3)
  IN3 w0.097: 106.98,52.2 105.64,52.2 104.42,50.98 98.02,50.98 97.96,51.04 92.94,51.04 91.03,49.12 90.88,49.12 90.83,49.12 84.9,43.19 81.85,43.19 77.61,38.96 69.73,38.96 69.33,39.36 66.6,39.36 66.41,39.17 66.37,39.17 65.53,38.32 62.24,38.32 60.87,39.69 58.48,39.69 56.68,41.49 53.15,41.49 52.72,41.93 52.1,41.93 51.97,42.05 51.97,43.12 v1(52.43,43.57)
  BOTTOM w0.089: v3(108.72,52.3) 108.72,52.19 U0400.AR33
  BOTTOM w0.102: CON2100.194 51.93,43.07 v1(52.43,43.57)
M_B_D45: length 72.1
  TOP w0.102: v1(51.18,43.6) 51.18,43.31 v2(51.47,43.02)
  IN3 w0.076: v3(109.36,52.3) 108.91,51.85 108.56,51.85 108.48,51.77 107.14,51.77
  IN3 w0.097: 107.14,51.77 106.99,51.92 105.66,51.92 104.52,50.78 98.04,50.78 97.96,50.7 93.09,50.7 91.17,48.78 91.03,48.78 90.97,48.78 85.04,42.85 81.95,42.85 77.71,38.61 69.59,38.61 69.19,39.02 66.74,39.02 66.34,38.61 66.3,38.61 65.67,37.98 65.39,37.98 62.1,37.98 60.73,39.35 58.34,39.35 56.54,41.15 53.01,41.15 52.57,41.58 51.21,41.58 50.39,42.4 50.39,42.81 v1(51.18,43.6)
  BOTTOM w0.089: U0400.AP33 109.36,52.2 v3(109.36,52.3)
  BOTTOM w0.102: v1(51.18,43.6) 50.71,44.07 CON2100.190
M_B_D46: length 70.2
  TOP w0.102: v2(52.73,39.96) 52.55,39.78 v1(52.55,39.08)
  IN3 w0.076: 105.26,49.89 108.16,49.89 v3(108.72,50.45)
  IN3 w0.097: 105.26,49.89 103.91,48.54 103.35,48.54 103.07,48.82 98.45,48.82 98.04,48.41 96.46,48.41 94.05,48.41 86.13,40.49 82.54,40.49 77.75,35.7 71.03,35.7 70.32,36.41 67.21,36.41 66.17,35.37 61.19,35.37 59.41,37.15 57.42,37.15 56.5,38.07 54.28,38.07 53.53,38.82 53.53,38.83 53.28,39.08 v1(52.55,39.08)
  BOTTOM w0.089: U0400.AR30 108.72,50.36 v3(108.72,50.45)
  BOTTOM w0.102: CON2100.204 51.06,40.57 v1(52.55,39.08)
M_B_D47: length 71.8
  TOP w0.102: v1(51.33,39.08) 52.23,38.18 v2(52.58,38.18)
  IN3 w0.076: 105.38,49.7 108.26,49.7
  IN3 w0.097: v1(51.33,39.08) 51.33,38.61 51.46,38.48 52.01,38.48 52.18,38.66 53.21,38.66 54.14,37.73 56.35,37.73 57.28,36.81 59.27,36.81 61.05,35.03 66.32,35.03 66.84,35.55 67.87,35.55 67.87,35.55 68.82,35.55 69.34,36.07 70.17,36.07 70.89,35.36 77.85,35.36 82.64,40.15 86.27,40.15 94.06,47.93 98.02,47.93 98.65,48.57 102.95,48.57 103.23,48.29 103.96,48.29 105.38,49.7 ; 108.26,49.7 108.57,50.01 108.91,50.01 v3(109.36,50.45)
  BOTTOM w0.089: v3(109.36,50.45) 109.36,50.37 U0400.AP30
  BOTTOM w0.102: v1(51.33,39.08) 50.84,39.57 CON2100.208
M_B_D48: length 72.4
  TOP w0.102: v1(51.4,37.29) 51.4,37.45 v2(50.83,38.03)
  IN3 w0.076: 105.59,48.3 106.23,48.94 107.8,48.94 v3(108.1,48.65)
  IN3 w0.097: 105.59,48.3 105.03,47.74 104.77,47.48 104.57,47.28 104.38,47.09 104.17,47.09 104.17,47.09 99.82,47.09 99,46.27 95.51,46.27 95.5,46.26 95.48,46.26 94.08,44.86 93.43,44.21 93.43,44.21 87.06,37.84 82.51,37.84 77.98,33.31 66.86,33.31 66.3,32.75 65.43,32.75 65.24,32.55 63.81,32.55 63.71,32.55 63.71,32.55 61.17,32.55 58.58,35.14 55.97,35.14 55.27,35.85 54.47,35.85 54.46,35.84 53.19,35.84 52.74,36.29 52.74,36.3 52.23,36.81 50.57,36.81 50.28,37.1 50.28,37.43 50.6,37.75 50.94,37.75 v1(51.4,37.29)
  BOTTOM w0.089: v3(108.1,48.65) 108.1,48.48 U0400.AU27
  BOTTOM w0.102: CON2100.216 50.29,37.57 50.47,37.76 51.08,37.76 51.4,37.44 v1(51.4,37.29)
M_B_D49: length 73.3
  TOP w0.102: v2(53.7,36.78) 53.35,37.13 v1(52.62,37.13)
  IN3 w0.076: v3(108.73,48.66) 108.51,48.87 108.45,48.87 108.19,49.13 106.09,49.13
  IN3 w0.097: 106.09,49.13 104.28,47.32 99.71,47.32 99,46.61 95.37,46.61 95.35,46.6 95.33,46.6 93.94,45.2 93.29,44.55 93.29,44.55 86.88,38.15 84.95,38.15 83.41,38.15 82.38,38.15 77.88,33.65 66.43,33.65 66.17,33.39 63.17,33.39 62.68,32.9 61.31,32.9 58.72,35.49 56.11,35.49 55.41,36.19 55.12,36.19 53.55,36.19 53.34,36.4 53.34,37.63 52.95,38.02 52.45,38.02 52.35,37.92 52.35,37.72 52.62,37.45 v1(52.62,37.13)
  BOTTOM w0.089: U0400.AT27 108.73,48.46 v3(108.73,48.66)
  BOTTOM w0.102: CON2100.212 51.99,38.57 52.62,37.95 v1(52.62,37.13)
M_B_D50: length 70.9
  TOP w0.102: v2(54.42,32.89) v1(54.42,33.58)
  IN3 w0.076: 106.08,47.25 107.92,47.25 108.05,47.37 v3(108.05,47.68)
  IN3 w0.097: v1(54.42,33.58) 53.87,33.58 53.75,33.45 53.75,33.17 53.87,33.05 57.24,33.05 58.3,31.99 59.05,31.99 59.3,31.75 59.3,30.99 59.91,30.38 66.52,30.38 67.03,30.89 69.63,30.89 69.75,30.76 69.75,30.5 69.88,30.37 70.13,30.37 70.26,30.5 70.26,30.76 70.39,30.89 71.35,30.89 71.35,30.89 78.06,30.89 83.24,36.07 87.91,36.07 94.12,42.27 94.48,42.27 95.51,43.29 95.51,43.29 96.23,44.01 102.24,44.01 102.51,44.28 103,44.28 103.15,44.43 104.13,44.43 104.63,44.93 104.63,45.8 105.95,47.11 106.08,47.25
  BOTTOM w0.089: v3(108.05,47.68) 108.05,47.64 U0400.AT25
  BOTTOM w0.102: CON2100.225 56.23,35.32 55.58,34.67 55.09,34.67 54.42,34 v1(54.42,33.58)
M_B_D51: length 70.3
  TOP w0.102: v2(56.29,33.12) 56.3,33.12 v1(55.64,33.78)
  IN3 w0.097: v3(107.46,47.61) 107.28,47.43 106.18,47.43 106.17,47.44 105.99,47.44 105.74,47.2 105.41,46.87 104.42,45.88 104.42,45.88 104.4,45.86 104.4,45.03 104.01,44.63 103.05,44.63 102.9,44.48 102.43,44.48 102.2,44.25 99.96,44.25 99.83,44.38 99.83,44.78 99.7,44.91 99.45,44.91 99.32,44.78 99.32,44.45 99.2,44.33 98.87,44.33 98.79,44.4 98.79,44.63 98.66,44.75 98.41,44.75 98.28,44.63 98.28,44.4 98.21,44.33 97.85,44.33 97.77,44.4 97.77,44.63 97.65,44.75 97.39,44.75 97.27,44.63 97.27,44.45 97.14,44.33 96.06,44.33 95.36,43.63 94.34,42.61 93.97,42.61 87.74,36.38 83.11,36.38 78.29,31.56 78.02,31.56 77.8,31.78 77.57,31.78 77.48,31.68 77.48,31.36 77.35,31.23 75.78,31.23 75.49,31.52 75.06,31.52 74.77,31.23 73.48,31.23 73.21,31.5 72.89,31.5 72.62,31.23 71.21,31.23 71.21,31.23 69.61,31.23 69.34,31.5 69.11,31.5 68.85,31.23 68.62,31.23 68.38,31.47 68.15,31.47 67.91,31.23 67.63,31.23 67.39,31.47 67.17,31.47 66.93,31.23 66.87,31.23 66.87,31.23 66.36,30.73 62.17,30.73 62.04,30.85 62.04,30.91 61.92,31.04 61.66,31.04 61.54,30.91 61.54,30.85 61.41,30.73 61.15,30.73 61.03,30.85 61.03,30.91 60.9,31.04 60.65,31.04 60.52,30.91 60.52,30.85 60.39,30.73 60.05,30.73 59.74,31.03 59.74,31.21 59.96,31.43 59.96,31.61 58.75,32.82 58.57,32.82 58.35,32.61 58.17,32.61 57.99,32.79 57.99,32.97 58.21,33.18 58.21,33.36 57.97,33.61 57,33.61 56.78,33.39 55.76,33.39 55.64,33.51 v1(55.64,33.78)
  BOTTOM w0.089: v3(107.46,47.61) 107.46,47.57 U0400.AU25
  BOTTOM w0.102: v1(55.64,33.78) 55.64,33.83 56.14,34.32 CON2100.229
M_B_D52: length 73.6
  TOP w0.102: v2(55.19,37.7) 54.98,37.7 v1(54.33,37.05)
  IN3 w0.076: v3(109.4,48.54) 108.89,49.05 108.54,49.05 108.27,49.32 105.96,49.32
  IN3 w0.097: 105.96,49.32 104.2,47.56 103.8,47.56 99.58,47.56 98.97,46.95 95.22,46.95 95.21,46.94 95.19,46.94 93.79,45.54 93.15,44.9 87.7,39.45 87.52,39.45 87.48,39.5 87.3,39.5 87.12,39.32 87.12,39.14 87.16,39.09 87.16,38.91 86.74,38.49 86.27,38.49 86.14,38.62 86.14,38.85 86.01,38.98 85.76,38.98 85.63,38.85 85.63,38.62 85.5,38.49 85.25,38.49 85.12,38.62 85.12,38.85 85,38.98 84.74,38.98 84.62,38.85 84.62,38.62 84.49,38.49 84.23,38.49 84.11,38.62 84.11,38.85 83.98,38.98 83.73,38.98 83.6,38.85 83.6,38.62 83.47,38.49 82.28,38.49 77.78,34 66.29,34 66.13,33.84 62.2,33.84 62.08,33.71 62.08,33.53 61.95,33.4 61.7,33.4 61.57,33.53 61.57,33.71 61.44,33.84 60.86,33.84 58.86,35.83 56.41,35.83 55.94,36.3 55.93,36.3 55.7,36.53 54.98,36.53 54.98,36.53 53.88,36.53 53.71,36.7 53.71,36.93 53.84,37.05 v1(54.33,37.05)
  BOTTOM w0.076: U0400.AP27 109.4,48.5 v3(109.4,48.54)
  BOTTOM w0.102: v1(54.33,37.05) 54.33,38.02 55.14,38.82 CON2100.211
M_B_D53: length 73.5
  TOP w0.102: v3(110.04,48.54) 110.04,48.79 v2(109.73,49.1)
  IN3 w0.076: v3(110.04,48.54) 109.34,49.24 108.62,49.24 108.35,49.51 105.83,49.51
  IN3 w0.097: v1(55.63,37.1) 55.83,36.89 55.83,36.88 56.07,36.64 56.08,36.64 56.55,36.17 59.01,36.17 61,34.18 65.99,34.18 66.15,34.34 69.37,34.34 69.49,34.47 69.49,34.6 69.62,34.72 69.88,34.72 70,34.6 70,34.47 70.13,34.34 70.38,34.34 70.51,34.47 70.51,34.6 70.64,34.72 70.89,34.72 71.02,34.6 71.02,34.47 71.15,34.34 71.4,34.34 71.53,34.47 71.53,34.6 71.65,34.72 71.91,34.72 72.03,34.6 72.03,34.47 72.16,34.34 72.42,34.34 72.54,34.47 72.54,34.6 72.67,34.72 72.92,34.72 73.05,34.6 73.05,34.47 73.18,34.34 73.43,34.34 73.56,34.47 73.56,34.6 73.69,34.72 73.94,34.72 74.07,34.6 74.07,34.47 74.19,34.34 74.45,34.34 74.57,34.47 74.57,34.6 74.7,34.72 74.96,34.72 75.08,34.6 75.08,34.47 75.21,34.34 75.46,34.34 75.59,34.47 75.59,34.6 75.72,34.72 75.97,34.72 76.1,34.6 76.1,34.47 76.23,34.34 76.48,34.34 76.61,34.47 76.61,34.6 76.73,34.72 76.99,34.72 77.11,34.6 77.11,34.47 77.24,34.34 77.68,34.34 82.86,39.52 86.01,39.52 86.54,39.51 87.23,40.21 87.41,40.21 87.49,40.13 87.67,40.13 87.85,40.31 87.85,40.49 87.77,40.57 87.77,40.75 87.95,40.93 88.13,40.93 88.32,40.74 88.5,40.74 88.68,40.92 88.68,41.1 88.49,41.29 88.49,41.47 88.67,41.65 88.85,41.65 89.04,41.45 89.22,41.45 89.4,41.63 89.4,41.81 89.21,42.01 89.21,42.19 89.39,42.36 89.57,42.36 89.76,42.17 89.94,42.17 90.12,42.35 90.12,42.53 89.93,42.72 89.93,42.9 90.11,43.08 90.29,43.08 90.48,42.89 90.66,42.89 90.84,43.07 90.84,43.25 90.65,43.44 90.65,43.62 90.83,43.8 91.01,43.8 91.2,43.61 91.38,43.61 95.06,47.3 98.79,47.3 99.28,47.79 99.48,47.79 104.1,47.79 105.83,49.51
  BOTTOM w0.076: U0400.AN27 110.38,48.17 110.04,48.52 v3(110.04,48.54)
  BOTTOM w0.102: v1(55.63,37.1) 55.63,37.68 55.77,37.82 CON2100.215
M_B_D54: length 74.3
  TOP w0.102: v2(53,33.91) 52.56,33.91 v1(51.36,35.11)
  IN3 w0.076: 106.34,46.86 108.86,46.86 109.21,47.21 109.69,47.21 v3(110.06,46.84)
  IN3 w0.097: 106.34,46.86 105.09,45.61 105.09,44.74 104.34,44 103.33,44 103.22,43.88 102.67,43.88 102.41,43.62 101.04,43.62 100.76,43.33 96.52,43.33 95.79,42.61 94.77,41.58 94.4,41.58 88.26,35.44 83.5,35.44 78.26,30.2 77.83,30.2 72.42,30.2 71.87,29.66 62.84,29.66 62.82,29.67 59.65,29.67 57.01,32.31 53.35,32.31 51.97,33.69 51.97,34.51 v1(51.36,35.11)
  BOTTOM w0.089: v3(110.06,46.84) 110.06,46.93 U0400.AN25
  BOTTOM w0.102: CON2100.228 50.82,34.57 v1(51.36,35.11)
M_B_D55: length 72.8
  TOP w0.102: v2(52.02,35.4) 51.87,35.4 v1(51.44,35.84)
  IN3 w0.076: 106.21,47.05 108.72,47.05 109.07,47.41 109.71,47.41 v3(110.01,47.7)
  IN3 w0.097: v1(51.44,35.84) 52.31,34.97 52.31,34.17 53.79,32.69 57.11,32.69 59.78,30.03 68.86,30.03 68.86,30.02 69.21,30.02 71.76,30.03 72.28,30.55 77.97,30.55 77.97,30.55 78.16,30.55 83.37,35.75 88.09,35.75 94.26,41.93 94.63,41.93 95.65,42.95 96.37,43.67 100.72,43.67 100.87,43.81 102.32,43.81 102.59,44.08 103.11,44.08 103.25,44.22 104.25,44.22 104.86,44.84 104.86,45.7 105.72,46.56 106.18,47.02 106.21,47.05
  BOTTOM w0.089: v3(110.01,47.7) 110.01,47.53 U0400.AP25
  BOTTOM w0.102: CON2100.224 51.02,35.57 51.28,35.84 v1(51.44,35.84)
M_B_D56: length 74.8
  TOP w0.102: v1(51.33,34.07) v2(51.33,33.43)
  IN3 w0.076: v3(108.71,45.87) 108.31,46.28 107.26,46.28
  IN3 w0.097: v1(51.33,34.07) 50.89,34.51 50.46,34.51 50.3,34.36 50.3,33.68 50.43,33.56 51.21,33.56 53.46,31.3 54.29,31.3 55.01,30.58 56.87,30.58 59.71,27.74 66.39,27.74 66.45,27.8 68.9,27.8 69.42,28.32 78.12,28.32 84.01,34.21 89.11,34.21 92.48,37.59 93.63,37.59 98.05,42.01 101.17,42.01 101.47,42.32 104.42,42.32 105.07,42.97 105.07,43.55 106.43,44.9 106.43,45.44 107.26,46.28
  BOTTOM w0.089: U0400.AT22 108.48,45.47 108.69,45.68 108.73,45.72 108.73,45.85 v3(108.71,45.87)
  BOTTOM w0.102: CON2100.232 50.84,33.57 v1(51.33,34.07)
M_B_D57: length 74.7
  TOP w0.102: v1(51.33,32.04) 52.41,32.04 v2(52.53,32.16)
  IN3 w0.097: v3(108.1,45.91) 107.92,45.72 107.86,45.72 107.56,45.42 107.24,45.42 107.09,45.57 106.85,45.57 106.65,45.37 106.65,44.81 105.3,43.45 105.3,42.89 104.45,42.04 101.55,42.04 101.19,41.68 98.21,41.68 93.77,37.24 92.62,37.24 89.28,33.9 84.14,33.9 78.21,27.97 71.16,27.97 70.44,27.97 70.43,27.97 70.31,27.97 69.14,26.8 67.8,26.8 67.23,27.37 59.59,27.37 57.1,29.87 56.73,30.24 54.91,30.24 54.16,30.99 53.34,30.99 52.87,31.45 50.52,31.45 50.28,31.69 50.28,32.45 50.42,32.59 50.78,32.59 v1(51.33,32.04)
  BOTTOM w0.089: v3(108.1,45.91) 108.1,45.74 U0400.AU22
  BOTTOM w0.102: CON2100.236 50.8,32.57 v1(51.33,32.04)
M_B_D58: length 73.4
  TOP w0.102: v2(56.08,29.54) 56.08,29.27 v1(55.66,28.85)
  IN3 w0.097: v1(55.66,28.85) 56.08,28.43 56.43,28.43 58.7,26.16 58.7,25.73 58.55,25.58 58.55,25.27 59.53,24.3 61.84,24.3 62.51,24.97 63.95,24.97 64.59,25.62 65.49,25.62 65.75,25.88 66.58,25.88 67.18,25.29 69.71,25.29 70.88,26.45 71.63,26.45 78.75,26.45 84.74,32.44 89.96,32.44 91.1,33.58 91.73,33.58 91.97,33.83 91.97,34.35 93.14,35.52 94.19,35.52 94.56,35.89 94.74,35.89 95.14,35.49 95.32,35.49 95.5,35.67 95.5,35.85 95.1,36.25 95.1,36.43 95.28,36.61 95.46,36.61 96.12,35.95 96.3,35.95 96.48,36.13 96.48,36.31 95.82,36.97 95.82,37.15 96,37.33 96.18,37.33 96.66,36.85 96.89,36.85 97.02,36.98 97.02,37.21 96.54,37.69 96.54,37.87 98.64,39.97 100.85,39.97 102.21,41.33 104.75,41.33 107.03,43.61 107.62,43.61 108.16,44.16 v3(108.16,44.92)
  BOTTOM w0.076: v3(108.16,44.92) 108.16,44.89 U0400.AU21
  BOTTOM w0.102: v1(55.66,28.85) 56.14,29.32 CON2100.249
M_B_D59: length 74
  TOP w0.102: v1(54.44,28.85) v2(54.44,28.2)
  IN3 w0.097: v1(54.44,28.85) 54.44,28.73 55.58,27.59 56.52,27.59 57.2,26.9 57.2,26.16 59.38,23.99 62.01,23.99 62.68,24.66 64.08,24.66 64.69,25.28 65.63,25.28 65.77,25.41 66.56,25.41 67.03,24.94 69.82,24.94 70.99,26.11 71.49,26.11 71.49,26.11 78.85,26.11 84.87,32.13 90.14,32.13 91.28,33.27 91.94,33.27 92.32,33.64 92.32,34.21 93.29,35.18 95.45,35.18 95.78,35.51 96.37,35.51 96.7,35.18 97.03,35.18 97.33,35.49 97.33,38.18 98.78,39.63 101.32,39.63 101.57,39.88 101.57,40.39 102.31,41.13 104.86,41.13 106.54,42.8 107.67,42.8 108.75,43.88 v3(108.75,44.92)
  BOTTOM w0.076: U0400.AT21 108.75,44.82 v3(108.75,44.92)
  BOTTOM w0.102: CON2100.245 55.72,30.32 54.44,29.04 v1(54.44,28.85)
M_B_D60: length 76.9
  TOP w0.102: v1(55.6,31.75) 56.01,31.35 56.74,31.35 v2(56.82,31.42)
  IN3 w0.076: v3(110.75,45.94) 110.5,46.19 110.22,46.47 109.11,46.47 108.91,46.67 106.99,46.67
  IN3 w0.097: v1(55.6,31.75) 55.6,31.42 55.75,31.27 55.98,31.27 55.98,31.27 57.15,31.27 59,29.42 60.02,28.4 60.36,28.4 60.49,28.53 60.49,28.91 60.62,29.03 60.87,29.03 61,28.91 61,28.53 61.13,28.4 61.38,28.4 61.51,28.53 61.51,28.91 61.63,29.03 61.89,29.03 62.02,28.91 62.02,28.53 62.14,28.4 62.38,28.4 62.46,28.48 62.46,28.73 62.54,28.81 62.81,28.81 62.89,28.73 62.89,28.5 62.99,28.4 64.82,28.4 64.9,28.48 64.91,28.48 65.15,28.71 65.15,28.73 65.44,29.02 68.14,29.02 68.26,28.9 68.26,28.63 68.39,28.5 68.64,28.5 68.77,28.63 68.77,28.9 68.9,29.02 72.68,29.02 72.81,29.15 72.81,29.44 72.94,29.57 73.19,29.57 73.32,29.44 73.32,29.15 73.44,29.02 73.7,29.02 73.82,29.15 73.82,29.44 73.95,29.57 74.21,29.57 74.33,29.44 74.33,29.15 74.46,29.02 74.71,29.02 74.84,29.15 74.84,29.44 74.97,29.57 75.22,29.57 75.35,29.44 75.35,29.15 75.48,29.02 75.73,29.02 75.86,29.15 75.86,29.44 75.98,29.57 76.24,29.57 76.36,29.44 76.36,29.15 76.49,29.02 76.75,29.02 76.87,29.15 76.87,29.44 77,29.57 77.25,29.57 77.38,29.44 77.38,29.15 77.51,29.02 77.76,29.02 77.89,29.15 77.89,29.44 78.02,29.57 78.48,29.57 83.75,34.84 88.55,34.84 94.66,40.95 95.51,40.95 97.23,42.67 101.14,42.67 101.19,42.73 102.31,42.73 103,43.41 103.89,43.41 104.16,43.69 104.59,43.69 105.89,44.99 105.89,45.57 106.99,46.67
  BOTTOM w0.089: U0400.AN22 110.38,45.58 v3(110.75,45.94)
  BOTTOM w0.102: CON2100.237 55.82,32.32 55.6,32.11 v1(55.6,31.75)
M_B_D61: length 76.3
  TOP w0.102: v2(54.94,31.04) 54.94,31.09 v1(54.33,31.7)
  IN3 w0.076: 107,46.35 107.13,46.48 108.83,46.48 109.03,46.27 109.96,46.27 110.08,46.15 v3(110.08,45.9)
  IN3 w0.097: 107,46.35 106.12,45.47 106.12,44.91 104.67,43.46 104.24,43.46 103.99,43.21 103.1,43.21 102.41,42.52 101.34,42.52 101.16,42.34 97.9,42.34 95.74,40.18 95.56,40.18 95.25,40.49 95.05,40.49 94.87,40.31 94.87,40.13 95.19,39.81 95.19,39.63 95.02,39.46 94.84,39.46 94.4,39.9 94.23,39.9 94.05,39.72 94.05,39.54 94.31,39.27 94.48,39.1 94.48,38.92 94.3,38.74 94.12,38.74 93.69,39.18 93.48,39.18 93.31,39.01 93.31,38.83 93.76,38.38 93.76,38.2 93.59,38.03 93.41,38.03 93.04,38.4 92.81,38.4 88.93,34.52 83.88,34.52 78.03,28.68 69.29,28.68 68.76,28.15 66.31,28.15 66.22,28.06 65.91,28.06 65.81,28.15 65.81,28.3 65.72,28.4 65.52,28.4 65.43,28.3 65.43,28.15 65.33,28.06 59.88,28.06 57.79,30.15 57.01,30.93 55.11,30.93 v1(54.33,31.7)
  BOTTOM w0.089: v3(110.08,45.9) 110.08,45.77 U0400.AP22
  BOTTOM w0.102: v1(54.33,31.7) 54.33,32.59 54.69,32.95 56.19,32.95 56.56,33.32 CON2100.233
M_B_D62: length 75.9
  TOP w0.102: v2(52.62,28.95) 52.55,29.01 v1(52.55,29.6)
  IN3 w0.097: v3(110.03,44.96) 110.03,44.8 107.65,42.42 107.65,41.99 107.49,41.84 106.58,41.84 105.23,40.49 105.23,38.73 100.98,34.47 98.73,34.47 98.36,34.84 93.82,34.84 93.18,34.2 93.18,33.91 92.22,32.96 91.45,32.96 90.31,31.82 85,31.82 78.97,25.78 71.11,25.78 69.95,24.63 69.56,24.63 68.63,23.7 65.83,23.7 65.18,24.35 62.83,24.35 62.05,23.57 59.33,23.57 56.85,26.06 56.43,26.06 52.98,29.52 52.64,29.52 v1(52.55,29.6)
  BOTTOM w0.089: U0400.AP21 109.73,44.67 v3(110.03,44.96)
  BOTTOM w0.102: v1(52.55,29.6) 52.08,30.07 CON2100.246
M_B_D63: length 77.1
  TOP w0.102: v2(50.8,28.93) 51.33,29.47 v1(51.33,29.6)
  IN3 w0.097: v1(51.33,29.6) 51.75,29.19 52.48,29.19 56.53,25.13 56.53,24.37 57.64,23.26 65.11,23.26 65.17,23.33 65.67,23.33 65.74,23.26 68.63,23.26 69.69,24.32 70.08,24.32 71.23,25.47 76.35,25.47 76.45,25.37 76.45,25.34 76.55,25.25 76.74,25.25 76.84,25.34 76.84,25.37 76.93,25.47 77.12,25.47 77.22,25.37 77.22,25.34 77.32,25.25 77.51,25.25 77.61,25.34 77.61,25.37 77.7,25.47 79.1,25.47 85.13,31.5 90.48,31.5 91.62,32.64 92.35,32.64 93.32,33.61 93.74,33.61 94.03,33.9 94.03,34.2 94.33,34.5 98.22,34.5 98.59,34.13 101.08,34.13 105.54,38.59 105.54,38.92 107.09,40.46 107.42,40.46 108.41,41.46 108.41,42.85 110.07,44.52 110.15,44.52 v3(110.64,45.01)
  BOTTOM w0.089: U0400.AN21 110.64,44.76 v3(110.64,45.01)
  BOTTOM w0.102: CON2100.250 50.32,29.07 50.43,29.19 50.92,29.19 v1(51.33,29.6)
M_B_DIM0_CKE0: length 67.8
  TOP w0.165: v1(55.04,67.86) v2(55.04,67.22)
  IN3 w0.076: v3(109.9,65.08) 109.51,64.7 107.04,64.7 106.83,64.49
  IN3 w0.152: v1(55.04,67.86) 55.2,68.01 55.2,68.04 55.48,68.33 56.67,68.33 56.87,68.53 56.87,68.88 57.06,69.07 57.87,69.07 58.06,68.88 58.06,68.53 58.26,68.33 59.82,68.33 60.3,68.81 60.97,68.81 61.69,68.1 70.75,68.1 70.95,68.29 83.78,68.29 84.47,68.99 96.45,68.99 97.52,67.91 98.21,67.22 100.84,67.22 101.74,68.13 103.71,68.13 104.19,67.64 104.19,67.11 105.77,65.53 105.77,64.92 106.2,64.49 106.83,64.49
  BOTTOM w0.089: U0400.AN56 109.93,65.08 v3(109.9,65.08)
  BOTTOM w0.165: CON2100.109 56.16,66.32 55.73,66.75 54,66.75 53.87,66.88 53.87,67.73 54,67.86 v1(55.04,67.86)
M_B_DIM0_CKE1: length 70
  TOP w0.165: v2(51.51,68.23) 51.28,68 v1(51.28,67.12)
  IN3 w0.076: v3(110.2,64.16) 110.2,64.63 110.27,64.71 110.27,65.24 110.05,65.46 109.71,65.46 109.21,64.96 106.96,64.96
  IN3 w0.152: 106.96,64.96 104.6,67.32 104.6,67.69 103.84,68.45 101.64,68.45 100.89,67.7 98.41,67.7 98,68.11 98,68.11 96.51,69.6 84.4,69.6 83.58,68.77 70.75,68.77 70.55,68.58 62.24,68.58 61.26,69.55 55.49,69.55 53.28,67.35 53.28,67.06 52.69,66.47 51.94,66.47 v1(51.28,67.12)
  BOTTOM w0.089: v3(110.2,64.16) 110.19,64.16 U0400.AP55
  BOTTOM w0.165: CON2100.110 50.35,66.07 51.28,67.01 v1(51.28,67.12)
M_B_DIM0_CLK0: length 72
  IN3 w0.076: v3(109.93,58.68) 109.93,58.45 109.8,58.32 107.14,58.32 107.12,58.34
  IN3 w0.109: v5(53.16,56.25) 53.41,56.49 53.41,56.83 53.71,57.13 54.3,57.13 55.37,56.07 63.72,56.07 64.18,55.61 69.51,55.61 69.91,56.01 70.66,56.01 71.04,55.62 71.4,55.62 71.79,56.02 72.58,56.02 72.97,55.62 73.68,55.62 75.89,57.84 76.73,57.84 77,57.57 77,56.19 77.15,56.04 77.62,56.04 77.8,56.22 77.8,57.66 78.09,57.95 79.17,57.95 80.54,59.32 97.93,59.32 98.83,58.42 103.02,58.42 103.37,58.07 105.2,58.07 105.75,58.63 106.83,58.63 107.12,58.34
  BOTTOM w0.102: U0400.AP45 109.93,58.42 v3(109.93,58.68) ; v5(53.16,56.25) 53.43,56.52 53.43,56.72 53.7,56.99 53.7,57.14 53.37,57.47 53.37,57.79 53.77,58.19 54.08,58.19 54.42,57.86 54.57,57.86 55.8,59.08 56.34,59.08 56.58,59.32 CON2100.137
M_B_DIM0_CLK1: length 71
  IN3 w0.076: v3(109.35,59.58) 109.47,59.46 109.47,59.26 109.35,59.13 109.14,59.13 109.04,59.24 107.88,59.24 107.85,59.26
  IN3 w0.109: 107.85,59.26 107.74,59.37 105.52,59.37 104.86,58.71 103.75,58.71 103.5,58.96 99.06,58.96 97.94,60.07 80.2,60.07 78.8,58.68 75.7,58.68 73.92,56.9 73.37,56.9 73.37,56.9 69.19,56.9 69.07,56.78 68.79,56.5 67.38,56.5 67.07,56.8 55.69,56.8 54.58,57.91 53.19,57.91 53.11,57.99 52.56,57.99 52.01,57.44 52.01,57.15 51.82,56.96 49.83,56.96 49.66,57.13 49.66,57.49 49.78,57.62 51.37,57.62 51.77,58.02 51.77,58.2 v1(52.14,58.57)
  BOTTOM w0.102: v3(109.35,59.58) 109.35,59.52 U0400.AP46 ; CON2100.138 51.64,59.07 v1(52.14,58.57)
M_B_DIM0_CLK#0: length 71.9
  IN3 w0.076: 106.97,58.19 106.98,58.18 107,58.18 107.04,58.14 107.17,58.14 109.88,58.14 110.01,58.27 110.11,58.27 110.31,58.47 110.41,58.47 v3(110.64,58.7)
  IN3 w0.109: 106.97,58.19 106.74,58.42 105.84,58.42 105.28,57.86 103.28,57.86 102.94,58.21 98.74,58.21 97.85,59.11 80.62,59.11 79.25,57.74 78.18,57.74 78.01,57.57 78.01,56.36 78.01,56.36 78.01,56.19 78.01,56.14 77.71,55.83 77.06,55.83 76.79,56.1 76.79,57.48 76.65,57.63 75.98,57.63 73.76,55.41 72.88,55.41 72.49,55.81 71.88,55.81 71.49,55.41 70.95,55.41 70.57,55.8 70,55.8 69.6,55.4 64.09,55.4 63.63,55.86 55.28,55.86 54.21,56.92 53.8,56.92 53.62,56.75 53.62,56.47 v1(53.86,56.23)
  BOTTOM w0.102: CON2100.139 56.57,58.82 56.52,58.88 55.88,58.88 54.66,57.66 54.33,57.66 54,57.99 53.86,57.99 53.57,57.71 53.57,57.55 53.91,57.22 53.91,56.91 53.64,56.64 53.64,56.46 v1(53.86,56.23) ; v3(110.64,58.7) 110.38,58.44 U0400.AN45
M_B_DIM0_CLK#1: length 71
  IN3 w0.076: 107.7,59.11 107.71,59.11 107.73,59.11 107.77,59.07 107.79,59.07 107.8,59.06 108.97,59.06 109.07,58.96 109.45,58.96 109.69,59.19 109.69,59.33 v3(109.98,59.63)
  IN3 w0.109: 107.7,59.11 107.65,59.16 105.61,59.16 104.95,58.5 103.66,58.5 103.41,58.75 98.97,58.75 97.86,59.86 80.29,59.86 78.89,58.46 75.79,58.46 74.01,56.69 73.29,56.69 69.28,56.69 68.88,56.29 67.29,56.29 66.99,56.59 55.6,56.59 54.49,57.7 53.1,57.7 53.02,57.78 52.64,57.78 52.22,57.35 52.22,57.06 51.91,56.75 49.74,56.75 49.45,57.04 49.45,57.58 49.7,57.83 51.28,57.83 51.56,58.11 51.56,58.38 v1(51.41,58.53)
  BOTTOM w0.102: v1(51.41,58.53) 51.16,58.78 51.07,58.87 50.53,58.87 50.23,58.57 CON2100.140 ; v3(109.98,59.63) 109.98,59.54 U0400.AN46
M_B_DIM0_CS#0: length 72.2
  TOP w0.165: v1(52.68,51.55) 53.25,52.12 v2(53.34,52.12)
  IN3 w0.152: v1(81.33,50.19) 81.33,50.05 80.51,49.23 76.78,49.23 75.61,48.07 73.06,48.07 72.43,47.44 70.97,47.44 70.69,47.71 66.03,47.71 65.77,47.44 63.81,47.44 63.81,47.44 61.62,47.44 61.47,47.59 61.47,47.88 61.22,48.13 58.24,48.13 57.84,48.53 56.92,49.45 52.1,49.45 51.94,49.61 51.94,50.25 52.14,50.45 52.4,50.45 52.68,50.73 v1(52.68,51.55)
  BOTTOM w0.076: U0400.BB42 104.56,56.23 103.2,56.23
  BOTTOM w0.165: CON2100.149 56.09,54.32 55.05,53.28 54.81,53.28 54.45,52.92 53.89,52.92 52.68,51.72 v1(52.68,51.55) ; v1(81.33,50.19) 81.33,49.74 81.21,49.61 80.71,49.61 80.56,49.76 80.56,54.17 82.58,56.19 90.33,56.19 90.48,56.34 101.52,56.34 101.63,56.23 103.2,56.23
M_B_DIM0_CS#1: length 74.6
  TOP w0.165: v1(54.69,50.81) v2(55.43,50.07)
  IN3 w0.152: v1(54.69,50.81) 54.69,50.6 54.88,50.41 57.32,50.41 58.64,49.09 62.14,49.09 62.41,48.81 62.82,48.4 65.37,48.4 65.64,48.67 71.09,48.67 71.36,48.39 72.04,48.39 72.67,49.02 75.22,49.02 76.88,50.68 77.35,50.68 77.5,50.53 77.5,50.29 77.65,50.14 77.96,50.14 78.11,50.29 78.11,50.53 78.26,50.68 78.7,50.68 78.85,50.53 78.85,50.29 79,50.14 79.31,50.14 79.46,50.29 79.46,50.53 79.61,50.68 79.98,50.68 80.11,50.56 v1(80.11,50.19)
  BOTTOM w0.076: U0400.AY42 105.7,56.4 105.23,56.4 105.11,56.36 104.85,56.36 104.78,56.39 104.77,56.4 103.45,56.4 103.32,56.53
  BOTTOM w0.165: v1(80.11,50.19) 80.11,54.89 82.08,56.85 82.08,57.81 82.2,57.94 82.61,57.94 82.74,57.81 82.74,56.85 82.9,56.69 83.23,56.69 83.4,56.85 83.4,58.38 83.52,58.5 83.93,58.5 84.06,58.37 84.06,56.85 84.22,56.69 84.55,56.69 84.72,56.85 84.72,58.41 84.84,58.52 85.22,58.52 85.38,58.36 85.38,56.85 85.54,56.69 90.2,56.69 90.3,56.79 101.66,56.79 101.92,56.53 103.32,56.53 ; v1(54.69,50.81) 54.69,50.94 56.08,52.32 CON2100.157
M_B_DIM0_ODT0: length 73.3
  TOP w0.165: v1(53.44,50.81) 53.44,50.09 v2(53.67,49.86)
  IN3 w0.152: v1(81.81,50.8) 81.81,51.29 81.69,51.41 80.72,51.41 80.54,51.23 80.54,49.94 80.31,49.71 76.58,49.71 75.42,48.54 72.86,48.54 72.23,47.91 71.17,47.91 70.89,48.19 65.84,48.19 65.57,47.92 63.61,47.92 62.63,47.92 61.94,48.61 58.44,48.61 58.32,48.73 57.12,49.93 53.16,49.93 53.04,50.06 53.04,50.41 v1(53.44,50.81)
  BOTTOM w0.076: U0400.BA42 105.11,56.13 104.88,55.9 104.75,55.86 104.51,55.86 104.31,56.07 103.33,56.07 103.17,55.9
  BOTTOM w0.165: 103.17,55.9 90.67,55.9 90.45,55.68 v2(88.29,55.68) 84.94,55.68 83.9,54.63 83.67,54.63 82.76,55.54 82.58,55.54 82.3,55.25 82.3,55.07 83.2,54.17 83.2,53.93 82.96,53.7 82.73,53.7 81.86,54.58 81.68,54.58 81.39,54.29 81.39,54.11 82.26,53.23 82.26,53 81,51.74 81,50.93 81.13,50.8 v1(81.81,50.8) ; v1(53.44,50.81) 53.44,51.31 53.7,51.56 54.94,51.56 56.2,52.82 CON2100.155
M_B_DIM0_ODT1: length 74.8
  TOP w0.165: v2(55.96,48.26) 55.31,48.91 v1(55.3,48.91)
  IN3 w0.152: v1(55.3,48.91) 55.3,48.87 55.7,48.46 55.88,48.46 55.88,48.46 57.24,48.46 57.36,48.34 58.05,47.65 60.78,47.65 60.99,47.45 60.99,46.98 61.35,46.61 61.87,46.61 62.13,46.87 62.54,46.87 62.76,46.64 62.76,46.36 62.96,46.16 63.45,46.16 63.67,46.38 63.68,46.38 63.68,46.38 65.35,46.38 65.39,46.42 65.4,46.42 65.98,47.01 66.01,47.01 66.23,47.23 70.5,47.23 70.77,46.96 72.63,46.96 73.26,47.59 75.81,47.59 76.98,48.76 80.71,48.76 81.79,49.84 82.25,50.29 82.25,51.08 82.37,51.21 82.78,51.21 82.91,51.08 82.91,50.5 v1(83.21,50.19)
  BOTTOM w0.076: U0400.AW42 106.53,56.13 106.23,55.83 105.04,55.83 104.97,55.75 104.78,55.7 104.77,55.7 104.44,55.7 104.23,55.9 103.47,55.9 103.21,55.64 102.91,55.64 102.77,55.5
  BOTTOM w0.165: CON2100.161 55.45,51.32 55.14,51.02 55.14,49.06 v1(55.3,48.91) ; v1(83.21,50.19) 83.37,50.04 84.43,50.04 84.63,49.84 84.63,49.3 84.46,49.13 83.44,49.13 83.21,48.9 83.21,48.01 83.09,47.88 82.47,47.88 82.32,48.03 82.32,52.43 85.03,55.14 90.53,55.14 90.85,55.45 102.72,55.45 102.77,55.5
M_B_DQS0: length 77.8
  IN3 w0.122: v1(51.21,84.59) 51.75,84.05 52.29,84.05 52.43,83.91 53.31,83.91 53.59,84.19 53.59,85.07 53.72,85.2 54.34,85.2 54.64,84.9 55.33,84.9 55.66,85.23 56.64,85.23 57.29,84.58 60.14,84.58 61.32,83.4 62.52,83.4 62.89,83.02 65.63,83.02 66.15,83.54 71.64,83.54 72.13,84.03 105.34,84.03 111.84,77.53 111.84,74.34 112.45,73.74 112.45,70.26 112.14,69.95 112.14,69.5 v3(112.51,69.13)
  BOTTOM w0.109: U0400.AH65 112.7,69.22 112.6,69.22 v3(112.51,69.13) ; v1(51.21,84.59) 50.73,85.07 CON2100.34
M_B_DQS1: length 84.5
  IN3 w0.122: v1(114.38,75.67) 114.43,75.67 114.59,75.84 114.91,75.84 115.44,76.37 115.44,77.13 116.1,77.79 116.1,80.72 115.15,81.67 114.97,81.67 114.79,81.67 114.4,82.06 114.4,82.44 113.66,83.18 113.22,83.18 112.8,83.6 112.8,84.07 112.2,84.67 111.81,84.67 111.65,84.5 111.44,84.5 111.07,84.87 111.07,85.08 111.21,85.22 111.21,85.66 110.71,86.16 110.31,86.16 110.18,86.02 109.99,86.02 107.12,88.9 101.44,88.9 62.74,88.9 62.02,89.63 61.41,89.63 61.16,89.87 61.16,90.4 60.86,90.71 60.21,90.71 59.95,90.45 59.95,89.79 59.82,89.66 59.22,89.66 58.9,89.98 58.9,90.34 59.27,90.71 59.27,91.08 58.83,91.52 58.45,91.52 58.1,91.18 57.78,91.18 57.09,91.87 56.9,91.87 55.19,91.87 54.89,91.57 54.89,91.3 v1(54.73,91.14)
  BOTTOM w0.076: U0400.AG70 113.25,72.59 113.25,72.83 113.19,72.95 113.19,73.06 113.21,73.11 113.25,73.2 113.25,74.11 113.76,74.61 113.76,74.86 113.91,75.02
  BOTTOM w0.109: 113.91,75.02 113.91,75.64 114.07,75.79 114.25,75.79 v1(114.38,75.67) ; v1(54.73,91.14) 54.89,90.98 54.88,90.98 54.88,90.59 55.14,90.32 CON2100.13
M_B_DQS2: length 69.8
  IN3 w0.122: v3(108.74,69.62) 108.85,69.73 108.85,69.93 108.55,70.22 108.55,72.47 106.74,74.28 106.74,74.54 105.92,75.36 105.92,76.21 105.75,76.38 105.75,77.62 103.51,79.86 85.66,79.86 84.09,78.29 76.38,78.29 76.08,77.98 74.92,77.98 74.61,78.29 73.97,78.29 73.65,77.97 72.91,77.97 72.58,78.3 71.96,78.3 71.64,77.98 70.85,77.98 70.52,78.31 69.82,78.31 69.5,77.99 58.87,77.99 58.51,78.34 58.51,78.77 59.14,79.4 59.14,79.58 58.89,79.83 55.55,79.83 55.41,79.7 55.41,79.52 v1(55.65,79.29)
  BOTTOM w0.109: CON2100.55 56.59,79.82 56.4,80.02 56.25,80.02 56.16,79.93 56.16,79.85 56.05,79.74 55.88,79.74 55.72,79.9 55.72,80.11 55.61,80.22 55.38,80.22 55.18,80.01 55.18,79.71 55.38,79.51 55.38,79.43 55.47,79.34 55.6,79.34 v1(55.65,79.29) ; U0400.AR65 109.08,69.49 108.96,69.62 v3(108.74,69.62)
M_B_DQS3: length 68
  IN3 w0.076: 107.17,67.23 108.44,67.23 v3(108.79,66.88)
  IN3 w0.122: 107.17,67.23 106.83,67.57 106.83,68.07 105.11,69.8 105.11,70.7 104.54,71.27 104.54,71.92 104.15,72.31 104.15,72.86 101.69,75.32 97.63,75.32 96.55,74.24 93.02,74.24 92.74,74.52 92.74,74.8 92.58,74.96 92.15,74.96 91.95,74.76 91.95,74.54 91.66,74.25 86.01,74.25 85.54,73.78 80.31,73.78 79.56,73.03 72.17,73.03 71.9,72.75 66.3,72.75 66.17,72.62 57.72,72.62 56.73,73.62 51.72,73.62 v1(51.26,74.08)
  BOTTOM w0.109: v3(108.79,66.88) 108.79,66.75 U0400.AR60 ; CON2100.76 51.06,74.57 51.26,74.38 v1(51.26,74.08)
M_B_DQS4: length 69
  IN3 w0.076: 106.71,55.15 106.71,55.15 106.76,55.15 107.16,55.55 108.26,55.55 v5(108.75,55.06)
  IN3 w0.122: 106.71,55.15 106.34,54.79 103.68,54.79 103.23,54.34 91.73,54.34 89.72,52.34 89.41,52.34 83.45,46.38 78.94,46.38 78.44,45.88 78.44,44.03 78.2,43.79 77.61,43.79 77.42,43.98 77.42,44.58 77.04,44.96 76.45,44.96 76.2,44.7 76.2,44.02 76,43.82 75.44,43.82 75.31,43.96 75.31,44.64 75.03,44.91 74.32,44.91 74.04,44.63 74.04,43.98 73.88,43.82 71.43,43.82 71.15,44.09 70.32,44.09 70.02,43.79 69.55,43.79 69.22,44.12 66.75,44.12 65.58,42.95 63.3,42.95 62.41,43.84 60.3,43.84 59.04,45.11 57.27,45.11 56.72,45.66 55.64,45.66 55.53,45.77 55.53,45.96 v1(55.63,46.06)
  BOTTOM w0.109: CON2100.179 56.59,46.82 56.3,47.11 55.78,47.11 55.34,46.68 55.34,46.52 55.63,46.24 v1(55.63,46.06) ; U0400.AR38 108.75,54.9 v5(108.75,55.06)
M_B_DQS5: length 69.2
  IN3 w0.076: v3(108.76,51.36) 108.2,50.8 107.87,50.8 107.85,50.83 107.04,50.83 106.96,50.83 106.9,50.88
  IN3 w0.122: v5(51.43,41.12) 51.65,40.9 51.65,40.52 51.91,40.27 56.18,40.27 57.99,38.46 59.98,38.46 61.75,36.69 65.62,36.69 66.67,37.73 78.01,37.73 82.25,41.96 85.4,41.96 91.35,47.92 91.56,47.92 93.38,49.74 98.01,49.74 98.1,49.64 102.84,49.64 102.94,49.74 104.11,49.74 105.7,51.34 106.36,51.34 106.36,51.34 106.45,51.34 106.9,50.88
  BOTTOM w0.109: U0400.AR32 108.76,51.23 v3(108.76,51.36) ; v5(51.43,41.12) 51.43,41.52 51.22,41.73 50.49,41.73 50.33,41.57 CON2100.200
M_B_DQS6: length 71.3
  IN3 w0.076: 105.64,48.01 105.64,48.02 105.66,48.04 105.66,48.08 105.78,48.2 106.21,48.63 106.64,48.63 107.07,48.2 107.75,48.2 107.79,48.24 108.69,48.24 108.81,48.11 109.09,48.11 v3(109.42,47.78)
  IN3 w0.122: v5(54.73,35.21) 54.74,35.21 54.74,35.21 54.56,35.03 54.56,34.62 54.69,34.49 58.34,34.49 60.91,31.91 65.54,31.91 65.73,32.1 66.59,32.1 66.89,32.4 68.96,32.4 69.26,32.69 69.93,32.69 70.24,32.38 70.24,32.24 70.4,32.08 72.28,32.08 72.41,32.21 72.41,32.32 72.73,32.64 73.34,32.64 73.68,32.31 73.68,32.24 73.82,32.1 74.34,32.1 74.48,32.24 74.48,32.43 74.74,32.69 75.72,32.69 76,32.41 76,32.25 76.16,32.08 76.69,32.08 76.82,32.21 76.82,32.39 77.11,32.69 78.23,32.69 82.76,37.22 87.32,37.22 93.58,43.48 94,43.48 96.15,45.63 99.04,45.63 99.43,46.01 101.04,46.01 101.21,45.85 103.72,45.85 105.06,47.19 105.45,47.57 105.64,47.76 105.64,48.01
  BOTTOM w0.109: v3(109.42,47.78) 109.38,47.82 109.38,48.06 109.27,48.17 U0400.AR27 ; v5(54.73,35.21) 54.73,35.22 54.51,35.44 54.38,35.44 54.26,35.56 54.26,35.77 54.92,36.44 56.46,36.44 56.57,36.32 CON2100.221
M_B_DQS7: length 74.1
  IN3 w0.076: v3(109.37,44.92) 109.37,45.16 109.23,45.3 107.94,45.3 107.75,45.11 107.75,44.84 107.34,44.43 107.19,44.43 107.05,44.43
  IN3 w0.122: 107.05,44.43 105.81,43.19 105.81,42.71 104.66,41.56 101.97,41.56 101,40.59 98.39,40.59 94.09,36.3 92.9,36.3 89.66,33.06 84.49,33.06 78.53,27.11 70.65,27.11 69.47,25.92 67.41,25.92 66.84,26.5 65.38,26.5 65.16,26.27 63.9,26.27 63.77,26.14 63.77,26.02 63.49,25.74 62.79,25.74 62.51,26.02 62.51,26.2 62.32,26.39 61.86,26.39 61.69,26.22 61.69,25.77 61.38,25.45 60.73,25.45 60.43,25.76 60.43,26.1 60.01,26.52 59.21,26.52 56.33,29.4 54.44,29.4 53.69,30.14 52.14,30.14 51.89,30.39 51.84,30.39 51.46,30.77 v5(51.46,30.77)
  BOTTOM w0.109: CON2100.242 50.3,31.07 50.47,31.25 51.5,31.25 51.62,31.12 51.62,30.93 v5(51.46,30.77) ; v3(109.37,44.92) 109.37,44.8 U0400.AR21
M_B_DQS#0: length 77.8
  IN3 w0.122: v3(112.54,69.75) 112.52,69.77 112.52,70 112.64,70.11 112.64,70.13 112.67,70.16 112.67,73.83 112.07,74.44 112.07,77.62 105.43,84.25 72.03,84.25 71.55,83.77 66.06,83.77 65.54,83.25 62.98,83.25 62.61,83.62 61.42,83.62 60.24,84.8 57.38,84.8 56.73,85.45 56.56,85.45 56.56,85.45 55.57,85.45 55.24,85.13 54.73,85.13 54.43,85.42 53.62,85.42 53.37,85.16 53.37,84.29 53.21,84.13 52.52,84.13 52.38,84.28 52.05,84.28 51.92,84.41 v5(51.92,84.61)
  BOTTOM w0.109: v3(112.54,69.75) 112.54,69.97 112.65,70.08 U0400.AH66 ; CON2100.32 50.52,85.57 50.97,85.13 51.69,85.13 51.92,84.89 v5(51.92,84.61)
M_B_DQS#1: length 84.6
  IN3 w0.122: v1(55.34,91.14) 55.14,91.34 55.14,91.5 55.29,91.65 56.99,91.65 57.69,90.95 58.2,90.95 58.54,91.3 58.74,91.3 59.05,90.99 59.05,90.81 58.67,90.43 58.67,89.89 59.13,89.44 59.92,89.44 60.17,89.69 60.17,90.36 60.3,90.48 60.77,90.48 60.94,90.31 60.94,89.78 61.32,89.4 61.92,89.4 62.65,88.68 101.53,88.68 107.02,88.68 109.9,85.8 110.27,85.8 110.41,85.94 110.62,85.94 110.98,85.57 110.98,85.32 110.84,85.18 110.84,84.78 111.34,84.28 111.74,84.28 111.9,84.44 112.11,84.44 112.58,83.97 112.58,83.51 113.13,82.96 113.56,82.96 114.17,82.35 114.17,81.97 114.7,81.44 115.06,81.44 115.88,80.63 115.88,77.88 115.22,77.22 115.22,76.46 114.82,76.06 114.57,76.06 114.35,76.28 v5(114.35,76.41)
  BOTTOM w0.076: U0400.AG69 113.38,71.87 113.3,71.95 113.19,71.95 113.08,72.05 113.08,72.79 113.02,72.91 113.02,73.1 113.09,73.24 113.09,74.17 113.59,74.68 113.59,74.8 113.59,74.96 113.7,75.07
  BOTTOM w0.109: v5(114.35,76.41) 113.97,76.02 113.87,76.02 113.7,75.86 113.7,75.07 ; v1(55.34,91.14) 55.09,90.89 55.09,90.67 55.23,90.54 56.22,90.54 56.51,90.82 CON2100.11
M_B_DQS#2: length 69.9
  IN3 w0.122: v3(109.42,69.7) 109.39,69.7 108.78,70.32 108.78,72.57 106.97,74.38 106.97,74.63 106.14,75.46 106.14,76.3 105.97,76.47 105.97,77.71 103.6,80.08 85.57,80.08 83.99,78.51 76.29,78.51 75.98,78.21 75.01,78.21 74.71,78.51 73.87,78.51 73.56,78.2 73,78.2 72.67,78.52 71.87,78.52 71.55,78.21 70.94,78.21 70.62,78.53 69.73,78.53 69.41,78.21 58.96,78.21 58.74,78.44 58.74,78.68 59.37,79.31 59.37,79.67 58.98,80.06 55.46,80.06 55.46,80.06 55.44,80.06 55.17,79.79 55.17,79.54 v5(54.97,79.34)
  BOTTOM w0.109: U0400.AR66 109.42,69.77 v3(109.42,69.7) ; CON2100.53 56.62,80.32 56.52,80.43 55.3,80.43 54.97,80.1 v5(54.97,79.34)
M_B_DQS#3: length 68
  IN3 w0.076: 107.27,67.45 108.44,67.45 v3(108.76,67.77)
  IN3 w0.122: 107.27,67.45 107.06,67.66 107.06,68.17 105.33,69.89 105.33,70.8 104.76,71.36 104.76,72.01 104.37,72.4 104.37,72.95 101.78,75.54 100.51,75.54 97.54,75.54 96.46,74.46 93.12,74.46 92.96,74.61 92.96,74.89 92.67,75.19 92.06,75.19 91.72,74.85 91.72,74.63 91.57,74.48 85.92,74.48 85.44,74 80.22,74 79.47,73.25 72.08,73.25 71.81,72.98 66.21,72.98 66.07,72.84 57.82,72.84 56.82,73.84 52.1,73.84 51.97,73.97 v5(51.97,74.13)
  BOTTOM w0.089: v3(108.76,67.77) 108.76,67.69 U0400.AR61
  BOTTOM w0.109: CON2100.74 50.33,75.07 50.62,74.79 51.15,74.79 51.56,74.37 51.72,74.37 v5(51.97,74.13)
M_B_DQS#4: length 69.1
  IN3 w0.076: v3(108.05,55.05) 108.05,55.23 107.89,55.39 107.23,55.39 106.86,55.02 106.86,54.99
  IN3 w0.122: 106.86,54.99 106.44,54.56 103.77,54.56 103.32,54.12 91.82,54.12 89.81,52.11 89.5,52.11 83.55,46.16 79.04,46.16 78.66,45.78 78.66,43.94 78.29,43.57 77.52,43.57 77.19,43.89 77.19,44.49 76.95,44.73 76.55,44.73 76.42,44.61 76.42,43.92 76.1,43.59 75.35,43.59 75.08,43.86 75.08,44.54 74.94,44.69 74.42,44.69 74.26,44.53 74.26,43.89 73.97,43.59 71.33,43.59 71.06,43.87 70.41,43.87 70.11,43.57 69.46,43.57 69.13,43.9 66.84,43.9 65.67,42.73 63.21,42.73 62.32,43.62 60.21,43.62 58.94,44.88 57.17,44.88 56.62,45.43 55.53,45.43 54.97,46 54.97,46.01 54.94,46.03 v5(54.94,46.04)
  BOTTOM w0.109: v5(54.94,46.04) 55.12,46.21 55.12,46.75 55.69,47.32 CON2100.177 ; U0400.AT38 108.05,54.95 v3(108.05,55.05)
M_B_DQS#5: length 69.2
  IN3 w0.076: v5(108.1,51.36) 108.27,51.2 108.27,51.1 108.14,50.97 107.94,50.97 107.91,50.99 107.11,50.99 107.06,51.04
  IN3 w0.122: 107.06,51.04 107.06,51.04 106.54,51.56 106.27,51.56 105.61,51.56 104.01,49.96 102.84,49.96 102.74,49.86 98.2,49.86 98.1,49.96 93.29,49.96 91.47,48.14 91.26,48.14 85.3,42.19 82.16,42.19 77.92,37.95 66.57,37.95 65.53,36.91 61.84,36.91 60.07,38.68 58.08,38.68 56.27,40.49 52,40.49 51.87,40.62 51.87,40.84 v1(52.14,41.11)
  BOTTOM w0.109: CON2100.198 50.27,42.07 50.4,41.95 51.31,41.95 51.84,41.41 51.84,41.18 51.92,41.11 v1(52.14,41.11) ; U0400.AT32 108.1,51.24 v5(108.1,51.36)
