# Allegro board 5n-armani13.a00.0828.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQS#6: length 71.3
  IN3 w0.076: 105.86,48.01 105.86,48.05 106.28,48.47 106.57,48.47 107.01,48.03 107.82,48.03 107.86,48.07 108.62,48.07 108.74,47.95 108.74,47.95 108.75,47.93 v3(108.75,47.74)
  IN3 w0.122: 105.86,48.01 105.86,47.67 103.82,45.63 101.11,45.63 100.95,45.79 99.52,45.79 99.14,45.41 96.24,45.41 94.09,43.26 93.68,43.26 87.41,37 82.85,37 78.32,32.46 77.2,32.46 77.04,32.3 77.04,32.12 76.78,31.86 76.07,31.86 75.76,32.17 75.76,32.33 75.62,32.47 74.83,32.47 74.72,32.35 74.72,32.14 74.45,31.87 73.71,31.87 73.44,32.14 73.44,32.23 73.25,32.42 72.82,32.42 72.63,32.23 72.63,32.12 72.37,31.86 70.31,31.86 70.3,31.87 70.28,31.87 70.01,32.14 70.01,32.3 69.84,32.47 69.35,32.47 69.06,32.17 66.98,32.17 66.69,31.88 65.82,31.88 65.63,31.69 60.82,31.69 58.24,34.27 54.59,34.27 54.34,34.52 54.34,34.85 v1(54.04,35.15)
  BOTTOM w0.109: U0400.AR25 108.78,47.56 108.78,47.72 v3(108.75,47.74) ; v1(54.04,35.15) 54.04,35.86 54.83,36.65 56.42,36.65 56.6,36.82 CON2100.219
M_B_DQS#7: length 74.2
  IN3 w0.076: v5(109.37,45.87) 109.37,45.67 109.17,45.47 107.87,45.47 107.59,45.18 107.59,44.9 107.3,44.62 107.12,44.62 106.93,44.61 106.91,44.59 106.9,44.59 106.89,44.58
  IN3 w0.122: 106.89,44.58 105.59,43.28 105.59,42.8 104.57,41.79 101.88,41.79 100.91,40.82 98.29,40.82 94,36.52 92.81,36.52 89.57,33.28 84.39,33.28 78.44,27.33 70.56,27.33 69.38,26.15 67.5,26.15 66.93,26.72 65.29,26.72 65.06,26.49 63.81,26.49 63.55,26.24 63.55,26.12 63.4,25.96 62.88,25.96 62.73,26.11 62.73,26.3 62.41,26.62 61.77,26.62 61.47,26.31 61.47,25.86 61.29,25.68 60.82,25.68 60.65,25.85 60.65,26.2 60.1,26.74 59.3,26.74 56.42,29.62 54.53,29.62 53.78,30.37 52.23,30.37 52.09,30.51 52.09,30.69 v1(52.22,30.82)
  BOTTOM w0.109: U0400.AR22 109.37,45.71 v5(109.37,45.87) ; CON2100.240 50.3,31.57 50.42,31.46 51.59,31.46 51.84,31.2 51.84,30.97 51.99,30.82 v1(52.22,30.82)
M_CH_DRAM_RESET#: length 98.6
  TOP w0.102: v2(59.89,64.16) v1(59.89,62.87) 60.35,63.32 62.05,63.32 R2000.2 R2001.1
  IN1 w0.097: v3(108.79,39.45) 108.36,39.02 106.1,39.02 105.84,38.76 105.84,37.51 102.15,33.82 100.88,33.82 100.29,33.23 94.1,33.23 93.73,33.6 89.53,33.6 89.15,33.23 86.88,33.23 84.01,30.36 83.55,30.36 77.81,24.62 75.97,24.62 75.64,24.28 70.87,24.28 69.47,25.68 67.59,25.68 66.75,26.52 63.31,26.52 62.62,27.21 62.62,50.25 58.47,54.4 58.47,61.45 v1(59.89,62.87)
  BOTTOM w0.102: U0400.AT13 108.43,39.8 v3(108.79,39.45)
M_CH_DRAM_RESET#_R: length 32.1
  TOP w0.102: v2(60.6,66.69) v1(60.6,66.06) 60.95,65.71 C2002.1 61.7,65.15 61.67,65.13 C2011.1 R2001.2 ; v1(45.48,64.42) 46.28,64.42 46.58,64.11 46.58,62.82 46.43,62.66 46.03,62.66 45.9,62.54 C2102.1 46.58,62.23 46.71,62.36 47.4,62.36 v1(47.98,61.78)
  IN1 w0.097: v1(47.98,61.78) 48.4,62.19 52.4,62.19 53.71,63.5 56.02,63.5 57.87,65.36 59.9,65.36 v1(60.6,66.06)
  BOTTOM w0.102: v2(45.72,65.03) 45.48,64.79 v1(45.48,64.42) 47.22,64.42 47.57,64.77 47.57,65.99 48.16,66.57 CON2100.108 ; CON2000.108 61.17,65.57 60.69,66.06 v1(60.6,66.06)
M_CHA_VREF_CA: length 115.7
  TOP w0.432: v2(59.56,51.62) 59.83,51.35 v1(59.83,50.93) C2007.1 C2008.1 59.88,49.24 60.51,48.61 R2004.1
  TOP w0.508: v1(101.52,89.51) 101.52,88.67 103.53,86.67 103.53,83.44 100.36,80.27 100.36,76.39 v3(105.17,71.57)
  IN1 w0.508: v1(101.52,89.51) 101.27,89.77 91.14,89.77 89.82,91.09 80.57,91.09 77.65,94.01 67.91,94.01 67.12,94.8 65.66,94.8 64.8,93.93 64.8,92.23 63.47,90.91 63.12,90.91 62.51,90.3 62.51,69.7 61.42,68.61 61.42,65 60.96,64.55 58.21,64.55 56.97,63.31 56.97,54.21 59.83,51.35 v1(59.83,50.93)
  BOTTOM w0.203: v3(105.17,71.57) 105.18,71.57 105.83,70.92 U0400.AY67
M_CHA_VREF_CA_D: length 8
  TOP w0.432: R2003.2 C2010.1 R2004.2 R2005.1 C2009.1 62.44,50.51 v1(63.35,49.61) 63.35,49.73 64.04,50.42 v2(64.16,50.42)
  BOTTOM w0.102: CON2000.164 63.31,49.57 v1(63.35,49.61)
M_CHB_VREF_CA: length 121.2
  TOP w0.305: v1(102.18,89.51) 104.88,86.82 v2(104.88,84.89) 104.88,83.49 101.35,79.96 v1(101.35,79.38) ; v1(47.17,54.18) 47.57,53.77 47.86,53.77 48.51,53.12 48.51,52.05 C2109.1 C2108.1 48,50.13 48.36,49.76 R2102.1
  IN1 w0.305: v1(63.78,93.37) 61.29,90.88 61.29,69.78 56.74,65.23 54.07,65.23 52.22,63.38 48.58,63.38 47.47,62.27 47.47,54.49 v1(47.17,54.18)
  IN2 w0.508: v1(63.78,93.37) 65.06,94.66 85,94.66 87.68,91.98 99.09,91.98 v1(99.75,92.64)
  BOTTOM w0.14: U0400.BA67 105.15,70.92 104.85,71.23 104.55,71.23 104.32,71.46 104.32,72.24 104.01,72.54 104.01,73.13
  BOTTOM w0.254: v1(101.35,79.38) 101.35,76.46 104.01,73.79 104.01,73.13
  BOTTOM w0.305: v1(102.18,89.51) 102.18,90.2 v1(99.75,92.64)
M_CHB_VREF_CA_D: length 7.2
  TOP w0.432: R2101.2 R2102.2 50.03,49.76 R2103.1 C2111.1 C2110.1 50.03,46.43 49.68,46.08 v2(49.23,46.08)
  TOP w0.508: v1(50.65,50.68) 50.63,50.7 R2101.2
  BOTTOM w0.305: v1(50.65,50.68) 50.54,50.57 CON2100.164
MAA0_0: length 37.5
  TOP w0.127: U6801.K4 194.96,99.78 v1(194.96,99.75)
  IN1 w0.122: v1(168.51,89.99) 168.95,90.43 174.39,90.43 175.27,91.32 188.02,91.32 188.38,90.95 193.29,90.95 193.88,91.54 193.88,92.26 193.62,92.51 193.62,93.79 194.52,94.69 194.52,95.04 194.5,95.05 194.5,95.96 195.36,96.82 195.36,99.35 v1(194.96,99.75)
  BOTTOM w0.102: U6000.K17 168.51,89.89 v1(168.51,89.99)
  BOTTOM w0.127: U6801.K4 194.96,99.78 v1(194.96,99.75)
MAA0_1: length 41.6
  TOP w0.127: v1(193.83,99.06) 194.15,99.38 U6801.K5
  IN1 w0.122: v1(168.48,92.38) 168.86,92 170.78,92 171.4,92.61 172.48,92.61 172.53,92.56 184.7,92.56 184.83,92.69 184.83,94.21 184.98,94.36 185.34,94.36 185.47,94.24 185.47,92.63 185.6,92.5 186.49,92.5 186.84,92.5 187.08,92.75 187.08,93.49 186.96,93.61 185.92,93.61 185.8,93.73 185.8,93.98 185.92,94.1 186.96,94.1 187.08,94.22 187.08,95.11 187.38,95.41 188.24,95.41 189.03,94.62 189.03,94.15 189.17,94 189.59,94 189.74,94.15 189.74,94.47 189.86,94.6 190.15,94.6 190.15,94.6 190.45,94.6 190.58,94.48 190.58,94.21 190.7,94.08 191.36,94.08 191.49,94.21 191.49,95.01 192.43,95.95 192.43,97.06 193.83,98.45 v1(193.83,99.06)
  BOTTOM w0.102: U6000.J20 168.83,92.03 v1(168.48,92.38)
  BOTTOM w0.127: v1(193.83,99.06) 194.15,99.38 U6801.K5
MAA0_2: length 40.8
  TOP w0.127: U6801.K11 189.4,99.02 v1(189.36,99.02)
  IN1 w0.122: v1(169.99,94.41) 169.25,95.15 169.25,95.49 169.39,95.63 172.24,95.63 172.36,95.75 172.36,97.25 172.49,97.38 172.84,97.38 172.96,97.25 172.96,96.37 173.08,96.24 173.33,96.24 173.45,96.37 173.45,97.29 173.54,97.38 173.85,97.38 173.94,97.29 173.94,96.37 174.06,96.24 175.34,96.24 175.47,96.37 175.47,96.76 175.59,96.88 175.83,96.88 175.95,96.76 175.95,96.39 176.08,96.27 176.32,96.27 176.44,96.39 176.44,96.76 176.56,96.88 176.81,96.88 176.93,96.76 176.93,95.98 177.05,95.86 177.29,95.86 177.42,95.98 177.42,96.76 177.54,96.88 177.78,96.88 177.9,96.76 177.9,95.98 178.03,95.86 178.27,95.86 178.39,95.98 178.39,96.76 178.51,96.88 178.76,96.88 178.88,96.76 178.88,95.98 179,95.86 179.25,95.86 179.37,95.98 179.37,96.76 179.49,96.88 179.73,96.88 179.85,96.76 179.85,95.98 179.98,95.86 180.22,95.86 180.34,95.98 180.34,97.72 181.19,98.57 181.7,98.57 181.83,98.69 181.83,98.96 181.95,99.09 182.19,99.09 182.31,98.96 182.31,98.69 182.44,98.57 182.68,98.57 182.8,98.69 182.8,98.96 182.92,99.09 183.17,99.09 183.29,98.96 183.29,98.69 183.41,98.57 183.66,98.57 183.78,98.69 183.78,98.96 183.9,99.09 184.14,99.09 184.27,98.96 184.27,98.69 184.39,98.57 184.63,98.57 184.75,98.69 184.75,98.96 184.87,99.09 185.12,99.09 185.24,98.96 185.24,98.69 185.36,98.57 186.63,98.57 186.88,98.81 186.88,99 186.97,99.09 189.29,99.09 v1(189.36,99.02)
  BOTTOM w0.102: U6000.H23 169.99,94.38 v1(169.99,94.41)
  BOTTOM w0.127: v1(189.36,99.02) 189.72,99.38 U6801.K11
MAA0_3: length 40.3
  TOP w0.127: v1(191.09,99.15) 190.86,99.38 U6801.K10 ; v2(171.37,94.03) 171.31,94.03 v1(170.78,93.5)
  IN1 w0.122: v1(170.78,93.5) 170.78,93.21 170.51,92.94 169.27,92.94 168.91,93.3 168.91,93.8 169.03,93.92 172.13,93.92 172.15,93.89 173.36,93.89 173.48,93.77 173.48,93.39 173.6,93.27 173.85,93.27 173.97,93.39 173.97,93.71 174.17,93.91 180.81,93.91 181.38,94.48 181.38,95.86 181.5,95.99 181.83,95.99 181.95,95.87 181.95,95.22 182.07,95.1 182.32,95.1 182.44,95.22 182.44,95.87 182.56,95.99 182.8,95.99 182.93,95.87 182.93,95.22 183.05,95.1 183.29,95.1 183.41,95.22 183.41,95.87 183.54,95.99 183.78,95.99 183.9,95.87 183.9,95.22 184.02,95.1 184.27,95.1 184.39,95.22 184.39,95.87 184.52,95.99 185.61,95.99 185.67,96.06 189.04,96.06 189.28,96.3 189.46,96.3 189.67,96.09 191.54,96.09 191.66,96.21 191.66,97 191.54,97.12 191.08,97.12 190.96,97.24 190.96,97.49 191.08,97.61 191.63,97.61 191.78,97.76 191.78,98.46 v1(191.09,99.15)
  BOTTOM w0.102: U6000.G23 170.78,93.67 v1(170.78,93.5)
  BOTTOM w0.127: v1(191.09,99.15) 190.86,99.38 U6801.K10
MAA0_4: length 36.7
  TOP w0.127: U6801.H11 189.78,97.78 v1(190.17,98.17)
  IN1 w0.122: v1(170.83,94.37) 172.13,94.37 172.27,94.24 180.67,94.24 181.05,94.62 181.05,96.24 181.17,96.37 183.45,96.37 183.57,96.49 183.57,96.73 183.45,96.85 181.17,96.85 181.05,96.98 181.05,97.51 181.46,97.92 185.01,97.92 185.13,97.8 185.13,96.59 185.25,96.47 185.5,96.47 185.62,96.59 185.62,97.77 185.74,97.89 186.76,97.89 186.88,97.77 186.88,97.12 187.01,97 187.25,97 187.35,97.1 187.35,98.05 187.48,98.17 187.98,98.17 188.1,98.05 188.1,97.88 188.23,97.76 188.78,97.76 188.94,97.6 188.94,96.84 189.15,96.63 190.07,96.63 190.61,97.16 190.61,98.04 190.48,98.17 v1(190.17,98.17)
  BOTTOM w0.127: v1(170.83,94.37) 170.83,94.42 U6000.G24 ; v1(190.17,98.17) 190.14,98.14 190.12,98.14 U6801.H11
MAA0_5: length 38
  TOP w0.127: v1(191.05,98.03) 190.8,97.78 U6801.H10
  IN1 w0.122: v1(191.05,98.03) 191.35,98.03 191.46,98.13 191.46,98.32 191.17,98.61 190.51,98.61 190.38,98.73 190.38,98.96 190.26,99.09 190.02,99.09 189.9,98.96 189.9,98.73 189.78,98.61 187.13,98.61 186.77,98.24 181.32,98.24 180.67,97.59 180.67,95.85 180.36,95.54 180.11,95.54 179.99,95.42 179.99,94.68 179.87,94.56 179.62,94.56 179.5,94.68 179.5,95.42 179.38,95.54 179.14,95.54 179.02,95.42 179.02,94.68 178.89,94.56 178.65,94.56 178.53,94.68 178.53,95.42 178.41,95.54 178.16,95.54 178.04,95.42 178.04,94.68 177.92,94.56 177.67,94.56 177.55,94.68 177.55,95.42 177.43,95.54 177.19,95.54 177.06,95.42 177.06,94.68 176.94,94.56 175.9,94.56 175.77,94.69 175.77,94.97 176.32,95.52 176.32,95.7 176.1,95.91 175.35,95.91 175.22,95.79 175.22,95.27 175.11,95.15 174.8,95.15 174.68,95.28 174.68,95.66 174.55,95.79 174.23,95.79 174.1,95.66 174.1,95.27 173.98,95.15 173.74,95.15 173.62,95.27 173.62,95.79 173.5,95.91 173.25,95.91 173.13,95.79 173.13,95.02 172.89,94.79 170.43,94.79 v1(170,95.21)
  BOTTOM w0.127: v1(170,95.21) 170,95.19 U6000.H24 ; U6801.H10 190.8,97.78 v1(191.05,98.03)
MAA0_6: length 40.5
  TOP w0.127: v1(194.13,98.15) 194.19,98.15 U6801.H5
  IN1 w0.122: v1(169.01,91.21) 169.47,91.67 170.92,91.67 171.53,92.28 172.34,92.28 172.4,92.23 185.41,92.23 185.5,92.14 190.65,92.14 190.78,92.27 190.78,92.76 190.55,93 189.18,93 189.18,93 187.61,93 187.41,93.21 187.41,93.43 187.66,93.68 192.67,93.68 192.8,93.8 192.8,94.17 192.68,94.29 191.97,94.29 191.85,94.42 191.85,94.66 191.97,94.78 192.68,94.78 192.8,94.9 192.8,96.82 v1(194.13,98.15)
  BOTTOM w0.102: v1(169.01,91.21) 169.01,90.8 U6000.J19
  BOTTOM w0.127: v1(194.13,98.15) 194.19,98.15 U6801.H5
MAA0_7: length 40.1
  TOP w0.127: v1(194.94,97.36) U6801.H4
  IN1 w0.122: v1(168.4,91.21) 168.84,90.78 172.25,90.78 172.4,90.93 172.4,91.8 172.5,91.9 172.78,91.9 172.88,91.8 172.88,91.05 173.01,90.93 173.25,90.93 173.37,91.05 173.37,91.8 173.47,91.9 173.76,91.9 173.86,91.8 173.86,90.9 173.98,90.78 174.28,90.78 175.4,91.9 175.61,91.9 175.87,91.64 176.1,91.64 176.36,91.9 176.58,91.9 176.85,91.64 177.07,91.64 177.33,91.9 177.56,91.9 177.82,91.64 178.05,91.64 178.31,91.9 178.53,91.9 178.8,91.64 179.02,91.64 179.29,91.9 179.51,91.9 179.77,91.64 180,91.64 180.26,91.9 180.48,91.9 180.75,91.64 180.97,91.64 181.24,91.9 181.46,91.9 181.72,91.64 181.95,91.64 182.21,91.9 182.43,91.9 182.7,91.64 182.92,91.64 183.19,91.9 183.41,91.9 183.67,91.64 183.9,91.64 184.16,91.9 184.41,91.9 184.49,91.82 187.98,91.82 188.52,91.28 188.91,91.28 189.45,91.82 190.79,91.82 191.57,92.61 192.16,92.61 192.53,92.24 193.02,92.24 193.14,92.36 193.14,94.54 193.63,95.04 193.63,95.76 193.46,95.93 193.46,96.28 193.7,96.52 194.1,96.52 v1(194.94,97.36)
  BOTTOM w0.102: U6000.K19 168.4,90.99 v1(168.4,91.21)
  BOTTOM w0.127: v1(194.94,97.36) U6801.H4
MAA0_8: length 41
  TOP w0.127: U6801.J5 194.95,98.19 v1(194.95,98.17)
  IN1 w0.122: v1(194.95,98.17) 194.95,99.14 194.6,99.48 193.65,99.48 192.85,98.68 192.85,98.51 193.05,98.31 193.05,98.14 192.88,97.96 192.71,97.96 192.51,98.16 192.34,98.16 192.11,97.93 192.11,96.08 191.27,95.25 190.86,95.25 190.67,95.44 189.6,95.44 189.55,95.39 189,95.39 188.66,95.73 185.8,95.73 185.74,95.67 184.92,95.67 184.71,95.46 184.71,94.64 184.51,94.43 184.51,93.02 184.38,92.89 183.34,92.89 183.11,93.12 183.11,94.44 182.99,94.57 182.73,94.57 182.6,94.44 182.6,93.02 182.47,92.89 182.19,92.89 182.07,93.02 182.07,94.1 181.94,94.22 181.69,94.22 181.56,94.1 181.56,93.02 181.43,92.89 181.2,92.89 181.08,93.02 181.08,93.45 180.95,93.58 180.65,93.58 180.52,93.45 180.52,93.02 180.39,92.89 173.29,92.89 173.24,92.93 172.92,92.93 172.8,93.06 172.8,93.35 172.67,93.47 172.44,93.47 172.31,93.35 172.31,93.06 172.18,92.93 171.13,92.93 v1(170.69,92.5)
  BOTTOM w0.102: v1(170.69,92.5) 170.69,92.48 170.43,92.21 U6000.G20
  BOTTOM w0.127: v1(194.95,98.17) 194.95,98.19 U6801.J5
MAA1_0: length 43.4
  TOP w0.127: U6803.H4 190.14,80.03 v1(190.17,80.03)
  IN3 w0.102: v1(169.22,87.63) 168.45,86.87 167.69,86.87 167.39,86.57 167.39,82.65 167.6,82.44 167.6,81.68
  IN3 w0.122: v1(190.17,80.03) 190.17,79.37 189.58,78.77 184.64,78.77 184.51,78.65 184.51,78.12 184.36,77.97 184.16,77.97 184.03,78.1 184.03,78.82 183.85,79 182.75,79 182.08,78.33 182.08,78.18 181.96,78.06 181.72,78.06 181.6,78.18 181.6,78.33 181.47,78.45 176.58,78.45 175.01,80.02 175.01,80.02 174.68,80.36 174,80.36 173.61,79.96 173.61,79.18 173.48,79.05 172.03,79.05 171.8,79.29 171.8,80.16 171.61,80.34 171.15,80.34 170.96,80.16 170.96,79.22 170.82,79.07 169.75,79.07 169.6,79.23 169.6,79.71 169.51,79.79 169.02,79.79 168.94,79.71 168.94,79.25 168.81,79.12 168.43,79.12 168.28,79.28 168.28,80.14 168.4,80.27 168.92,80.27 169.04,80.39 169.04,80.93 168.76,81.21 167.87,81.21 167.6,81.47 167.6,81.68
  BOTTOM w0.102: U6000.J14 168.83,87.25 v1(169.22,87.63)
  BOTTOM w0.127: v1(190.17,80.03) 190.14,80.03 U6803.H4
MAA1_1: length 43.7
  TOP w0.127: U6803.H5 190.57,80.42 v1(190.18,80.81)
  IN3 w0.102: v1(168.45,86.44) 168.45,86.41 168,85.96 168,83.06 168.25,82.81 169.49,82.81 169.62,82.68 169.62,82.25 169.9,81.97 170.54,81.97 170.64,82.07 170.64,82.64 170.76,82.77 171.02,82.77 171.15,82.64 171.15,82.55 171.27,82.43 171.95,82.43
  IN3 w0.122: v1(190.18,80.81) 189.84,80.47 188.29,80.47 188.16,80.34 188.16,80.15 188.04,80.03 187.8,80.03 187.71,80.12 187.71,80.29 187.6,80.39 187.35,80.39 187.22,80.27 187.22,80.11 187.07,79.96 181.5,79.96 181.38,80.08 181.38,80.22 181.23,80.37 180.99,80.37 180.86,80.24 180.86,80.08 180.74,79.96 180.49,79.96 180.37,80.09 180.37,80.14 180.24,80.26 180.06,80.26 179.93,80.39 179.93,80.71 179.81,80.84 179.55,80.84 179.43,80.96 179.43,80.98 179.31,81.11 179.06,81.11 178.94,80.98 178.94,80.96 178.82,80.84 178.18,80.84 178.05,80.96 178.05,82.6 177.93,82.72 177.69,82.72 177.57,82.6 177.57,80.96 177.44,80.84 177.2,80.84 177.08,80.96 177.08,82.6 176.96,82.72 176.71,82.72 176.59,82.6 176.59,80.96 176.47,80.84 176.23,80.84 176.1,80.96 176.1,82.6 175.98,82.72 175.74,82.72 175.62,82.6 175.62,80.96 175.49,80.84 175.17,80.84 175.03,80.98 175.03,81.94 174.9,82.07 174.37,82.07 174.24,82.2 174.24,82.32 174.12,82.45 173.86,82.45 173.74,82.32 173.74,82.12 173.64,82.03 172.34,82.03 171.95,82.43
  BOTTOM w0.127: U6000.K14 168.45,86.6 v1(168.45,86.44) ; v1(190.18,80.81) 190.18,80.78 U6803.H5
MAA1_2: length 44.7
  TOP w0.127: U6803.H11 195.01,80.04 194.34,80.04 v1(194,79.7)
  IN3 w0.102: v1(169.27,84.18) 169.52,84.18 169.65,84.31 169.65,85.55 169.8,85.7 170.26,85.7
  IN3 w0.122: 170.26,85.7 170.56,86.01 170.74,86.01 170.9,85.85 170.9,85.74 171.03,85.62 171.22,85.62 171.35,85.74 171.35,85.95 171.48,86.08 172.16,86.08 172.39,85.85 172.39,84.79 172.49,84.69 172.79,84.69 172.87,84.77 172.87,85.85 173,85.98 173.25,85.98 173.38,85.85 173.38,84.84 173.51,84.72 173.76,84.72 173.89,84.84 173.89,85.94 174.02,86.06 174.33,86.06 174.45,85.94 174.45,85.83 174.57,85.71 174.82,85.71 174.94,85.83 174.94,85.94 175.06,86.06 175.3,86.06 175.43,85.94 175.43,85.83 175.55,85.71 177.44,85.71 178.06,85.09 178.06,84.88 178.19,84.75 179.23,84.75 181.71,82.27 182.03,82.27 182.16,82.39 182.16,82.41 182.28,82.53 182.52,82.53 182.64,82.41 182.64,82.39 182.77,82.27 183.01,82.27 183.13,82.39 183.13,82.41 183.25,82.53 183.5,82.53 183.62,82.41 183.62,82.39 183.74,82.27 183.98,82.27 184.11,82.39 184.11,82.41 184.23,82.53 184.47,82.53 184.59,82.41 184.59,82.39 184.72,82.27 185.17,82.27 185.29,82.39 185.29,82.85 185.43,82.99 185.62,82.99 185.78,82.83 185.78,82.39 185.9,82.27 186.14,82.27 186.26,82.39 186.26,82.68 186.39,82.81 186.63,82.81 186.75,82.68 186.75,82.39 186.87,82.27 187.2,82.27 187.36,82.43 187.36,83.4 187.62,83.66 191.36,83.66 191.62,83.4 191.62,82.92 191.74,82.8 191.86,82.8 191.98,82.68 191.98,82.43 191.86,82.31 191.74,82.31 191.62,82.19 191.62,81.77 192.09,81.3 192.09,81.2 192.66,80.63 192.84,80.63 192.89,80.68 193.06,80.68 193.24,80.51 193.24,80.34 193.18,80.28 193.18,80.11 193.59,79.7 v1(194,79.7)
  BOTTOM w0.102: v1(169.27,84.18) U6000.J11
  BOTTOM w0.127: v1(194,79.7) 194.34,80.04 195.01,80.04 U6803.H11
MAA1_3: length 43.2
  TOP w0.127: U6803.H10 194.01,80.4 194,80.41 v1(193.99,80.41)
  IN3 w0.102: 169.49,86.87 v1(169.06,86.44)
  IN3 w0.122: 169.49,86.87 170.46,86.87 170.92,86.41 172.94,86.41 173.06,86.53 173.06,87.49 173.18,87.61 173.44,87.61 173.55,87.5 173.55,86.53 173.67,86.41 175.42,86.41 175.79,86.04 177.6,86.04 177.88,85.75 179.04,85.75 179.2,85.6 179.2,85.32 179.32,85.2 179.55,85.2 180.05,85.69 180.22,85.69 180.39,85.52 180.39,85.35 179.9,84.85 179.9,84.68 180.07,84.51 180.24,84.51 181.17,85.44 181.37,85.44 181.53,85.28 181.53,85.1 180.59,84.17 180.59,83.99 180.76,83.82 180.94,83.82 181.84,84.73 182.02,84.73 182.19,84.56 182.19,84.39 181.28,83.48 181.28,83.3 181.73,82.85 182.34,82.85 182.46,82.97 182.46,83.89 182.59,84.02 182.88,84.02 182.95,83.95 182.95,82.97 183.07,82.85 184.48,82.85 185.3,83.68 187.18,83.68 187.49,83.98 191.22,83.98 191.49,83.98 192.3,83.17 192.3,81.55 192.41,81.44 192.41,81.42 192.66,81.18 193.22,81.18 v1(193.99,80.41)
  BOTTOM w0.127: v1(169.06,86.44) 168.83,86.21 U6000.J13 ; v1(193.99,80.41) 194,80.4 U6803.H10
MAA1_4: length 42.4
  TOP w0.127: v1(195.76,79.21) 195.76,79.19 U6803.K11
  IN3 w0.102: v1(170.07,85.05) 170.28,84.84 171.48,84.84 171.78,84.53 172.09,84.53 172.23,84.39 172.76,84.39
  IN3 w0.122: v1(195.76,79.21) 196.13,78.84 196.45,78.84 196.57,78.97 196.57,79.43 196.7,79.56 196.94,79.56 197.06,79.43 197.06,78.97 197.18,78.84 197.43,78.84 197.55,78.97 197.55,79.43 197.67,79.56 197.91,79.56 198.04,79.43 198.04,78.97 198.16,78.84 198.98,78.84 199.11,78.97 199.11,79.81 198.57,80.35 197.22,80.35 197.16,80.41 195.48,80.41 195.34,80.27 195.34,79.39 195.21,79.26 193.57,79.26 191.76,81.07 191.76,81.17 191.06,81.87 188.84,81.87 188.74,81.98 188.39,81.98 188.36,81.95 181.57,81.95 179.13,84.39 177.04,84.39 176.92,84.51 176.92,84.69 176.8,84.81 176.55,84.81 176.43,84.69 176.43,84.51 176.31,84.39 176.06,84.39 175.94,84.51 175.94,84.72 175.82,84.85 175.58,84.85 175.46,84.72 175.46,84.51 175.33,84.39 172.76,84.39
  BOTTOM w0.102: v1(170.07,85.05) U6000.H11
  BOTTOM w0.127: v1(195.76,79.21) 195.76,79.19 U6803.K11
MAA1_5: length 42
  TOP w0.127: v1(193.99,78.81) 194,78.8 U6803.K10
  IN3 w0.122: v1(193.99,78.81) 195.17,78.81 195.3,78.68 195.3,78.39 195.17,78.26 194.59,78.26 194.49,78.36 193.85,78.36 193.7,78.51 192.99,78.51 192.86,78.64 192.86,78.82 193.08,79.04 193.08,79.24 192.96,79.37 192.75,79.37 191.99,78.6 191.81,78.6 191.62,78.79 191.62,78.97 192.4,79.75 192.4,79.97 192.23,80.14 192.05,80.14 191.84,79.93 191.67,79.93 191.44,80.16 191.44,81.03 190.92,81.55 189.68,81.55 189.28,81.15 188.06,81.15 187.94,81.27 187.94,81.52 187.84,81.62 187.59,81.62 187.46,81.49 187.46,81.27 187.3,81.12 187.04,81.12 186.89,81.27 186.89,81.5 186.76,81.62 186.52,81.62 186.4,81.51 186.4,81.34 186.4,81.34 186.4,81.23 186.18,81.01 186.18,80.79 186,80.62 185.55,80.62 185.42,80.75 185.42,81.5 185.29,81.62 184.92,81.62 184.8,81.5 184.8,81.26 184.68,81.14 184.43,81.14 184.31,81.26 184.31,81.5 184.19,81.62 183.94,81.62 183.82,81.5 183.82,81.26 183.7,81.14 183.46,81.14 183.33,81.26 183.33,81.5 183.21,81.62 182.97,81.62 182.85,81.5 182.85,81.26 182.72,81.14 182.48,81.14 182.36,81.26 182.36,81.5 182.24,81.62 181.99,81.62 181.87,81.5 181.87,81.26 181.75,81.14 181.43,81.14 181.31,81.27 181.31,81.61 181.18,81.74 180.82,81.74 180.64,81.92 180.64,82.09 180.72,82.17 180.72,82.34 180.55,82.51 180.37,82.51 180.3,82.44 180.13,82.44 179.95,82.61 179.95,82.78 180.03,82.86 180.03,83.03 179.86,83.2 179.68,83.2 179.61,83.13 179.44,83.13 179.26,83.3 179.26,83.47 179.34,83.55 179.34,83.72 179.17,83.89 178.99,83.89 178.92,83.82 178.75,83.82 178.5,84.06 171.69,84.06 171.27,84.48 170.36,84.48 v1(170.03,84.15)
  BOTTOM w0.102: v1(170.03,84.15) 170.03,84.19 170.24,84.4 170.24,84.42 U6000.G11
  BOTTOM w0.127: v1(193.99,78.81) 194,78.8 U6803.K10
MAA1_6: length 43.5
  TOP w0.127: v1(191.13,78.8) U6803.K5
  IN3 w0.122: v1(168.63,88.8) 166.19,86.36 166.19,84.61 166.73,84.08 166.73,81.97 166.8,81.89 166.8,78.31 167.36,77.75 168.56,77.75 168.68,77.63 168.68,77.39 168.8,77.27 169.04,77.27 169.16,77.39 169.16,77.63 169.29,77.75 170.18,77.75 170.3,77.63 170.3,77.04 170.42,76.91 170.67,76.91 170.79,77.04 170.79,77.63 170.91,77.75 172.31,77.75 172.97,78.4 173.9,78.4 174.5,79.01 174.85,79.01 176.05,77.8 177.67,77.8 177.79,77.68 177.79,77.5 177.92,77.37 178.15,77.37 178.28,77.5 178.28,77.68 178.4,77.8 180.57,77.8 181.11,77.26 188.36,77.26 188.67,76.96 190.43,76.96 190.73,77.26 190.73,78.4 v1(191.13,78.8)
  BOTTOM w0.102: v1(168.63,88.8) 168.63,88.42 U6000.J16
  BOTTOM w0.127: v1(191.13,78.8) U6803.K5
MAA1_7: length 44.5
  TOP w0.127: v1(189.4,79.19) 189.4,79.16 U6803.K4
  IN3 w0.102: v1(167.84,86.44) 167.83,86.43 167.83,86.42 167.69,86.29 167.69,82.78 168.12,82.35 169.04,82.35 169.7,81.68
  IN3 w0.122: 169.7,81.68 169.75,81.64 170.38,81.64 170.51,81.51 170.51,80.74 170.64,80.61 170.92,80.61 171.05,80.74 171.05,81.49 171.18,81.62 171.41,81.62 171.54,81.49 171.54,80.81 171.67,80.67 171.89,80.67 172.03,80.8 172.03,81.47 172.15,81.59 172.41,81.59 172.54,81.46 172.54,79.48 172.64,79.38 172.92,79.38 173.03,79.48 173.03,81.47 173.15,81.59 173.34,81.59 173.49,81.44 173.49,80.8 173.61,80.68 173.85,80.68 173.98,80.8 173.98,81.06 174.1,81.18 174.34,81.18 174.46,81.06 174.46,80.8 174.59,80.68 174.82,80.68 175.34,80.16 175.34,80.16 175.53,79.96 176,79.96 176.12,79.83 176.12,79.49 176.29,79.33 176.48,79.33 176.61,79.45 176.61,79.84 176.73,79.96 176.97,79.96 177.1,79.83 177.1,78.98 177.23,78.84 177.46,78.84 177.59,78.97 177.59,79.74 177.71,79.87 177.95,79.87 178.07,79.74 178.07,78.99 178.2,78.86 178.43,78.86 178.56,78.99 178.56,79.79 178.68,79.91 178.93,79.91 179.05,79.79 179.05,79.48 179.17,79.36 179.41,79.36 179.54,79.48 179.54,79.79 179.66,79.91 179.9,79.91 180.02,79.79 180.02,79.48 180.15,79.36 180.39,79.36 180.51,79.48 180.51,79.51 180.63,79.63 180.88,79.63 181,79.51 181,79.48 181.12,79.36 181.37,79.36 181.49,79.48 181.49,79.51 181.61,79.63 181.85,79.63 181.97,79.51 181.97,79.48 182.1,79.36 182.34,79.36 182.46,79.48 182.46,79.51 182.58,79.63 182.83,79.63 182.95,79.51 182.95,79.48 183.07,79.36 183.32,79.36 183.44,79.48 183.44,79.51 183.56,79.63 183.8,79.63 183.93,79.51 183.93,79.48 184.05,79.36 184.29,79.36 184.41,79.48 184.41,79.51 184.54,79.63 187.92,79.63 187.95,79.61 188.98,79.61 v1(189.4,79.19)
  BOTTOM w0.102: v1(167.84,86.44) 167.83,86.44 167.61,86.65 167.61,87.03 U6000.L15
  BOTTOM w0.127: U6803.K4 189.4,79.16 v1(189.4,79.19)
MAA1_8: length 42.9
  TOP w0.127: U6803.J5 190.9,79.93 v1(191.04,79.93)
  IN3 w0.102: v1(170.28,86.44) 170.28,86.17 170.14,86.03 168.59,86.03 168.45,85.89 168.45,85.7 168.58,85.58 168.71,85.58 168.81,85.47 168.81,83.75 168.94,83.62 170.38,83.62 170.51,83.75 170.51,84.15 170.58,84.22 170.9,84.22 170.97,84.15 170.97,83.82 171.09,83.7
  IN3 w0.122: v1(191.04,79.93) 190.6,80.37 190.6,80.98 190.36,81.22 189.82,81.22 189.38,80.79 186.64,80.79 186.39,80.55 186.39,80.4 186.29,80.29 185.22,80.29 185.09,80.42 185.09,80.65 184.96,80.77 184.66,80.77 184.53,80.65 184.53,80.42 184.4,80.29 181.79,80.29 181.15,80.93 180.98,80.93 180.72,80.67 180.54,80.67 180.37,80.85 180.37,81.02 180.63,81.28 180.63,81.45 180.46,81.62 180.29,81.62 179.98,81.32 179.8,81.32 179.62,81.5 179.62,81.67 179.93,81.98 179.93,82.15 179.77,82.31 179.6,82.31 178.69,81.41 178.52,81.41 178.38,81.54 178.38,81.71 179.25,82.58 179.25,82.83 179.05,83.03 178.87,83.03 178.62,82.79 178.37,82.79 178.11,83.06 175.29,83.06 175.17,82.94 175.17,82.6 175.05,82.48 174.8,82.48 174.68,82.6 174.68,82.94 174.56,83.06 173.91,83.06 173.79,83.18 173.79,83.57 173.66,83.7 173.42,83.7 173.3,83.57 173.3,82.45 173.21,82.35 172.94,82.35 172.81,82.49 172.81,83.57 172.69,83.7 172.44,83.7 172.32,83.57 172.32,82.9 172.18,82.76 171.7,82.76 171.58,82.88 171.58,83.21 171.09,83.7
  BOTTOM w0.127: v1(170.28,86.44) 170.28,86.86 U6000.G14 ; v1(191.04,79.93) 190.9,79.93 U6803.J5
MASK_SATA_LED#: length 95.4
  TOP w0.102: R5002.1 25.37,89.46 v1(25.98,88.85) ; U2300.56 25.96,33.1 25.83,32.97 25.83,32.63 25.59,32.39 23.17,32.39 v1(22.94,32.63) ; v1(23.19,52.56) 24.49,53.85 39.45,53.85 v2(40.79,52.5) 40.79,50.35 40.49,50.04 40.13,49.68 40.03,49.58 40.03,49.2 40.44,48.8 41.53,48.8 41.99,48.34 41.99,47.48 41.25,46.74 R2341.2
  IN2 w0.102: v1(22.94,32.63) 23.55,32.63 23.67,32.75 23.67,36.45 24.23,37.01 24.23,38.86 24.23,39.96 23.83,40.36 23.83,44.71 23.8,44.74 23.8,45.1 23.83,45.12 23.83,48.97 23.67,49.13 23.67,52.07 v1(23.19,52.56) 23.55,52.91 23.55,55.1 24.78,56.33 24.78,64.33 25.12,64.67 25.12,68.69 24.56,69.25 24.56,70.59 22.09,73.07 22.09,79.16 22.99,80.06 22.99,85.85 v1(25.98,88.85)
MDA0_0: length 39.7
  TOP w0.127: v1(190.16,103.81) 190.12,103.81 U6801.T11
  IN3 w0.122: v1(168.28,101.03) 167.82,101.03 166.8,102.05 166.8,105.93 169.54,108.67 175.31,108.67 177.95,111.31 180.59,111.31 184.33,107.57 186.12,107.57 188.13,105.56 188.13,105.32 188.49,104.96 189.02,104.96 v1(190.16,103.81)
  BOTTOM w0.102: v1(168.28,101.03) 167.88,100.62 167.88,100.33 168.16,100.05 168.17,100.05 168.36,99.86 168.36,99.47 168.3,99.35 168.3,99.17 168.31,99.08 168.39,98.89 168.39,98.39 168.53,98.25 168.53,97.72 U6000.K27
MDA0_1: length 37.6
  TOP w0.127: v1(189.3,105.41) 189.33,105.41 U6801.U11
  IN3 w0.122: v1(189.3,105.41) 186.58,108.13 184.38,108.13 180.77,111.74 177.75,111.74 175.11,109.1 169.37,109.1 166.37,106.1 166.37,101.88 167.82,100.43 v1(168.36,100.43)
  BOTTOM w0.102: v1(168.36,100.43) 168.69,100.09 168.69,100.03 168.66,99.57 168.58,99.45 168.5,99.3 168.5,99.18 168.5,99.14 168.83,98.42 U6000.J29
MDA0_2: length 32.9
  TOP w0.127: U6801.T13 187.8,103.82 v1(187.76,103.82)
  IN3 w0.122: v1(187.76,103.82) 187.22,104.36 187.22,105.16 185.85,106.54 182.4,106.54 181.71,106.54 180.87,105.7 178.28,105.7 176.17,107.82 170.01,107.82 168.23,106.04 168.23,104.91 167.67,104.34 167.67,102.39 168.13,101.93 169,101.93 v1(169.09,101.84)
  BOTTOM w0.102: U6000.H30 169.95,99.5 169.96,99.59 169.96,101.47 169.67,101.75
  BOTTOM w0.127: 169.67,101.75 169.58,101.84 v1(169.09,101.84)
MDA0_3: length 32.1
  TOP w0.127: v1(187.71,105.39) 187.75,105.39 U6801.U13
  IN3 w0.122: v1(187.71,105.39) 187.67,105.43 187.66,105.43 185.94,107.14 181.72,107.14 180.7,106.12 178.46,106.12 176.34,108.24 169.83,108.24 167.23,105.64 167.23,102.22 168,101.46 168.46,101.46 168.71,101.21 v1(169.11,101.21)
  BOTTOM w0.102: 169.55,101.21 169.74,101.02 169.74,99.73 U6000.H32
  BOTTOM w0.127: 169.55,101.21 v1(169.11,101.21)
MDA0_4: length 26.3
  TOP w0.127: U6801.N11 190.14,101.39 v1(190.17,101.39)
  IN3 w0.122: v1(190.17,101.39) 190.17,101.12 190.01,100.96 189.16,100.96 189.16,100.97 187.62,100.97 187.31,101.27 185.33,101.27 183.92,102.68 183.29,102.68 183.23,102.75 177.06,102.75 176.56,103.26 171.55,103.26 170.43,102.14 v1(170.43,102.14)
  BOTTOM w0.102: U6000.G29 170.76,99.08 170.76,99.3 170.73,99.37 170.7,99.42 170.7,99.96 171.07,100.33 171.07,101.5 170.81,101.75
  BOTTOM w0.127: 170.81,101.75 v1(170.43,102.14)
MDA0_5: length 26.2
  TOP w0.127: U6801.M13 187.75,100.57 v1(187.75,100.55)
  IN3 w0.122: v1(170.42,101.51) 171.74,102.83 174.4,102.83 174.52,102.7 174.52,102.59 174.69,102.43 174.9,102.43 175.03,102.56 175.03,102.69 175.17,102.83 175.44,102.83 175.57,102.7 175.57,102.52 175.69,102.39 175.92,102.39 176.05,102.52 176.05,102.68 176.17,102.81 176.38,102.81 176.56,102.63 176.56,102.45 176.68,102.32 182.47,102.32 182.6,102.2 182.6,101.88 182.73,101.75 183.06,101.75 183.24,101.93 183.24,102.11 183.36,102.24 183.67,102.24 183.79,102.11 183.79,101.93 183.92,101.81 184.2,101.81 185.16,100.85 186.94,100.85 187.4,100.38 187.58,100.38 v1(187.75,100.55)
  BOTTOM w0.102: v1(170.42,101.51) 170.56,101.37 170.56,100.97 170.17,100.58 170.17,99.61 170.14,99.44 170.1,99.35 170.1,98.33 170.23,98.11 170.49,98.05 171.2,98.05 U6000.F28
MDA0_6: length 28.2
  TOP w0.127: U6801.M11 189.36,101.38 v1(189.33,101.38)
  IN3 w0.122: v1(170.43,103.46) 170.85,103.87 170.85,105.32 171.25,105.72 175.3,105.72 177.42,103.6 181.76,103.6 182.6,104.44 183.37,104.44 185.69,102.13 188.59,102.13 v1(189.33,101.38)
  BOTTOM w0.102: U6000.F32 171.23,99.88 171.5,100.15 171.5,101.75
  BOTTOM w0.127: 171.5,101.75 171.5,102.42 170.47,103.46 v1(170.43,103.46)
MDA0_7: length 25.1
  TOP w0.127: v1(187.75,101.42) 187.8,101.42 U6801.N13
  IN3 w0.122: v1(170.46,102.77) 172.77,105.08 175.33,105.08 177.24,103.18 182.09,103.18 182.43,103.52 183.69,103.52 185.51,101.7 187.47,101.7 v1(187.75,101.42)
  BOTTOM w0.102: 171.27,101.75 171.27,100.23 170.9,99.86 170.9,99.48 170.91,99.46 U6000.F30
  BOTTOM w0.127: v1(170.46,102.77) 171.27,101.96 171.27,101.75
MDA0_8: length 29.3
  IN1 w0.122: v1(197.36,105.41) 196.63,106.14 191.4,106.14 191.12,105.86 181.26,105.86 179.52,104.12 177.73,104.12 174.2,100.59 v1(174.2,99.97)
  BOTTOM w0.102: U6000.C30 172.83,99.06 173.26,99.49 173.26,99.87 173.48,100.09 173.87,100.09 173.99,99.97 v1(174.2,99.97)
  BOTTOM w0.127: U6800.A2 196.96,105.01 v1(197.36,105.41)
MDA0_9: length 33.5
  IN1 w0.122: v1(197.39,104.57) 197.79,104.98 197.79,105.64 196.86,106.57 191.23,106.57 190.95,106.29 181.08,106.29 179.34,104.55 177.5,104.55 173.36,100.41 173.36,99.36 v1(172.4,98.41)
  BOTTOM w0.102: v1(172.4,98.41) 172.4,97.92 172.04,97.56 171.85,97.56 171.51,97.22 U6000.F27
  BOTTOM w0.127: U6800.B2 196.99,104.18 v1(197.39,104.57)
MDA0_10: length 26.7
  IN1 w0.122: v1(194.98,104.56) 194.97,104.55 187.28,104.55 186.82,105.01 181.61,105.01 179.87,103.27 178.25,103.27 176.24,101.26 v1(176.24,100.7)
  BOTTOM w0.102: U6000.A28 174.41,98.02 174.71,98.32 174.71,98.61 174.99,98.9
  BOTTOM w0.127: v1(194.98,104.56) 195.36,104.18 U6800.B4 ; 174.99,98.9 174.99,99.03 175.52,99.55 175.64,99.55 176.1,100.01 176.1,100.56 v1(176.24,100.7) 176.73,101.2 v2(176.73,101.32)
MDA0_11: length 26.9
  IN1 w0.122: v1(174.83,99.94) 174.83,100.49 178.04,103.7 179.69,103.7 181.43,105.43 187,105.43 187.46,104.97 193.24,104.97 193.73,105.47 v1(194.87,105.47)
  BOTTOM w0.102: U6000.C28 172.83,98.17 173.23,98.57 173.23,99 173.46,99.23 173.88,99.23 174.21,99.56 174.45,99.56 v1(174.83,99.94)
  BOTTOM w0.127: U6800.A4 v1(194.87,105.47)
MDA0_12: length 26.6
  IN1 w0.122: v1(194.94,102.16) 194.42,101.63 192.61,101.63 192.37,101.39 190.87,101.39 190.42,101.83 186.26,101.83 186.06,101.63 185.5,101.63 185.29,101.83 184.86,101.83 184,100.97 180.64,100.97 179.58,99.91 178.2,99.91 177.2,98.91 176.95,98.91 176.05,98.01 175,98.01 174.57,98.44 v1(174.22,98.44)
  BOTTOM w0.102: v1(174.22,98.44) 173.52,98.44 173.26,98.18 173.26,97.91 172.9,97.56 172.37,97.56 U6000.E27
  BOTTOM w0.127: U6800.E4 195.32,101.78 v1(194.94,102.16)
MDA0_13: length 30.7
  IN1 w0.122: v1(197.34,101.39) 196.94,100.99 195.97,100.99 195.75,101.2 193.02,101.2 192.77,100.96 190.48,100.96 190.48,100.96 188.75,100.96 188.74,100.97 185.09,100.97 184.56,100.43 180.71,100.43 179.75,99.48 178.38,99.48 177.27,98.38 v1(177.01,98.38)
  BOTTOM w0.102: v1(177.01,98.38) 176.6,98.38 176.02,97.79 175.17,97.79 174.69,97.31 174.3,97.31 173.87,96.89 173.49,96.89 173.41,96.93 173.37,96.95 173.11,96.95 172.91,96.86 170.87,96.86 U6000.G26
  BOTTOM w0.127: v1(177.01,98.38) 177.01,97.74 v2(176.78,97.51) ; U6800.E2 v1(197.34,101.39)
MDA0_14: length 27.3
  IN1 w0.122: v1(197.39,100.58) 197,100.2 194.52,100.2 194.23,99.91 193.48,99.91 193.23,99.66 190.86,99.66 190.71,99.51 181.53,99.51 179.34,97.33 176.93,97.33 176.87,97.39 175.41,97.39 v1(175.29,97.26)
  BOTTOM w0.102: v1(175.29,97.26) 175.14,97.11 174.38,97.11 173.95,96.68 173.43,96.68 173.32,96.75 173.15,96.75 U6000.D26
  BOTTOM w0.127: U6800.F2 197.36,100.58 v1(197.39,100.58)
MDA0_15: length 28.1
  TOP w0.127: v1(171.67,96.05) 171.67,96.46 v2(171.96,96.75)
  IN1 w0.122: v1(171.67,96.05) 171.67,97.27 172.21,97.82 174.04,97.82 174.1,97.76 177.26,97.76 178.55,99.05 179.93,99.05 180.82,99.94 190.54,99.94 190.69,100.09 192.5,100.09 193.19,100.78 194.79,100.78 v1(194.95,100.61)
  BOTTOM w0.127: v1(171.67,96.05) U6000.F25 ; v1(194.95,100.61) 194.99,100.61 U6800.F4
MDA0_16: length 30.1
  IN3 w0.122: v1(189.37,95.8) 189.37,95.88 190.28,96.78 190.28,96.78 190.28,96.98 190.77,97.48 191.09,97.48 191.69,98.08 191.69,99.49 191.36,99.82 190.81,99.82 190.59,99.61 190.59,97.99 190.34,97.75 189.94,97.75 189.81,97.62 189.81,97.21 188.65,96.04 185.71,96.04 184,97.74 v1(179.14,97.74)
  BOTTOM w0.102: 176.61,95.89 175.25,95.89 174.98,95.62 U6000.A25
  BOTTOM w0.127: U6800.M11 189.75,96.18 v1(189.37,95.8) ; v2(180.34,97.74) v1(179.14,97.74) 179.14,96.13 178.89,95.89 176.61,95.89
MDA0_17: length 27.3
  IN3 w0.122: v1(178.5,97.76) 178.09,98.17 178.09,99.02 178.25,99.18 178.93,99.18 179.05,99.06 179.05,98.3 179.17,98.17 179.42,98.17 179.54,98.3 179.54,99.06 179.66,99.18 179.9,99.18 180.03,99.06 180.03,98.24 180.1,98.17 180.41,98.17 180.51,98.27 180.51,99.06 180.63,99.18 180.88,99.18 181,99.06 181,98.24 181.08,98.17 181.39,98.17 181.49,98.27 181.49,99.06 181.61,99.18 181.85,99.18 181.98,99.06 181.98,98.24 182.05,98.17 182.36,98.17 182.46,98.27 182.46,99.06 182.59,99.18 183.17,99.18 185.69,96.66 186.01,96.66 186.29,96.93 187.41,96.93 v1(187.75,96.59)
  BOTTOM w0.102: 176.37,96.17 175.17,96.17 174.95,95.95 173.56,95.95 U6000.C25
  BOTTOM w0.127: U6800.M13 v1(187.75,96.59) ; v1(178.5,97.76) v2(178.5,97.08) 178.5,96.6 178.22,96.32 176.86,96.32 176.71,96.17 176.37,96.17
MDA0_18: length 29.6
  IN3 w0.122: v1(187.74,94.99) 187.7,95.04 185.5,95.04 184.11,96.43 182.2,96.43 182.18,96.44 182.18,96.44 181.77,96.85 178.08,96.85 177.43,97.5 177.43,99.14 176.34,100.23 176,100.23 175.64,100.59 173.63,100.59 173.51,100.46 173.51,99.17 173.72,98.96 173.72,96.67 175.13,95.25 v1(175.13,94.72)
  BOTTOM w0.102: v1(175.13,94.72) 175.13,95.05 174.96,95.23 173,95.23 172.85,95.07 172.85,94.67 172.67,94.49 172.35,94.49 172.25,94.54 172.1,94.68 172.1,95.34 172.03,95.41 U6000.E25
  BOTTOM w0.127: U6800.N13 187.77,94.99 v1(187.74,94.99)
MDA0_19: length 31.6
  IN3 w0.122: v1(177.86,97.76) 178.34,97.27 181.95,97.27 182.11,97.12 182.11,97.11 182.35,96.87 182.36,96.87 182.37,96.85 184.29,96.85 185.53,95.61 188.92,95.61 189.15,95.39 189.55,95.39 190.71,96.55 190.71,96.81 190.95,97.05 191.59,97.05 192.84,98.3 193.22,98.3 193.42,98.1 193.42,97.84 191.66,96.08 190.86,96.08 190.61,95.84 190.61,95.48 v1(190.15,95.02)
  BOTTOM w0.102: U6000.D24 172.43,95.68 172.69,95.95 173.07,95.95 173.51,96.15 174.87,96.15 175.16,96.45 176.54,96.45 177.35,97.25
  BOTTOM w0.127: U6800.N11 190.11,95.02 v1(190.15,95.02) ; v2(178.03,98.76) 177.86,98.58 v1(177.86,97.76) 177.35,97.25
MDA0_20: length 27.7
  IN3 w0.122: v1(176.2,93.32) 177.21,94.33 178.66,94.33 178.78,94.21 179.14,94.21 179.27,94.33 179.63,94.33 179.75,94.21 180.12,94.21 180.24,94.33 180.72,94.33 181.06,93.99 181.06,93.81 180.87,93.62 180.87,93.5 181.07,93.3 181.25,93.3 181.81,93.86 181.99,93.86 182.12,93.73 182.12,93.53 181.63,93.04 181.63,92.79 181.76,92.66 181.92,92.66 182.04,92.54 182.04,92.18 182.14,92.08 182.43,92.08 182.56,92.2 182.56,93.4 182.7,93.55 182.92,93.55 183.04,93.42 183.04,92.2 183.17,92.08 183.41,92.08 183.56,92.22 183.56,92.76 183.7,92.9 183.88,92.9 184.02,92.76 184.02,92.2 184.12,92.1 184.3,92.1 184.43,92.23 184.61,92.23 184.76,92.08 186.69,92.08 186.89,92.28 187.12,92.28 187.2,92.2 187.2,92.16 187.29,92.08 187.47,92.08 187.55,92.16 187.55,92.46 187.68,92.59 v1(187.78,92.59)
  BOTTOM w0.102: 175.34,92.95 174.07,92.95 174.06,92.95 173.49,92.95 173.28,92.89 173.13,92.89 173.03,92.96 172.83,93.15 172.83,93.28 172.61,93.5 172.35,93.69 U6000.E23
  BOTTOM w0.114: v1(176.2,93.32) 176.2,94.18 176.07,94.3 175.84,94.3 175.72,94.18 175.72,93.17 175.5,92.95 175.34,92.95
  BOTTOM w0.127: U6800.T13 188.16,92.71 188.03,92.59 v1(187.78,92.59)
MDA0_21: length 27.4
  IN3 w0.122: v1(188.57,92.59) 188.15,93 187.34,93 186.84,92.5 186.17,92.5 184.95,92.5 183.68,93.77 183.34,93.77 182.78,94.33 181.33,94.33 181.31,94.35 181.31,94.35 180.9,94.75 177.02,94.75 175.62,93.35 175.62,92.75 175.22,92.36 172.85,92.36 172.65,92.56 172.65,92.85 172.84,93.04 174.29,93.04 174.54,92.79 174.9,92.79 175.17,93.06 v1(175.17,93.36)
  BOTTOM w0.102: U6000.F23 171.57,94.34 171.58,94.35 172.1,94.35 172.21,94.3 172.43,94.08 172.44,94.01 172.49,93.88 172.7,93.69 172.76,93.65 172.94,93.65 173.19,93.63 173.51,93.48 174.04,93.48 174.35,93.8 174.71,93.8 175.15,93.36 v1(175.17,93.36)
  BOTTOM w0.127: v1(188.57,92.59) 188.16,92.18 U6800.U13
MDA0_22: length 28.2
  IN3 w0.122: v1(189.36,92.58) 189.67,92.58 189.73,92.52 189.73,92.39 189.97,92.14 190.32,92.14 190.56,92.39 190.56,92.69 190.68,92.81 191,92.81 191.13,92.68 191.13,91.78 191,91.65 189.45,91.65 189.35,91.75 189.35,92.01 189.15,92.2 188.91,92.2 188.79,92.08 188.79,91.75 188.69,91.65 188.43,91.65 188.3,91.78 188.3,92.08 188.18,92.2 187.99,92.2 187.83,92.05 187.83,91.76 187.72,91.65 181.83,91.65 180.37,93.11 180.37,93.45 180.04,93.78 177.27,93.78 v1(176.81,93.32)
  BOTTOM w0.102: U6000.D22 172.77,92.87 172.9,92.8 173.07,92.68 173.31,92.68 173.52,92.75 174.05,92.75 174.16,92.73 174.17,92.73 176.22,92.73 v1(176.81,93.32)
  BOTTOM w0.127: v1(189.36,92.58) 189.36,91.82 189.46,91.72 189.67,91.72 189.76,91.81 U6800.U11 ; v1(176.81,93.32) 177.42,93.93 v2(177.62,93.93)
MDA0_23: length 28.9
  IN3 w0.122: v1(190.14,92.56) 190.14,92.96 191.1,93.91 191.36,93.91 191.55,93.72 191.55,91.35 191.43,91.22 181.65,91.22 179.91,92.97 v1(179.91,93.32)
  BOTTOM w0.102: U6000.F21 171.56,92.75 172.17,92.75 172.36,92.55 172.36,92.42 172.73,92.05 173.14,92.05 173.46,91.91 173.49,91.89 173.61,91.88 173.8,91.88 174.2,91.95 174.27,92.02 174.93,92.02 175.02,91.94
  BOTTOM w0.127: 175.02,91.94 177.02,91.94 177.29,91.68 178.47,91.68 179.55,92.76 179.55,92.97 v1(179.91,93.32) v2(180.57,93.32) ; U6800.T11 190.14,92.59 v1(190.14,92.56)
MDA0_24: length 34
  TOP w0.127: v1(197.37,96.55) 197.33,96.55 U6801.F2
  IN3 w0.122: v1(171.92,91.87) 172.75,91.04 174.54,91.04 175.82,92.32 179.72,92.32 181.24,90.8 191.85,90.8 191.98,90.92 191.98,94.03 191.59,94.42 191.59,95.38 193.16,96.95 193.51,96.95 196.97,96.95 v1(197.37,96.55)
  BOTTOM w0.102: v1(171.92,91.87) 172.03,91.97 U6000.E21
MDA0_25: length 31.3
  TOP w0.127: U6801.E4 195.76,95.79 v1(195.78,95.79)
  IN3 w0.122: v1(195.78,95.79) 195.35,95.36 194.01,95.36 193.57,94.92 193.57,92.7 193.26,92.39 193.26,89.95 192.83,89.52 180.71,89.52 179.19,91.04 177.95,91.04 v1(177.72,90.81)
  BOTTOM w0.102: U6000.D20 173.16,91.29 173.31,91.29 173.44,91.35 174.16,91.35 174.22,91.34 174.34,91.21 174.7,91.21 174.93,91.45 174.93,91.48 175.05,91.59
  BOTTOM w0.127: 175.05,91.59 176.94,91.59 v1(177.72,90.81) v2(178.38,90.81)
MDA0_26: length 34.6
  TOP w0.127: U6801.E2 v1(197.34,95.77)
  IN3 w0.122: v1(171.64,91.24) 172.44,90.45 174.55,90.45 175.99,91.89 179.54,91.89 181.06,90.37 192.28,90.37 192.41,90.5 192.41,94.21 192.02,94.6 192.02,95.2 193.34,96.52 196.59,96.52 v1(197.34,95.77)
  BOTTOM w0.102: U6000.F19 171.66,91.24 v1(171.64,91.24)
MDA0_27: length 28.5
  TOP w0.127: v1(194.92,95.79) 194.96,95.79 U6801.F4
  IN3 w0.122: v1(175.69,90.88) 175.69,90.99 176.17,91.46 179.36,91.46 180.89,89.94 192.65,89.94 192.83,90.13 192.83,94.75 192.74,94.85 192.74,95.31 193.11,95.69 194.1,95.69 194.19,95.79 v1(194.92,95.79)
  BOTTOM w0.102: U6000.A19 174.11,90.82 174.15,90.77 175.25,90.77 175.36,90.88 v1(175.69,90.88)
MDA0_28: length 30
  TOP w0.127: v1(194.99,92.57) 195.36,92.94 U6801.B4
  IN3 w0.122: v1(175.72,90.05) 175.88,90.05 177.01,88.91 177.26,88.91 178.34,88.91 179.83,87.42 194.83,87.42 195.52,88.12 195.52,88.82 195.66,88.95 195.66,90.5 195.48,90.67 195.48,92.07 v1(194.99,92.57)
  BOTTOM w0.102: U6000.D18 173.15,90.35 173.16,90.35 173.27,90.35 173.52,90.28 174.1,90.28 174.27,90.35 175.13,90.35 175.44,90.05 v1(175.72,90.05)
MDA0_29: length 33.1
  TOP w0.127: v1(195.79,92.58) 195.39,92.18 U6801.A4
  IN3 w0.122: v1(195.79,92.58) 196.92,91.46 196.92,89.25 196.56,88.89 196.19,88.89 195.95,88.64 195.95,87.9 195.04,87 179.65,87 178.16,88.49 177.76,88.49 177.76,88.49 177,88.49 177,88.49 176.83,88.49 175.88,89.44 175.46,89.44 v1(174.98,89.92)
  BOTTOM w0.102: U6000.F17 171.56,89.22 171.87,89.52 172.78,89.69 173.37,89.69 173.51,89.75 173.59,89.75 173.82,89.75 173.97,89.71 174.18,89.54 174.58,89.54 174.64,89.6 174.66,89.6 v1(174.98,89.92)
MDA0_30: length 35.3
  TOP w0.127: v1(197.33,93.37) 196.96,93 U6801.B2
  IN3 w0.122: v1(197.33,93.37) 197.75,92.95 197.75,92.42 198.17,92 198.17,89.9 198.18,89.89 198.18,89.54 198.17,89.53 198.17,89.47 198.16,89.46 198.16,88.28 197.59,87.71 197.59,87.49 197.58,87.48 197.58,87.13 197.59,87.12 197.59,87.05 197.87,86.77 197.87,86.31 197.61,86.06 195.35,86.06 194.5,85.2 187.44,85.2 187.2,84.97 185.15,84.97 184.62,84.45 183.02,84.45 181.32,86.14 179.3,86.14 177.81,87.63 176.27,87.63 174.93,88.97 v1(174.93,88.98)
  BOTTOM w0.102: v1(174.93,88.98) 174.62,88.98 174.48,89.12 173.96,89.12 173.86,89.22 U6000.A17
MDA0_31: length 32.9
  TOP w0.127: v1(196.57,92.59) 196.96,92.2 U6801.A2
  IN3 w0.122: v1(175.55,88.99) 176.49,88.06 177.94,88.06 177.98,88.06 179.47,86.57 182.24,86.57 182.5,86.31 182.5,85.68 182.87,85.31 184.75,85.31 185.57,86.13 194.78,86.13 195.22,86.57 197.35,88.7 197.35,91.81 v1(196.57,92.59)
  BOTTOM w0.102: U6000.C17 173.56,89.55 173.6,89.55 173.79,89.55 173.88,89.52 174.11,89.34 174.66,89.34 174.71,89.39 175.16,89.39 v1(175.55,88.99)
MDA1_0: length 21
  TOP w0.127: v1(186.89,86.58) 186.91,86.59 187.58,86.59 U6803.A2
  IN1 w0.122: v1(186.89,86.58) 186.89,86.59 186.5,86.98 186.12,86.98 185.95,86.82 185.95,85.96 185.78,85.78 185.55,85.78 185.37,85.96 185.37,86.9 185.24,87.02 179.63,87.02 179.42,86.82 v1(178.03,86.82)
  BOTTOM w0.102: U6000.E17 172.36,89.22 172.69,88.89 172.97,88.89 173.11,88.95 173.27,88.95 173.37,88.95 173.48,88.89 174.42,88.89 174.74,88.57 176.39,88.57
  BOTTOM w0.127: v2(178.41,87.66) 178.41,87.2 v1(178.03,86.82) 178.03,87.3 176.76,88.57 176.39,88.57
MDA1_1: length 20.5
  TOP w0.127: U6803.B2 187.77,85.59 v1(187.77,85.62)
  IN1 w0.122: v1(187.77,85.62) 187.4,85.99 187.4,86.8 186.57,87.63 184.42,87.63 184.3,87.75 184.3,88.2 184.18,88.32 183.93,88.32 183.81,88.2 183.81,87.75 183.69,87.63 179.17,87.63 178.78,87.24 177.82,87.24 v1(177.42,86.85)
  BOTTOM w0.102: 176.43,88.34 174.68,88.34 174.34,88.68 173.43,88.68 173.31,88.75 173.24,88.75 173.16,88.75 U6000.D16
  BOTTOM w0.127: v2(177.32,86.18) 177.42,86.29 v1(177.42,86.85) 177.42,87.43 176.51,88.34 176.43,88.34
MDA1_2: length 27.6
  TOP w0.127: v1(190.16,85.64) 190.16,85.61 189.77,85.22 U6803.B4
  IN1 w0.122: v1(190.16,85.64) 191.08,86.56 191.08,87.09 187.61,90.56 178.72,90.56 177.45,89.29 176.43,89.29 175.97,88.83 175.97,88.82 175.73,88.58 175.72,88.58 175.26,88.12 175.26,87.18 v1(175.59,86.85)
  BOTTOM w0.102: U6000.F15 171.56,87.29 172.17,87.29 172.46,87.58 172.46,87.71 172.69,87.95 172.97,87.95 173.2,87.72 173.22,87.56 173.49,87.29 173.51,87.29 173.87,87.29 174.02,87.43 174.68,87.43 174.87,87.24 175.2,87.24 v1(175.59,86.85)
MDA1_3: length 22.4
  TOP w0.127: U6803.A4 190.21,86.44 v1(190.21,86.55)
  IN1 w0.122: v1(176.2,86.87) 175.92,87.15 175.92,88.01 176.71,88.8 177.57,88.8 178.91,90.14 187.44,90.14 190.21,87.37 v1(190.21,86.55)
  BOTTOM w0.102: v1(176.2,86.87) 176.2,87.51 176.08,87.64 v2(175.72,87.64) 173.93,87.64 173.91,87.62 U6000.A15
MDA1_4: length 20
  TOP w0.127: v1(189.33,82.39) 189.38,82.39 U6803.F4
  IN1 w0.122: v1(189.33,82.39) 188.9,82.82 188.39,82.82 188.36,82.8 185.04,82.8 184.99,82.85 182.44,82.85 180.9,84.39 177.27,84.39 177.14,84.52 v1(177.14,85.3)
  BOTTOM w0.102: U6000.D14 173.16,86.49 173.28,86.49 173.5,86.55 173.91,86.55 174.52,86.28 175.24,86.28 175.57,85.96 175.77,85.96
  BOTTOM w0.127: v1(177.14,85.3) 177.14,85.7 176.89,85.96 175.77,85.96
MDA1_5: length 21.6
  TOP w0.127: v1(187.78,83.22) 187.78,83.2 188.17,82.81 U6803.E2
  IN1 w0.122: v1(177.65,84.84) 181.28,84.84 182.07,84.05 182.32,84.05 182.47,83.9 182.47,83.49 182.63,83.34 182.93,83.34 183.11,83.52 183.11,83.9 183.26,84.05 183.87,84.05 184,83.92 184,83.44 184.12,83.31 184.43,83.31 184.56,83.44 184.56,83.81 184.68,83.93 185.18,83.93 185.44,83.68 187.32,83.68 v1(187.78,83.22)
  BOTTOM w0.102: U6000.F13 171.69,86.35 172.97,86.35 173.11,86.28 173.3,86.28 173.53,86.35 173.87,86.35 174.14,86.07 175.15,86.07 175.52,85.71 176.42,85.71
  BOTTOM w0.127: v2(178.44,84.84) v1(177.65,84.84) 176.98,84.84 176.7,85.13 176.7,85.46 176.45,85.71 176.42,85.71
MDA1_6: length 18
  TOP w0.127: v1(189.34,83.21) 189.36,83.21 U6803.E4
  IN1 w0.122: v1(175.67,85.27) 176.12,85.73 177.32,85.73 177.7,85.35 181.74,85.35 181.97,85.12 181.97,84.81 182.25,84.53 185.23,84.53 185.66,84.11 187.5,84.11 187.83,83.77 188.77,83.77 v1(189.34,83.21)
  BOTTOM w0.102: U6000.A13 173.78,85.87 175.07,85.87 v1(175.67,85.27)
MDA1_7: length 19.2
  TOP w0.127: U6803.F2 187.8,82.36 v1(187.78,82.36)
  IN1 w0.122: v1(187.78,82.36) 184.87,82.36 184.82,82.42 182.27,82.42 180.72,83.96 176.94,83.96 176.8,84.1 174.25,84.1 174.12,84.23 174.12,84.61 174.25,84.74 174.88,84.74 175.01,84.86 v1(175.01,85.27)
  BOTTOM w0.102: U6000.C13 173.18,85.67 174.61,85.67 v1(175.01,85.27)
MDA1_8: length 29.5
  IN1 w0.122: v1(195.77,86.53) 193.31,86.53 191.14,84.36 191.13,84.36 190.38,83.61 190.37,83.61 190.03,83.61 189.76,83.34 189.76,82.24 189.75,82.23 189.75,82.22 189.51,81.97 189.49,81.97 189.48,81.96 189.16,81.96 189.14,81.98 188.39,81.98 188.35,81.94 184.69,81.94 184.64,81.99 181.91,81.99 180.38,83.52 v1(178.31,83.52)
  BOTTOM w0.102: 176.39,84.83 174.13,84.83 174.01,84.95 173.51,84.95 173.48,84.94 173.37,84.89 172.5,84.89 U6000.E11
  BOTTOM w0.127: 176.39,84.83 176.81,84.41 177.42,84.41 v1(178.31,83.52) v2(179.02,82.81) ; U6802.U11 195.77,86.4 v1(195.77,86.53)
MDA1_9: length 26.7
  IN1 w0.122: v1(195.74,85.6) 193.84,85.6 191.61,83.37 191.61,83.06 191.03,82.48 191.03,82.07 190.52,81.56 190.3,81.56 189.46,80.72 187.05,80.72 186.98,80.79 186.64,80.79 186.52,80.67 184.75,80.67 184.29,81.14 181.45,81.14 180.12,82.46 177.33,82.46 v1(176.22,83.57)
  BOTTOM w0.102: v1(176.22,83.57) 175.37,84.42 U6000.A11
  BOTTOM w0.127: v1(195.74,85.6) 195.74,85.57 U6802.T11
MDA1_10: length 30.5
  IN1 w0.122: v1(177.67,83.52) 178.3,82.89 180.3,82.89 181.62,81.57 184.46,81.57 184.93,81.1 186.34,81.1 186.46,81.22 187.16,81.22 187.23,81.15 189.28,81.15 190.12,81.99 190.35,81.99 190.61,82.25 190.61,82.66 190.62,82.67 190.62,83.24 191.3,83.93 191.31,83.93 193.47,86.09 196.93,86.09 v1(197.37,86.53)
  BOTTOM w0.102: U6000.C11 173.56,84.75 173.93,84.75 174.05,84.63 175.89,84.63 176.42,84.09
  BOTTOM w0.127: v2(177.29,82.88) 177.29,83.14 v1(177.67,83.52) 177.22,83.97 176.54,83.97 176.42,84.09 ; v1(197.37,86.53) 197.37,86.41 196.96,86 U6802.U13
MDA1_11: length 32.4
  IN1 w0.122: v1(175.58,83.56) 177.11,82.03 179.89,82.03 181.76,80.16 186.21,80.16 186.74,79.63 187.92,79.63 187.95,79.61 189.19,79.61 189.19,79.61 190.33,79.61 190.6,79.87 190.6,81.03 191.47,81.89 191.47,82.3 192.05,82.88 192.05,83.2 194,85.15 195.55,85.15 195.58,85.18 196.97,85.18 v1(197.38,85.59)
  BOTTOM w0.102: U6000.F11 171.56,84.09 172.97,84.09 173.11,84.15 173.28,84.15 173.4,84.13 173.52,84.09 173.76,84.09 173.88,84.1 174.1,84.16 174.98,84.16 v1(175.58,83.56)
  BOTTOM w0.127: v1(197.38,85.59) 196.99,85.2 U6802.T13
MDA1_12: length 33.1
  IN1 w0.122: v1(197.36,83.22) 196.96,82.82 196.4,82.82 196.39,82.8 195.58,82.8 194.63,81.85 194.63,81.75 194.42,81.54 194.42,78.64 194.1,78.32 194.1,77.13 192.53,75.56 190.79,75.56 190.72,75.63 187.99,75.63 187.75,75.87 184.69,75.87 183.57,76.99 181.32,76.99 179.29,79.02 178.74,79.02 177.65,80.11 v1(177.65,80.39)
  BOTTOM w0.102: U6000.A9 173.72,82.73 174.01,82.73 174.34,82.73 174.34,82.73 175.03,82.73 175.99,81.77
  BOTTOM w0.127: v1(197.36,83.22) 196.97,82.82 U6802.N13 ; 175.99,81.77 176.3,81.77 v2(176.89,81.18) 177.65,80.42 v1(177.65,80.39)
MDA1_13: length 33.5
  IN1 w0.122: v1(176.43,80.39) 176.43,79.61 179.47,76.56 182.74,76.56 183.87,75.44 186.92,75.44 187.8,74.56 192.76,74.56 194.53,76.33 194.53,78.15 194.85,78.47 194.85,81.36 195.04,81.56 195.04,81.67 v1(195.76,82.39)
  BOTTOM w0.102: U6000.C9 173.61,82.46 174.66,82.46 175.76,81.36
  BOTTOM w0.127: v1(195.76,82.39) 195.74,82.39 195.37,82.01 U6802.M11 ; 175.76,81.36 176.43,80.69 v1(176.43,80.39)
MDA1_14: length 33.7
  IN1 w0.122: v1(195.78,83.23) 195.36,83.23 194.37,82.24 194.37,82.09 193.57,81.29 193.57,78.14 191.42,75.99 190.96,75.99 190.9,76.06 188.17,76.06 187.39,76.84 184.33,76.84 183.75,77.42 182.12,77.42 181.67,77.87 181.05,77.87 179.4,79.51 178.88,79.51 178.26,80.13 v1(178.26,80.39)
  BOTTOM w0.102: U6000.F9 171.55,82.49 172.17,82.49 172.44,82.76 172.46,82.91 172.69,83.15 172.9,83.15 173.05,83.08 173.41,83.08 173.55,83.14 173.58,83.15 173.86,83.15 173.88,83.14 174.08,82.94 175.76,82.94 176.42,82.27
  BOTTOM w0.127: U6802.N11 195.37,82.82 v1(195.78,83.23) ; v1(178.26,80.39) 178.08,80.57 178.08,80.62 176.42,82.27
MDA1_15: length 35.7
  IN1 w0.122: v1(175.82,80.39) 175.82,79.56 179.24,76.14 182.28,76.14 184.28,74.14 193.19,74.14 193.65,74.6 194.13,74.6 195.36,75.83 195.36,77.82 195.27,77.91 195.27,80.39 196.48,81.59 v1(197.38,81.59)
  BOTTOM w0.102: U6000.D8 172.88,82.35 173.37,82.35 173.57,82.26 174.4,82.26 175.82,80.84 v1(175.82,80.39)
  BOTTOM w0.127: U6802.M13 196.98,82 v1(197.38,81.59)
