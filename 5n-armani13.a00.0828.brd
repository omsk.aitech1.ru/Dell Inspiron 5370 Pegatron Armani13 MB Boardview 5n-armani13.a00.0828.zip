# Allegro board 5n-armani13.a00.0828.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK_PCIE_NVME_REQ#: length 161.5
  TOP w0.102: R1002.2 104.72,30.86 105,31.14 105,31.56 104.51,32.05 104.51,32.63 v3(104.55,32.67) 107.62,35.74 v3(107.62,35.82) ; v1(158.88,12.73) 158.98,12.63 159.4,12.63 160.14,11.89 164.21,11.89 164.87,11.23 171.95,11.23 172.71,11.99 v2(175.64,11.99) 175.69,11.99 176.4,11.28 181.27,11.28 181.9,10.65 188.42,10.65 190.3,12.52 201.09,12.52 208.19,19.63 210.56,19.63 212.13,18.06 214.02,18.06 214.4,18.44 216.41,18.44 218.44,16.41 218.44,14.33 217.56,13.44 217.56,11.24 216.76,10.44 214.7,10.44 214.22,9.96 214.22,7.75 214.86,7.11 216.13,7.11 217.27,5.97 220.9,5.97 221.08,5.79 R3104.1
  IN1 w0.097: v1(158.88,12.73) 158.86,12.74 150.82,12.74 149.5,11.43 147.85,11.43 147.26,12.02 138.32,12.02 136.84,13.51 129.85,13.51 126.65,16.72 120.98,16.72 120.07,17.63 116.87,17.63 111.07,23.43 111.07,27.12 110.61,27.58 109.26,27.58 109.11,27.43 108.07,27.43 107.76,27.73 107.76,28.77 105.33,31.2 105.33,32.41 105.08,32.67 v3(104.55,32.67)
  BOTTOM w0.102: v3(107.62,35.82) 107.48,35.96 107.48,36.89 U0400.AU8
CLK_PCIE_PEG_REQ#: length 255.1
  TOP w0.102: v1(189.76,62.99) 191.5,61.25 194.04,61.25 195.81,63.03 195.81,66.69 v2(197.31,68.2) 199.3,70.18 208.91,70.18 209.5,69.59 209.5,66.63 v1(210.27,65.86) ; v1(168.9,69.66) 168.9,71.06 163.35,76.61 163.35,78.92 162.94,79.33 162.94,80.5 163.98,81.54 163.98,82.22 164.19,82.43 R6908.1 ; v3(108.76,37.65) 109.07,37.34 109.07,36.48 108.84,36.25 107.47,36.25 104.1,32.88 104.1,31.82 v3(104.45,31.47) 104.22,31.24 104.14,31.24 103.76,30.86 R1004.2 R1030.1
  IN1 w0.097: v1(168.9,69.66) 171.26,69.66 172.18,68.74 172.9,68.74 174.22,67.42 179.5,67.42 181.2,65.72 181.2,64.4 182.27,63.32 189.43,63.32 v1(189.76,62.99) ; v3(104.45,31.47) 107.36,28.56 107.36,27.57 107.9,27.03 109.69,27.03 110.67,26.05 110.67,23.27 117.76,16.18 121.56,16.18 121.69,16.31 126.44,16.31 129.64,13.11 136.65,13.11 138.14,11.62 147.09,11.62 147.68,11.03 149.67,11.03 150.99,12.34 152.2,12.34 152.77,11.77 162.38,11.77 162.95,11.21 176.42,11.21 176.84,10.8 181.18,10.8 181.63,10.34 195.96,10.34 202.77,17.15 204.37,17.15 205.41,18.19 205.41,19.59 212.32,26.5 212.32,35.9 214.71,38.29 214.71,43.59 213.54,44.77 213.54,47.63 207.49,53.67 207.49,58.19 210.27,60.97 v1(210.27,65.86)
  BOTTOM w0.102: U0400.AR10 109.08,37.97 v3(108.76,37.65)
CLK_PCIE_PEG_REQ#_R: length 2.6
  TOP w0.102: v1(165.3,80.88) 165.3,81 164.74,81.56 R6908.2 164.64,80.83 v2(164.54,80.72)
  BOTTOM w0.102: v1(165.3,80.88) 165.49,80.88 U6000.N7
CLK_PCIE_SSD_REQ#_R: length 6.9
  TOP w0.102: v2(223.22,5.97) 223.22,5.62 v1(222.91,5.31) 222.91,5.54 222.66,5.79 R3104.2
  BOTTOM w0.102: v1(222.91,5.31) 222.68,5.31 221.67,6.33 221.67,7.77 221.99,8.1 CON3100.52
CLK_PCIE_WLAN_REQ#: length 155.6
  TOP w0.102: v1(153.11,12.25) 153.24,12.37 153.24,12.45 155.04,14.25 164.36,14.25 165.6,13.01 169.27,13.01 v1(170.05,13.79) ; v3(108.74,35.82) 108.59,35.66 108.59,35.51 105.74,32.67 v3(105.74,32.21) 106.5,31.45 R1003.2
  IN1 w0.097: v3(105.74,32.21) 107.36,30.59 108.38,30.59 108.92,30.05 109.54,30.05 110.87,28.71 110.87,28.46 111.97,27.36 112.31,27.02 112.31,25.75 111.87,25.32 111.87,23.77 114.15,21.49 117.68,21.49 120.96,18.21 122.4,18.21 122.63,18.44 126.44,18.44 130.2,14.68 v1(130.2,14.46)
  IN3 w0.127: v1(153.11,12.25) 153.11,12.3 152.55,12.87 150.82,12.87 149.27,11.31 139.17,11.31 138.87,11.01 132.66,11.01 130.2,13.48 v1(130.2,14.46) ; v1(174.13,18.35) 174.79,17.69 179.6,17.69 179.96,17.34 194.72,17.34 197.32,19.94 197.32,20.67 198.81,22.15 198.81,22.74 200.59,24.53 202.25,24.53 202.69,24.97 205.18,24.97 209.3,29.09 213.56,29.09 214.12,29.64 214.12,30.78 205.38,39.52 v1(205.19,39.52)
  BOTTOM w0.102: U0400.AT7 108.74,35.98 v3(108.74,35.82) ; v2(152.71,13.41) 153.11,13.01 v1(153.11,12.25) ; v1(174.13,18.35) 172.32,16.54 171.3,16.54 170.05,15.29 v1(170.05,13.79) ; CON5103.34 205.42,39.76 v1(205.19,39.52)
CLK_TP_SIO: length 29.5
  TOP w0.102: R2338.2 34.19,24.18 v1(34.52,24.51) 33.7,25.34 v2(33.7,26.47) U2300.78
  IN1 w0.097: v1(34.52,24.51) 34.52,22.8 35.33,21.99 35.33,18.19 38.43,15.09 39.7,15.09 v1(39.7,15.09)
  BOTTOM w0.102: v1(39.7,15.09) 39.7,7.16 42.3,4.56 Q5104.3
CLK_TP_SIO_C: length 27.1
  TOP w0.102: R5106.2 59.35,8.95 v2(59.08,9.22) C5130.1 58.45,10.14 58.44,10.14 D5103.1 57.81,9.43 57.63,9.25 v1(57.63,8.94)
  IN1 w0.097: v1(40.26,7.85) 44.97,7.85 46.05,8.93 46.67,8.93 47.21,8.39 51.45,8.39 51.67,8.18 55.8,8.18 56.57,8.94 v1(57.63,8.94)
  BOTTOM w0.102: CON5100.1 57.73,9.35 57.63,9.25 v1(57.63,8.94) ; v1(40.26,7.85) 40.26,7.47 41.43,6.3 Q5104.4
CLKA0: length 46.1
  TOP w0.114: U6801.J12 188.55,98.17 v1(188.52,98.17)
  IN3 w0.147: v1(169.24,96.01) 169.39,96.01 169.67,96.29 169.67,96.6 170.05,96.98 172.58,96.98 172.83,97.23 172.83,98.59 172.58,98.84 171.86,98.84 171.09,99.6 171.09,101.27 172.01,102.19 173.99,102.19 174.5,101.68 177.23,101.68 177.5,101.41 177.5,100.33 177.63,100.2 178.36,100.2 178.49,100.33 178.49,101.4 178.77,101.68 179.6,101.68 179.87,101.41 179.87,100.28 180,100.15 180.62,100.15 180.75,100.28 180.75,101.38 181.05,101.68 181.84,101.68 182.14,101.38 182.14,100.23 182.3,100.07 182.81,100.07 182.99,100.26 182.99,100.87 183.27,101.14 183.95,101.14 184.3,100.8 184.3,99.34 184.48,99.16 185.12,99.16 185.37,98.9 185.37,98.42 185.5,98.3 187.81,98.3 188.22,97.89 188.39,97.89 188.52,98.02 v1(188.52,98.17) 188.72,98.37 188.72,98.7 188.68,98.74 188.68,99.52 188.55,99.65 186.1,99.65 185.83,99.92 185.83,99.98 v1(185.45,100.36)
  BOTTOM w0.114: U6801.J12 188.55,98.17 v1(188.52,98.17) ; v1(185.45,100.36) 185.61,100.52 185.61,100.98 185.3,101.29 185.08,101.29 R6812.2 ; v1(169.24,96.01) 169.24,96.02 U6000.H26
CLKA0#: length 46.6
  TOP w0.114: U6801.J11 189.36,98.18 v1(189.33,98.18)
  IN3 w0.147: v1(170.03,96.06) 169.93,96.16 169.93,96.5 170.16,96.73 172.69,96.73 173.08,97.12 173.08,98.69 172.68,99.09 171.96,99.09 171.34,99.7 171.34,101.17 172.11,101.94 173.89,101.94 174.39,101.43 177.13,101.43 177.25,101.3 177.25,100.22 177.53,99.95 178.46,99.95 178.74,100.22 178.74,101.3 178.87,101.43 179.5,101.43 179.62,101.31 179.62,100.17 179.89,99.9 180.72,99.9 181,100.18 181,101.28 181.16,101.43 181.73,101.43 181.89,101.28 181.89,100.13 182.19,99.82 182.91,99.82 183.24,100.16 183.24,100.77 183.37,100.9 183.85,100.9 184.05,100.69 184.05,99.24 184.38,98.91 185.01,98.91 185.12,98.8 185.12,98.32 185.4,98.05 187.71,98.05 188.12,97.64 188.79,97.64 v1(189.33,98.18) 188.97,98.53 188.97,98.8 188.93,98.84 188.93,99.63 188.66,99.9 186.21,99.9 186.08,100.03 v1(186.08,100.36)
  BOTTOM w0.114: R6813.2 185.12,101.5 185.39,101.5 185.83,101.07 185.83,100.61 v1(186.08,100.36) ; v1(170.03,96.06) 170.03,96.02 U6000.H25 ; v1(189.33,98.18) 189.36,98.18 U6801.J11
CLKA1: length 49.5
  TOP w0.114: v1(196.56,79.97) 196.54,79.97 U6803.J12
  IN1 w0.127: v1(199.55,81.09) 199.24,81.09 199.01,80.85 199.01,80.68 198.42,80.09 196.68,80.09 v1(196.56,79.97) 196.56,79.42 197.27,78.71 197.27,74.98 196.68,74.39 195.92,74.39 193.57,72.04 184.91,72.04 181.82,75.12 180.26,75.12 180.13,75 180.13,72.96 179.87,72.7 179.17,72.7 178.91,72.96 178.91,75 178.8,75.11 176.84,75.11 171.07,80.88 171.07,82.08 170.49,82.65 170.27,82.65 v1(170.03,82.42)
  BOTTOM w0.102: U6000.G9 v1(170.03,82.42)
  BOTTOM w0.114: R6814.2 199.97,81.31 199.78,81.31 v1(199.55,81.09) ; v1(196.56,79.97) 196.54,79.97 U6803.J12
CLKA1#: length 50.8
  TOP w0.114: U6803.J11 195.38,79.6 v1(195.75,79.97)
  IN1 w0.127: v1(170.03,83.21) 170.03,83.01 170.15,82.88 170.59,82.88 171.3,82.17 171.3,80.98 176.94,75.34 178.89,75.34 179.14,75.09 179.14,73.05 179.27,72.93 179.78,72.93 179.9,73.05 179.9,75.09 180.16,75.35 181.92,75.35 185,72.27 193.48,72.27 195.83,74.62 196.59,74.62 197.05,75.08 197.05,78.61 196.33,79.32 196.33,79.61 196.21,79.73 195.99,79.73 v1(195.75,79.97) 195.97,79.97 196.39,80.39 196.74,80.39 196.81,80.39 196.88,80.32 198.32,80.32 198.78,80.77 198.78,80.95 v1(199.55,81.72)
  BOTTOM w0.102: U6000.H9 v1(170.03,83.21)
  BOTTOM w0.114: R6815.2 199.86,81.58 199.68,81.58 v1(199.55,81.72) ; v1(195.75,79.97) 195.38,79.6 U6803.J11
CLKPCIE_GPU_N0: length 69.6
  IN1 w0.109: v1(150.75,99.85) 151.16,99.44 151.16,98.51 149.6,96.95 143.73,96.95 140.23,93.45 140.23,92.39 138.38,90.53 134.29,90.53 131.19,87.43 131.19,84.28 131.5,83.97 131.5,77.88 130.69,77.07 130.69,75.04 128.85,73.21 128.85,72.63 128.46,72.23 128.46,70.07 128.83,69.7 128.83,68.32 130,67.15 130,66.67 131.96,64.71 131.96,61.13 131.68,60.85 131.68,59.12 131.32,58.76 131.32,57.62 130.85,57.14 129.73,57.14 129.33,57.55 129.33,57.78 129.18,57.93 v3(129.14,57.98)
  BOTTOM w0.076: 129.04,57.53 129.04,57.52 129.03,57.51 129.03,57.51 128.92,57.39 127.82,57.39 127.73,57.49 127.46,57.61 127.15,57.61 127.06,57.57 126.89,57.57 126.77,57.62 126.51,57.62 126.44,57.58 126.42,57.58 126.19,57.47 125.87,57.47 125.58,57.18 U0400.D42
  BOTTOM w0.102: U6000.AK32 152.55,99.9 152.55,100 152.31,100.25 151.47,100.25 151.07,99.85 v1(150.75,99.85) ; v3(129.14,57.98) 129.26,57.85 129.26,57.74 129.04,57.53
CLKPCIE_GPU_P0: length 69.6
  IN1 w0.109: v1(130.02,57.97) 129.94,58.05 129.67,58.05 129.54,57.92 129.54,57.64 129.82,57.36 130.76,57.36 131.11,57.7 131.11,58.85 131.47,59.21 131.47,60.94 131.75,61.22 131.75,64.62 129.79,66.58 129.79,67.07 128.62,68.23 128.62,69.61 128.24,69.99 128.24,72.32 128.64,72.72 128.64,73.29 130.48,75.13 130.48,77.16 131.29,77.97 131.29,83.89 130.98,84.19 130.98,87.52 134.2,90.74 138.29,90.74 140.02,92.48 140.02,93.54 143.64,97.16 149.51,97.16 150.95,98.6 150.95,99.04 v1(150.75,99.24)
  BOTTOM w0.076: U0400.C42 126.09,57.22 126.46,57.41 126.56,57.45 126.74,57.45 126.86,57.4 127.1,57.4 127.1,57.41 127.19,57.45 127.42,57.45 127.63,57.35 127.76,57.23 129.03,57.23 129.18,57.38
  BOTTOM w0.102: 129.18,57.38 129.52,57.71 129.52,58.04 129.64,58.17 129.82,58.17 v1(130.02,57.97) ; U6000.AK30 152.45,99.2 152.45,99.71 152.35,99.81 152.35,99.92 152.22,100.05 151.55,100.05 v1(150.75,99.24)
CLKPCIE_LAN_N3: length 103.1
  IN3 w0.127: v1(130.74,54.72) 130.74,53.92 131.62,53.04 131.62,52.68 131.84,52.45 136.7,52.45 137.67,51.48 147.03,51.48 147.69,52.14 152.51,52.14 154.89,49.76 154.89,44.53 155.7,43.72 157.42,43.72 160.05,41.09 160.05,35.19 159.66,34.81 159.66,28.76 163.03,25.4 163.03,23.92 167.58,19.37 183.33,19.37 183.98,20.02 186.31,20.02 187.58,18.75 193.83,18.75 194.95,19.87 194.95,20.75 194.82,20.88 194.63,20.88 194.6,20.86 v5(194.59,20.86)
  BOTTOM w0.076: U0400.D41 125.67,55.98 125.7,55.95 125.7,55.93 125.87,55.76 126.21,55.76 126.21,55.76 126.29,55.68 126.36,55.68 126.52,55.6 126.53,55.6 126.76,55.6 126.87,55.65 127.08,55.65 127.12,55.62 127.18,55.59 127.6,55.59 127.76,55.42 127.76,55.39 127.77,55.38
  BOTTOM w0.102: CON5104.10 194.82,20.02 195,20.2 195,20.58 194.71,20.86 v5(194.59,20.86) ; v1(130.74,54.72) 130.56,54.54 130.56,54.33 130.33,54.11 129.05,54.11 127.77,55.38
CLKPCIE_LAN_P3: length 103.2
  IN3 w0.127: v1(130.13,54.72) 130.51,54.35 130.51,53.83 131.39,52.94 131.39,52.58 131.75,52.22 136.6,52.22 137.58,51.25 147.12,51.25 147.78,51.91 152.42,51.91 154.66,49.66 154.66,44.43 155.61,43.49 157.32,43.49 159.82,40.99 159.82,35.28 159.44,34.9 159.44,28.67 162.8,25.3 162.8,23.83 167.49,19.14 183.43,19.14 184.07,19.79 186.21,19.79 187.48,18.52 193.92,18.52 195.17,19.77 195.17,20.59 195.17,20.67 195.33,20.82 v1(195.33,20.93)
  BOTTOM w0.076: U0400.C41 126.19,56.74 126.09,56.74 126.01,56.67 126.01,56.47 126.29,56.19 126.29,55.98 126.43,55.84 126.57,55.76 126.72,55.76 126.84,55.81 127.13,55.81 127.23,55.76 127.67,55.76 127.9,55.53 127.91,55.53
  BOTTOM w0.102: CON5104.11 195.32,19.97 195.2,20.09 195.2,20.81 v1(195.33,20.93) ; 127.91,55.53 129.13,54.31 130.25,54.31 130.35,54.42 130.35,54.5 v1(130.13,54.72)
CLKPCIE_SSD_N4: length 144.5
  IN3 w0.127: v1(129.36,55.38) 129.09,55.11 129.09,54.45 130.94,52.61 130.94,52.42 132.66,50.7 136.28,50.7 138.09,48.9 138.09,45.18 139.26,44.01 148.79,44.01 149.79,45.01 153.16,45.01 155.31,42.85 157.35,42.85 159.39,40.81 159.39,39.42 158.95,38.99 158.95,28.5 161.47,25.99 161.47,24.52 168.12,17.87 173.8,17.87 174.49,17.19 179.39,17.19 179.75,16.83 194.98,16.83 201.09,22.94 201.98,22.94 202.39,23.35 202.39,23.88 202.97,24.46 205.51,24.46 206.1,25.05 214.53,25.05 219.89,19.69 219.89,12.73 217.31,10.15 217.31,8.04 217.63,7.72 217.75,7.72 217.75,7.72 217.98,7.72 v1(218.08,7.83)
  BOTTOM w0.102: v1(218.08,7.83) 218.08,7.77 217.96,7.65 217.04,7.65 216.84,7.85 CON3100.53 ; U0400.B40 126.86,56.05 127.14,56.34 128.66,56.34 129.19,55.81 129.19,55.55 v1(129.36,55.38)
CLKPCIE_SSD_P4: length 144.4
  IN3 w0.127: v3(128.74,55.43) 128.86,55.31 128.86,54.36 130.71,52.51 130.71,52.33 132.56,50.47 136.19,50.47 137.86,48.81 137.86,45.08 139.16,43.78 148.88,43.78 149.89,44.78 153.06,44.78 155.22,42.62 157.25,42.62 159.16,40.72 159.16,39.52 158.73,39.09 158.73,28.41 161.24,25.89 161.24,24.43 168.02,17.65 173.7,17.65 174.39,16.96 179.3,16.96 179.65,16.6 195.08,16.6 201.18,22.71 202.07,22.71 202.62,23.25 202.62,23.78 203.07,24.23 205.61,24.23 206.19,24.82 214.43,24.82 219.66,19.59 219.66,12.82 217.08,10.24 217.08,7.95 217.53,7.5 217.53,7.49 217.65,7.37 217.65,7.11 217.8,6.96 217.98,6.96 v5(218.08,7.06)
  BOTTOM w0.102: v3(128.74,55.43) 128.86,55.43 128.98,55.55 128.98,55.73 128.58,56.14 127.38,56.14 U0400.A40 ; CON3100.55 216.9,7.35 216.99,7.44 217.53,7.44 217.65,7.32 217.65,7.13 217.78,7 218.02,7 v5(218.08,7.06)
CLKPCIE_WLAN_N1: length 115.9
  IN3 w0.127: v1(205.11,26.24) 204.78,26.57 204.31,26.57 203.85,26.11 200.74,26.11 198.35,23.73 194.54,23.73 193.73,22.91 193.73,19.79 193.14,19.2 189.94,19.2 188.53,20.61 183.83,20.61 183.02,19.8 167.76,19.8 164.29,23.28 164.29,24.75 160.12,28.91 160.12,34.62 160.48,34.97 160.48,41.27 157.6,44.15 156.12,44.15 155.35,44.92 155.35,49.92 152.7,52.57 146.82,52.57 146.16,51.91 138.68,51.91 136.93,53.65 136.93,55.74 136.13,56.54 132.7,56.54 132.13,55.98 132.13,55.58 131.74,55.18 130.68,55.18 v1(130.21,55.66)
  BOTTOM w0.102: v1(205.11,26.24) 205.22,26.35 205.5,26.35 205.6,26.26 CON5103.7 ; U0400.B42 126.75,57.07 126.75,56.87 126.96,56.65 129.73,56.65 130.21,56.17 v1(130.21,55.66)
CLKPCIE_WLAN_P1: length 116.2
  IN3 w0.127: v1(205.13,26.85) 205.08,26.8 204.22,26.8 203.76,26.34 200.64,26.34 198.25,23.95 194.44,23.95 193.5,23.01 193.5,19.88 193.05,19.43 190.04,19.43 188.63,20.84 183.74,20.84 182.93,20.03 167.86,20.03 164.52,23.37 164.52,24.84 160.35,29.01 160.35,34.52 160.71,34.88 160.71,41.36 157.69,44.38 156.21,44.38 155.58,45.01 155.58,50.01 152.79,52.8 146.72,52.8 146.06,52.14 138.77,52.14 137.16,53.75 137.16,55.83 136.22,56.77 132.6,56.77 131.9,56.07 131.9,55.67 131.64,55.41 130.95,55.41 130.82,55.54 v1(130.82,55.66)
  BOTTOM w0.102: U0400.A42 127.04,57.18 126.96,57.09 126.96,56.95 127.05,56.86 129.81,56.86 130.16,56.5 ; 130.16,56.5 v2(130.33,56.67) ; 130.16,56.5 130.56,56.11 130.84,56.11 130.98,55.96 130.98,55.82 v1(130.82,55.66) ; CON5103.8 205.6,26.76 205.49,26.65 205.26,26.65 205.13,26.78 v1(205.13,26.85)
CMP_VIN0: length 148.3
  TOP w0.102: v1(86.61,27.54) 86.21,27.94 84.25,27.94 79.96,23.65 79.96,21.9 80.78,21.08 80.78,20.3 80.65,20.17 80.65,18.27 80.29,17.91 80.29,16.23 79.71,15.64 79.71,14.2 80.34,13.57 80.34,12.8 79.81,12.27 75.46,12.27 74.13,10.95 74.13,10.14 73.81,9.82 73.81,6.67 72.18,5.03 61.71,5.03 60.88,5.85 60.88,11.79 59.53,13.15 57.8,13.15 v2(57.16,13.79) 56.76,14.19 56.76,18.1 50.32,24.54 50.32,39.35 50.52,39.55 50.52,40.67 50.32,40.87 50.32,43.21 48.59,44.94 48.59,45.96 v1(48.1,46.45) ; C3707.1 TR3700.1 105.33,45.34 104.22,44.22 97.89,44.22 96.85,45.27 v1(95.12,45.27) 95.12,45.34 94.26,46.21 R3709.2 ; U2300.20 33.3,42.73 v1(33.71,42.32)
  BOTTOM w0.102: v1(86.61,27.54) 84.46,29.7 84.46,33.99 95.12,44.66 v1(95.12,45.27) ; v1(48.1,46.45) 46.3,46.45 44.5,44.66 42.32,44.66 41.13,43.46 35.56,43.46 34.42,42.32 v1(33.71,42.32)
CMP_VOUT0: length 4.9
  TOP w0.102: v2(38.16,24.96) 37.74,25.38 R2333.2 36.78,25.38 36.75,25.4 R2400.1 36.37,26.37 36.5,26.49 U2300.85
COMP_A_VCPU: length 3.5
  BOTTOM w0.229: PR7813.1 PC7814.1 178.92,48.62 v2(178.84,48.54) 178.66,48.54 178.49,48.72 178.03,48.72 177.9,48.85 PU7800.16
COMP_A_VCPU_R: length 0.9
  BOTTOM w0.229: PC7816.2 PR7813.2
COMP_B_VCPU: length 6.1
  BOTTOM w0.229: PU7800.4 174.3,51.72 173.53,52.49 173.53,52.61 PC7812.2 172.4,53.74 v2(172.4,54.03) 172.4,55.03 172.62,55.25 PR7854.2
  BOTTOM w0.254: PR7812.2 PR7854.2
COMP_B_VCPU_R: length 3.9
  BOTTOM w0.102: PC7815.1 173.9,57.19 173.38,57.71 172.44,57.71 v2(172.21,57.48)
  BOTTOM w0.254: PR7854.1 PR7812.1 PC7815.1
COMP_C_VCPU: length 5.8
  TOP w0.102: v2(174.78,45.77) 174.78,45.47 175.31,44.94 v1(176.61,44.94)
  TOP w0.229: PR7842.2 176.3,44.63 v1(176.61,44.94)
  BOTTOM w0.229: PU7800.24 175.5,46.22 175.95,45.78 PC7831.1 176.5,45.04 v1(176.61,44.94)
COMP_C_VCPU_R: length 1.9
  TOP w0.229: PC7832.1 176.89,42.55 176.71,42.37 v2(176.4,42.37) 176.4,42.8 176.3,42.9 PR7842.1
CPU_DP1_CTRL_CLK: length 166.8
  TOP w0.102: Q2900.1 25.99,63.74 R2900.2 25.58,62.44 v2(25.83,62.18) 27.1,62.18 27.58,62.66 28.27,62.66 28.89,62.04 28.89,61.43 29.39,60.94 30.05,60.94 30.28,60.71 30.28,59.79 29.72,59.24 29.72,58.66 30.53,57.85 30.53,55.78 v1(30.44,55.69)
  IN3 w0.102: 120.87,31.45 120.87,34.3 120.27,34.89 120.27,39.05 v3(120.88,39.66)
  IN3 w0.127: v1(30.44,55.69) 30.44,54.57 30.52,54.5 30.52,48 30.63,47.89 30.63,40.95 31.78,39.8 31.78,35.7 33.24,34.24 33.24,32.6 35.12,30.73 35.12,29.33 39.35,25.1 41.47,25.1 44.58,21.99 45.81,21.99 48.09,19.7 49.82,19.7 51.7,17.82 51.7,14.46 53.46,12.7 58.11,12.7 58.75,13.34 64.08,13.34 64.45,12.97 69.37,12.97 69.85,12.49 72.37,12.49 73.34,13.46 73.34,14.6 76.45,17.71 76.45,18.12 78.13,19.79 78.74,19.79 79.12,19.41 79.12,18.35 81.52,15.95 87.66,15.95 89.39,14.23 91.53,14.23 91.91,14.61 93.47,14.61 94.23,15.37 94.23,15.95 94.92,16.63 105.11,16.63 106.67,18.2 108.76,18.2 109,17.96 114.63,17.96 115.63,18.96 117.53,18.96 118.08,19.52 118.08,21.54 118.29,21.74 118.4,21.86 118.4,22.35 120.5,24.44 120.5,27.98 120.87,28.35 120.87,31.45
  BOTTOM w0.102: v3(120.88,39.66) 121,39.66 U0400.L13
CPU_DP1_CTRL_DATA: length 166.2
  TOP w0.102: Q2900.4 27.29,66.08 27.94,65.43 R2901.2 28.55,65.15 28.37,64.98 28.22,64.98 28.09,64.85 28.09,64.24 28.97,63.36 v2(28.97,63.2) 28.97,62.93 v1(29.47,62.44)
  IN3 w0.102: v3(120.88,39.1) 120.5,38.72 120.5,34.95 121.12,34.33
  IN3 w0.127: 121.12,34.33 121.12,28.24 120.75,27.87 120.75,24.34 118.66,22.25 118.66,21.75 118.34,21.43 118.34,19.42 117.63,18.71 115.74,18.71 114.73,17.7 108.84,17.7 108.6,17.94 106.78,17.94 105.21,16.38 95.03,16.38 94.49,15.84 94.49,15.27 93.57,14.35 92.01,14.35 91.63,13.97 87.66,13.97 87.48,14.15 87.48,15.17 86.94,15.7 81.41,15.7 78.76,18.35 77.52,18.35 77.14,17.98 77.14,17.06 76.35,16.27 75.37,16.27 73.6,14.5 73.6,13.35 72.47,12.22 69.72,12.22 69.23,12.72 64.33,12.72 63.98,13.06 58.85,13.06 58.24,12.45 53.35,12.45 51.45,14.35 51.45,17.71 49.72,19.45 47.99,19.45 45.7,21.73 44.47,21.73 41.36,24.84 39.24,24.84 34.85,29.24 34.85,30.63 32.98,32.5 32.98,34.13 31.5,35.62 31.5,39.65 30.38,40.77 30.38,47.78 30.26,47.9 30.26,54.39 30.02,54.63 30.02,56.19 31.04,57.2 31.04,59.72 30.02,60.73 30.02,61.88 v1(29.47,62.44)
  BOTTOM w0.089: U0400.L12 121.09,39.1 v3(120.88,39.1)
CPU_DP1_HPD: length 10.1
  TOP w0.102: v3(120.88,37.05) 120.88,37.04 121.26,36.66 121.26,35.93 123.93,33.26 125.65,31.53 v2(125.65,31.27) 125.65,30.62 126.12,30.15 R0408.1
  BOTTOM w0.076: U0400.L9 120.99,37.05 v3(120.88,37.05)
CPU_DP2_HPD: length 30.6
  TOP w0.102: v1(122.12,21.64) 122.53,22.05 123.2,22.05 123.25,22 124.45,22 126.57,24.12 v2(126.57,24.62) 126.57,25.48 R0411.2 127.1,25.5 127.53,25.94 127.53,27.54 127.28,27.79 126.95,27.79 126.57,28.17 125.94,28.17 125.64,28.47 125.64,30.35 125.22,30.77 125.22,31.53 121.02,35.74 v3(120.88,35.74)
  BOTTOM w0.089: U0400.L7 121.23,36.08 v3(120.88,35.74)
  BOTTOM w0.102: Q5801.2 R5825.2 119.13,19.26 119.41,19.54 120.5,19.54 121.69,20.73 121.69,21.51 121.82,21.64 v1(122.12,21.64)
CPU_THERM#: length 5.8
  BOTTOM w0.254: U3700.4 129.18,91.19 129.41,91.42 129.41,92.2 v2(129.72,92.51) 130.25,93.04 130.25,93.88 D3700.2 129.92,93.88 129.46,94.34 R3708.2
CPUFAN_TACH_R: length 23.7
  TOP w0.102: v2(206.6,81.18) 206.35,81.43 v1(206.35,81.89)
  IN1 w0.102: v1(206.35,81.89) 206.73,81.51 v1(206.73,73.38)
  BOTTOM w0.102: v1(206.73,73.38) 207.18,72.94 207.18,72.05 204.62,69.5 D3600.2 204.62,67.47 205.08,67.01 C3602.1 ; CON3600.3 207.33,82.87 v1(206.35,81.89)
CSA0_0#: length 42.9
  TOP w0.127: v1(170.15,93.5) 170.41,93.76 170.41,94.54 170.43,94.57 170.43,95.5 170.56,95.63 172.42,95.63 174.6,97.81 175.83,97.81 176.31,97.32 179.41,97.32 179.55,97.46 179.55,99.85 179.43,99.98 178.56,99.98 178.41,100.13 178.41,100.46 178.56,100.61 180.09,100.61 180.22,100.48 180.22,97.41 180.35,97.28 180.6,97.28 180.73,97.41 180.73,100.57 180.85,100.69 181.11,100.69 181.23,100.56 181.23,97.41 181.36,97.28 181.62,97.28 181.74,97.41 181.74,100.16 182.76,101.18 184.5,101.18 v2(184.94,100.74) 184.94,100.28 185.28,99.94 186.01,99.94 186.28,99.76 186.34,99.73 186.39,99.72 188.19,99.72 188.26,99.8 188.57,100.11 v1(188.57,100.55) 188.57,100.57 U6801.L12
  BOTTOM w0.102: v1(170.15,93.5) 170.11,93.5 U6000.H22
  BOTTOM w0.127: v1(188.57,100.55) 188.57,100.57 U6801.L12
CSA0_1#: length 1.4
  TOP w0.127: T6302.1 169.35,93.48 v1(169.35,93.5)
  BOTTOM w0.127: v1(169.35,93.5) 169.31,93.5 U6000.J22
CSA1_0#: length 50.1
  TOP w0.127: U6803.G12 196.16,81.2 v1(195.77,81.59) 194.1,81.59 193.12,82.57 193.12,83.61 192.99,83.73 192.8,83.73 192.67,83.86 192.67,84.11 192.8,84.24 192.99,84.24 193.12,84.37 193.12,86.18 190.93,88.37 181.76,88.37 v2(181.36,88.77) 181.08,89.05 180.85,89.05 180.72,88.93 180.72,88.66 180.54,88.48 179.41,88.48 179.07,88.83 178.33,88.83 178.21,88.95 178.21,90.02 178.05,90.17 177.83,90.17 177.7,90.05 177.7,88.95 177.57,88.83 177.32,88.83 177.19,88.95 177.19,89.6 177.06,89.73 176.81,89.73 176.68,89.6 176.68,88.95 176.56,88.83 176.23,88.83 176.1,88.95 176.1,89.35 175.97,89.47 174.04,89.47 173.91,89.6 173.91,90.45 173.75,90.62 173.53,90.62 173.41,90.49 173.41,90.02 173.28,89.89 173.08,89.89 172.85,90.12 172.85,90.38 172.72,90.5 172.47,90.5 172.22,90.74 170.14,90.74 169.62,90.22 169.62,89.81 169.36,89.55 168.26,89.55 167.67,88.95 167.67,87.1 167.89,86.87 170.44,86.87 170.69,86.61 170.69,85.25 v1(170.69,85.24)
  BOTTOM w0.127: U6000.G13 170.69,85.56 v1(170.69,85.24) ; v1(195.77,81.59) 195.78,81.59 U6803.G12
CSA1_1#: length 1.7
  TOP w0.127: v1(168.4,85.09) 167.95,85.55 T6303.1
  BOTTOM w0.127: v1(168.4,85.09) 168.4,85.45 U6000.K13
CSI2_COMP: length 8
  IN2 w0.305: v1(130.15,38.94) 128.52,38.94 128.12,39.35 124.93,39.35 v3(124.82,39.46)
  BOTTOM w0.254: U0400.E13 124.82,39.69 v3(124.82,39.46)
  BOTTOM w0.432: v1(130.15,38.94) 130.15,39.19 v2(130.47,39.51) 130.94,39.98 R1300.2
CSIN_R: length 7.2
  BOTTOM w0.102: PJP7700.2 185.78,30.03 185.7,29.95 184.33,29.95 183.92,29.54 183.92,28.3 v2(184.07,28.15)
  BOTTOM w0.203: PR7704.1 188.54,29.59 188.11,30.03 PJP7700.2
CSIP_R: length 6.1
  BOTTOM w0.102: PJP7701.2 185.8,30.38 185.57,30.15 184.23,30.15 183.52,30.86 v2(183.52,31.27)
  BOTTOM w0.203: PR7703.1 188.34,30.43 188.29,30.38 PJP7701.2
CSON_R:
  vias: v2(150.6,25.76)
CTAL_1: length 4.7
  TOP w0.102: R1008.1 92.13,42.67 92,42.55 92,41.56 91.36,40.92 X1001.2 90.91,40.21 90.42,39.73 v2(90.17,39.73)
DAT_TP_SIO: length 28
  TOP w0.102: U2300.79 34.1,27.37 34.19,27.28 34.19,25.54 35.13,24.6 v1(35.13,24.51) R2337.2
  IN1 w0.097: v1(40.26,14.84) 40.26,15.37 39.78,15.85 38.38,15.85 35.81,18.42 35.81,22.19 35.13,22.87 v1(35.13,24.51)
  BOTTOM w0.102: v1(40.26,14.84) v2(40.26,12.7) 40.26,9.1 42.37,6.99 43.41,6.99 43.6,6.79 Q5104.6
DAT_TP_SIO_C: length 27.9
  TOP w0.102: v1(54.38,11.71) v2(55.12,11.71) 55.78,11.05 55.78,10.89 55.79,10.89 D5102.1 56.54,9.45 56.59,9.4 C5129.1 R5105.2
  IN1 w0.097: v1(54.38,11.71) 53.78,12.31 51.03,12.31 50.23,11.5 45.06,11.5 v1(43.56,10)
  BOTTOM w0.102: Q5104.1 43.6,5.38 44.03,5.8 44.03,7.1 44.35,7.42 44.35,8.94 43.56,9.73 v1(43.56,10) ; CON5100.2 56.73,11 56.02,11.71 v1(54.38,11.71)
DBC_PANEL_EN: length 133.2
  IN2 w0.102: v1(83.46,24.84) 83.61,25 85.45,25 85.68,25.22 86.03,25.22 89.51,28.7 92.47,28.7 92.5,28.73 92.53,28.73 94.6,30.8 102.81,30.8 103.63,31.63 103.63,32.69 104.78,33.85 109.46,33.85 110.7,35.09 v3(110.7,35.83)
  IN3 w0.102: v1(110.2,25.95) 110.2,26.76 110.2,26.76 110.2,33.02 110.85,33.67 110.85,35.69 v3(110.7,35.83)
  BOTTOM w0.102: T1501.1 110.34,26.1 v1(110.2,25.95) ; v3(110.7,35.83) 110.7,35.7 U0400.AM5 ; CON3000.16 63.58,100.26 63.71,100.13 64.01,100.13 64.61,99.54 64.61,97.67 64.57,97.63 64.57,97.08 64.21,96.73 64.21,96.35 65.3,95.27 70.02,95.27 72.54,92.75 72.54,88.52 74.68,86.39 v2(74.68,69.27) 74.68,33.21 80.85,27.04 80.85,25.82 82.25,24.41 83.03,24.41 v1(83.46,24.84)
DC_IN_ID_ADAP_Q: length 72.8
  TOP w0.102: PL7605.2 46.3,96.1 46.3,96.09 PD7602.2 v1(47.52,95.54) v2(47.52,94.91)
  IN3 w0.102: v1(39.8,87.51) 40.89,88.6 40.89,90.93 45.51,95.54 v1(47.52,95.54)
  BOTTOM w0.102: v2(14.61,58.5) 14.91,58.19 PR7608.1 16.64,59.06 18.44,59.06 18.64,58.85 20.12,58.85 20.57,58.4 PC7608.1 21.07,57.69 21.2,57.56 PQ7601.3 21.2,56.02 21.41,55.81 22.14,55.81 23.17,56.83 23.17,57.58 27.43,61.85 27.43,62.43 28.78,63.77 28.78,67.82 30.4,69.45 33.83,69.45 35.84,71.45 39.52,71.45 39.78,71.71 40.74,71.71 41.99,72.95 41.99,77.4 43.51,78.92 43.51,80.35 40.18,83.69 40.18,87.13 v1(39.8,87.51)
DC_IN_ID_ADAP_R: length 2.9
  BOTTOM w0.102: PQ7601.4 21.2,53.89 21.79,53.29 v2(21.79,52.76) 21.79,52.35 21.54,52.1 PR7607.1
DC_IN_OK: length 31.8
  TOP w0.102: PR7614.1 37.74,85.68 37.24,85.17 PR7613.2 36.78,85.91 36.82,85.95 PU7600.6 36.82,86.96 37.04,87.18 38.91,87.18 v2(40.39,85.7) 41.93,85.7 43.26,87.03 43.26,89.84 37.11,95.99 32.03,95.99 30.91,97.11 30.91,98.58 31.17,98.83 PR7644.1
DCI_CLK: length 2.7
  TOP w0.102: U5703.32 22.57,83.7 T5700.1
DCI_DATA: length 3.9
  TOP w0.102: U5703.29 23.36,84.9 22.63,85.63 21.44,85.63 T5701.1
DCIN_R:
  vias: v2(185.24,22.46)
DCPDSW_1P0: length 1.7
  TOP w0.432: v3(111.27,32.29) 111,32.29 C1611.2
  BOTTOM w0.203: U0400.AL1 111.28,32.94 111.28,32.3 v3(111.27,32.29)
DCPRTC: length 10.3
  BOTTOM w0.076: U0400.BB10 104.62,37.9 104.54,37.9 104.22,37.57 104.22,36.98 103.56,36.32 103.56,35.84 102.77,35.06
  BOTTOM w0.102: C1617.1 100.17,31.32 100.17,33.17 100.58,33.58 v2(101.65,33.58) 101.96,33.89 101.96,34.24 102.77,35.06
DDBIA0_0: length 31.6
  TOP w0.127: v1(170.05,97.64) 170.05,98.2 v2(169.98,98.28) ; v1(188.55,102.96) 188.53,102.96 U6801.P13
  IN3 w0.122: v1(188.55,102.96) 188.14,102.55 185.9,102.55 185.62,102.84 185.62,103.11 183.86,104.87 182.4,104.87 181.56,104.03 177.59,104.03 175.48,106.15 170.74,106.15 169.98,105.39 169.98,102.31 169.57,101.91 169.57,100.16 169.21,99.8 169.21,98.48 v1(170.05,97.64)
  BOTTOM w0.127: v1(170.05,97.64) U6000.H27
DDBIA0_1: length 26.7
  IN1 w0.122: v1(175.82,98.44) 176.16,98.44 176.56,98.84 176.56,99.18 177.91,100.54 179.3,100.54 180.36,101.6 183.73,101.6 184.6,102.46 190.68,102.46 191.13,102.02 192.09,102.02 192.88,102.81 193.46,102.81 193.78,102.49 194.38,102.49 194.47,102.58 196.18,102.58 v1(196.57,102.97)
  BOTTOM w0.102: v1(175.82,98.44) 175.42,98.04 175.13,98.04 174.61,97.52 174.18,97.52 173.89,97.22 U6000.A27
  BOTTOM w0.127: U6800.D2 v1(196.57,102.97)
DDBIA0_2: length 27.7
  IN3 w0.122: v1(187.76,94.14) 187.74,94.17 185.64,94.17 183.8,96 182.02,96 182,96.01 182,96.01 181.59,96.42 177.91,96.42 176.28,98.05 176.28,98.23 176.92,98.87 176.92,99.05 176.41,99.55 175.01,99.55 174.75,99.29 174.76,99.29 174.76,98.74 174.64,98.62 174.64,98.27 174.15,97.78 174.15,97.32 174.37,97.1 174.79,97.1 175.03,96.85 175.03,96.51 174.96,96.43 174.96,96.12 v1(175.64,95.43)
  BOTTOM w0.102: v1(175.64,95.43) 175.64,95.28 175.67,95.26 175.67,94.57 175.11,94.01 174.21,94.01 173.92,93.73 173.86,93.69 173.55,93.69 U6000.C23
  BOTTOM w0.127: U6800.P13 187.76,94.19 v1(187.76,94.14) ; v2(176.68,95.4) 176.66,95.43 v1(175.64,95.43)
DDBIA0_3: length 31.8
  TOP w0.127: U6801.D2 v1(196.58,94.2)
  IN3 w0.122: v1(196.58,94.2) 196.16,93.78 195.94,93.78 195.55,93.4 195.55,93.38 195.16,92.99 194.81,92.99 194.57,92.74 194.57,92.4 195.03,91.94 195.03,90.07 195.21,89.89 195.21,89.54 193.52,87.85 180,87.85 178.51,89.34 177.19,89.34 176.35,90.17 v1(176.35,90.27)
  BOTTOM w0.102: v1(176.35,90.27) 176.16,90.47 175.45,90.47 175.36,90.56 174.23,90.56 174.04,90.49 173.55,90.49 173.53,90.49 U6000.C19
  BOTTOM w0.127: v1(176.35,90.27) v2(176.35,89.46)
DDBIA1_0: length 23.2
  TOP w0.127: U6803.D2 187.78,83.98 v1(187.78,84.79)
  IN1 w0.122: v1(187.78,84.79) 187.2,84.79 187.02,84.97 185.7,84.97 185.5,85.16 184.99,85.16 184.78,85.37 184.78,86.36 184.65,86.49 184.42,86.49 184.29,86.36 184.29,85.31 184.15,85.16 183.12,85.16 182.84,85.44 182.84,85.65 182.72,85.78 182.29,85.78 182.17,85.9 182.17,86.44 182.05,86.57 181.8,86.57 181.68,86.44 181.68,85.9 181.56,85.78 181.32,85.78 181.19,85.9 181.19,86.44 181.07,86.57 180.83,86.57 180.71,86.44 180.71,85.9 180.58,85.78 180.34,85.78 180.21,85.91 180.21,86.01 180.09,86.13 179.86,86.13 179.73,86.01 179.73,85.91 179.6,85.78 179.17,85.78 178.92,86.03 178.59,86.03 178.33,85.78 177.87,85.78 177.49,86.15 175.67,86.15 v1(174.98,86.84)
  BOTTOM w0.102: U6000.C15 173.23,87.17 173.48,87.08 174.02,87.08 174.17,87.23 174.59,87.23 v1(174.98,86.84)
DDBIA1_1: length 33.8
  IN1 w0.122: v1(197.35,83.99) 195.67,83.99 194.05,82.37 194.03,82.37 193.14,81.49 193.14,78.97 192.45,78.28 192.45,78.15 191.37,77.07 188.06,77.07 187.66,77.47 184.6,77.47 184.02,78.05 182.41,78.05 181.96,78.5 181.02,78.5 179.52,80 179.04,80 178.87,80.18 v1(178.87,80.39)
  BOTTOM w0.102: U6000.E9 172.2,83.14 172.64,83.35 172.94,83.35 173.09,83.29 173.37,83.29 173.42,83.31 173.51,83.35 173.53,83.35 173.88,83.35 173.98,83.33 174.17,83.14 176.16,83.14 176.42,82.88
  BOTTOM w0.127: 176.42,82.88 177.49,81.82 178.33,81.82 178.87,81.28 v2(178.87,81.03) v1(178.87,80.39) ; v1(197.35,83.99) 196.97,83.61 U6802.P13
DDBIA1_2: length 21.3
  BOTTOM w0.102: U6000.C5 173.26,79.19 173.87,79.19 174.06,79 174.84,79 174.86,78.98
  BOTTOM w0.127: U6802.D2 188.17,75.34 187.79,74.97 187.79,74.74 187.43,74.38 186.49,74.38 186.25,74.63 186.25,74.88 185.88,75.25 183.15,75.25 v2(182.88,75.52) 182.49,75.91 182.49,76.75 181.92,77.32 181.41,77.32 181.28,77.19 181.28,76.76 181.15,76.63 180.88,76.63 180.76,76.76 180.76,77.22 180.63,77.35 180.37,77.35 180.25,77.22 180.25,76.76 180.12,76.63 178.38,76.63 178.21,76.81 178.21,77.4 178.07,77.54 176.17,77.54 175.35,78.35 175.35,78.53 174.89,78.98 174.86,78.98
DDBIA1_3: length 33.6
  TOP w0.127: U6803.P13 196.58,75.21 v1(196.55,75.21)
  IN3 w0.122: v1(169.75,76.48) 170.03,76.48 171.11,75.39 171.11,75 171.32,74.8 171.32,74.79 171.4,74.7 171.4,73.94 171.59,73.76 172.79,73.76 173.05,74.02 176.3,74.02 176.56,73.76 178.71,73.76 179.31,74.36 183.07,74.36 183.65,73.78 187.09,73.78 187.34,74.04 192.83,74.04 193.45,74.65 194.28,74.65 194.47,74.84 195.14,74.84 195.23,74.75 196.08,74.75 v1(196.55,75.21)
  BOTTOM w0.102: v1(169.75,76.48) 169.34,76.89 169.34,77.31 169.36,77.34 169.36,78.14 169.3,78.28 169.3,78.49 169.32,78.58 169.63,78.88 U6000.H4
DDPC_AUXN: length 143.1
  TOP w0.102: 40.48,87.9 39.32,89.05 39.32,89.77 37.31,91.77 31.83,91.77 30.81,90.76 25.15,90.76 24.83,91.07 22.65,91.07 22.4,90.83 22.4,90.73 C5718.1 ; 40.48,87.9 41.15,87.22 v1(42.4,87.22) ; 40.48,87.9 v2(40.64,88.06)
  IN1 w0.109: v1(42.4,87.22) 43.17,87.22 43.3,87.35 43.3,88.99 44.43,90.12 46.69,90.12 52.51,95.94 56.71,95.94 59.56,98.79 60.27,98.79 60.68,99.19 61.67,99.19 63,100.52 78.12,100.52 83.88,94.76 93.82,94.76 95.15,93.42 97.31,93.42 98.97,91.76 103.24,91.76 105.25,89.75 105.99,89.75 111.65,84.08 112.23,84.08 114.59,81.72 123.58,81.72 124.74,80.57 124.74,76.31 124.61,76.18 124.61,68.55 123.21,67.16 123.21,61.83 124.03,61.01 124.41,61.01 v3(124.85,60.57)
  BOTTOM w0.102: U0400.E48 124.57,60.3 v3(124.85,60.57)
DDPC_AUXP: length 143.1
  TOP w0.102: 36.25,91.57 37.23,91.57 39.12,89.68 39.12,88.97 41.07,87.02 41.86,87.02 v1(42.25,86.63) ; 36.25,91.57 31.91,91.57 30.89,90.55 25.06,90.55 24.75,90.87 22.73,90.87 22.61,90.74 22.61,90.66 C5717.1 ; 36.25,91.57 v2(36.25,91.34)
  IN1 w0.109: v3(124.29,60.57) 124.06,60.8 123.94,60.8 123,61.74 123,67.24 124.4,68.64 124.4,76.27 124.53,76.4 124.53,80.48 123.5,81.51 114.5,81.51 112.14,83.87 111.56,83.87 105.9,89.54 105.16,89.54 103.15,91.55 98.89,91.55 97.22,93.21 95.07,93.21 93.73,94.55 83.79,94.55 78.03,100.31 63.09,100.31 61.76,98.98 60.76,98.98 60.36,98.57 59.64,98.57 56.8,95.73 52.6,95.73 46.78,89.91 44.52,89.91 43.51,88.9 43.51,87.26 43.26,87.01 42.98,87.01 42.85,86.88 42.85,86.34 42.77,86.26 42.62,86.26 v1(42.25,86.63)
  BOTTOM w0.102: v3(124.29,60.57) 124.29,60.42 U0400.F48
DDR0_A_ALERT_N: length 61.6
  TOP w0.165: v3(106.36,60.58) 105.38,60.58 v2(105.16,60.35)
  IN1 w0.152: v3(106.36,60.58) 106.77,60.99 108.22,60.99 109.17,61.93 109.17,62.86 108.45,63.59 108.45,64.3 108.13,64.62 107.29,64.62 106.84,64.17 105.87,64.17 104.8,63.1 101.66,63.1 101.66,63.1 100.53,63.1 100.33,63.3 97.1,63.3 96.51,63.88 76.23,63.88 71.84,59.49 64.69,59.49 62.89,61.29 62.89,61.78 63.27,62.16 63.4,62.16 v1(64.11,62.87)
  BOTTOM w0.102: v3(106.36,60.58) 106.36,60.75 U0400.AW50
  BOTTOM w0.165: CON2000.116 63.51,63.57 64.11,62.98 v1(64.11,62.87)
DDR0_A_PARITY: length 53.4
  TOP w0.165: v3(108.74,62.36) 108.74,63.45 v2(108.81,63.53)
  IN1 w0.152: v1(66.12,56.06) 67.34,54.84 73.79,54.84 78.47,59.52 90.38,59.52 90.59,59.31 99.59,59.31 99.8,59.51 99.8,59.64 100.18,60.02 101.35,60.02 101.8,60.48 104.29,60.48 106.16,62.35 107.61,62.35 107.97,62.71 108.39,62.71 v3(108.74,62.36)
  BOTTOM w0.165: v3(108.74,62.36) 108.74,62.19 108.54,61.99 U0400.AT52 ; CON2000.143 69.19,56.82 68,55.63 66.55,55.63 v1(66.12,56.06)
DDR1_B_ALERT_N: length 79
  TOP w0.165: v2(53.34,68.2) 52.58,67.44 v1(52.58,67.12)
  IN3 w0.152: v3(110.15,57.76) 110.57,58.19 110.76,58.19 111.07,58.5 111.07,61.96 111.27,62.16 111.27,65.26 110.94,65.59 110.33,65.59 110.18,65.74 109.63,65.74 109.09,65.21 107.09,65.21 104.88,67.41 104.88,67.82 103.95,68.75 101.46,68.75 101.12,68.4 98.7,68.4 96.8,70.31 83.85,70.31 83.01,69.48 70.1,69.48 69.9,69.28 62.54,69.28 61.54,70.28 55.22,70.28 52.58,67.64 v1(52.58,67.12)
  BOTTOM w0.076: U0400.AN43 110.38,57.52 v3(110.15,57.76)
  BOTTOM w0.165: v1(52.58,67.12) 52.58,66.3 50.86,64.57 CON2100.116
DDR1_B_PARITY: length 69.3
  TOP w0.165: v1(54.28,55.68) 55.09,55.68 v2(55.35,55.43)
  IN3 w0.076: 108.43,57.38 109.08,57.38 v3(109.43,57.73)
  IN3 w0.152: v1(54.28,55.68) 54.77,55.19 63.36,55.19 63.81,54.74 75.04,54.74 75.24,54.93 75.24,55.35 75.44,55.55 75.83,55.55 76.03,55.35 76.03,54.93 76.23,54.74 77.59,54.74 81.31,58.45 97.82,58.45 98.37,57.9 102.86,57.9 103.2,57.56 105.61,57.56 105.89,57.28 108.33,57.28 108.43,57.38
  BOTTOM w0.076: U0400.AP43 109.43,57.61 v3(109.43,57.73)
  BOTTOM w0.165: CON2100.143 56.43,57.82 56.11,57.51 54.96,57.51 54.83,57.38 54.83,56.77 55.01,56.59 56.62,56.59 56.74,56.47 56.74,55.87 56.64,55.77 55.44,55.77 55.35,55.68 v1(54.28,55.68)
DDR_VTT_CNTL: length 23.8
  TOP w0.254: v2(106.63,96.67) 106.63,96.26 106.81,96.08 v1(106.85,96.08) 106.85,95.5 PR8603.1
  IN1 w0.254: v1(96.47,110.85) 96.47,109.43 97.89,108 100.57,108 103.35,105.22 103.35,102.89 105.51,100.74 105.51,99.04 106.85,97.7 v1(106.85,96.08)
  BOTTOM w0.254: U0500.4 96,111.32 v1(96.47,110.85) 96.56,110.85 R0503.1
DDR_VTT_CNTL_R: length 60.4
  TOP w0.102: v1(103.72,89.5) 105.59,87.63 v2(105.59,87.4) 105.59,83.14 102.06,79.61 102.06,76.38 103.38,75.06 v3(104.24,75.06)
  BOTTOM w0.102: 93.96,110.8 93.96,112.85 94.46,113.36 R0504.1 ; 93.96,110.8 93.83,110.67 U0500.2 ; 93.96,110.8 94.31,110.44 96.22,110.44 96.42,110.24 96.42,109.17 96.6,108.99 101.3,108.99 102.58,107.71 102.58,105.04 102.92,104.7 102.92,102.21 101.47,100.76 101.47,100.21 100.33,99.06 100.04,99.06 99.5,98.53 99.5,97.09 101.09,95.51 101.09,93.8 103.72,91.18 v1(103.72,89.5) ; U0400.AW67 106.36,71.04 106.05,71.35 106.05,71.91 105.59,72.37 105.03,72.37 104.86,72.54 104.48,72.54 104.32,72.7 104.32,74.07 104.11,74.27 104.11,74.93 v3(104.24,75.06)
DEVSLP0_HDD: length 78.7
  TOP w0.102: v1(147.9,19.81) 147.9,18.77 v2(149.82,16.86) 150.11,16.56 150.11,13.3 146.17,9.35 v1(116.87,9.35)
  IN1 w0.102: v1(124.55,26.84) 124.69,26.7 125.8,26.7 126.06,26.96 127.49,26.96 130.8,23.65 132.33,22.13 133.49,22.13 135.15,20.47 147.24,20.47 v1(147.9,19.81)
  BOTTOM w0.102: v1(124.55,26.84) 123.91,27.47 R1407.2 ; CON3101.8 113.68,14.15 113.55,14.02 113.27,14.02 112.93,13.69 112.93,13.55 112.93,11.76 114.71,9.98 116.23,9.98 v1(116.87,9.35)
DEVSLP2_SSD: length 118.9
  TOP w0.102: v1(222.28,15.85) 222.02,16.11 R3102.1 219.76,16.66 219.63,16.79 218.77,16.79 216.23,19.33 214.6,19.33 213.82,18.54 212.33,18.54 210.76,20.11 204.99,20.11 204.27,19.38 204.27,18.96 204.51,18.72 204.51,18.72 204.7,18.54 204.7,17.64 204.21,17.15 203.87,17.15 203.69,17.33 202.41,17.33 198.7,13.62 188.26,13.62 187.22,12.58 177.11,12.58 175.46,14.23 165.07,14.23 164.56,14.73 159.27,14.73 v2(156.59,17.41) 155.7,18.3 v1(155.7,18.97)
  IN1 w0.102: v1(155.7,18.97) 155.17,18.44 153.34,18.44 153.09,18.7 152.24,18.7 151.05,19.89 149.58,19.89 148.9,20.58 148.21,20.58 148.11,20.68 135.23,20.68 133.5,22.41 132.33,22.41 131.01,23.73 127.27,27.47 126.29,27.47 125.72,26.9 125.09,26.9 v1(124.55,27.45)
  BOTTOM w0.102: CON3100.38 222.57,11.6 222.28,11.89 v1(222.28,15.85) ; R1408.2 124.83,27.73 v1(124.55,27.45)
DGPU_CS_CTR: length 15.5
  TOP w0.102: T1107.1 114.36,23.38 v1(114.36,23.51)
  IN2 w0.102: v1(114.36,23.51) 114.75,23.12 116.84,23.12 117.61,23.88 118.55,23.88 119.02,24.36 119.02,29.58 118.49,30.11 118.49,31.78 118.19,32.08 v3(117.86,32.08)
  BOTTOM w0.076: v3(117.86,32.08) 117.82,32.12 U0400.V1
DGPU_DMINUS: length 7.6
  BOTTOM w0.102: U6000.T2 163.23,75.79 164.48,74.54 164.48,72.63 T6922.1
DGPU_DPLUS: length 4.6
  BOTTOM w0.102: U6000.T4 163.47,78.97 163.47,78.8 163.56,78.54 163.56,78.36 163.45,78.07 163.45,76.25 T6923.1
DGPU_FANOUT: length 46.7
  TOP w0.102: v1(142.56,80.53) 142.99,80.53 R6941.2
  IN1 w0.102: v1(142.56,80.53) 142.56,79.03 142.95,78.64 144.63,78.64 146.2,77.07 147.42,77.07 148.41,78.06 149.73,78.06 150.77,77.02 150.77,75.92 151.66,75.03 152.4,75.03 153.49,73.94 157.33,73.94 160.43,70.84 165.23,70.84 166.79,69.28 v1(167.41,69.28)
  BOTTOM w0.102: U6000.R5 163.7,79.29 163.7,78.76 163.76,78.57 163.76,78.32 163.65,78.03 163.65,76.73 164.97,75.41 164.97,74.92 164.69,74.64 164.69,72.86 165.08,72.47 165.33,72.47 165.91,71.88 165.91,71.27 166.12,71.07 167.07,71.07 167.26,70.88 167.26,69.43 v1(167.41,69.28) 167.41,68.89 T6939.1
DGPU_HOLD_RST#: length 243.9
  TOP w0.102: v1(209.09,69.42) 208.15,68.48 v2(207.9,68.48) 207.11,68.48 206.73,68.86 200.74,68.86 v1(200.13,68.25) ; v1(201.8,35.11) 202.41,34.5 205.31,34.5 205.74,34.93 205.74,37.75 207.09,39.09 212.83,39.09 v1(213.21,38.71)
  IN1 w0.102: v1(151.72,75.71) 152.06,75.71 153.6,74.17 157.43,74.17 160.55,71.05 165.33,71.05 166.68,69.7 167.69,69.7 169.54,67.85 172.51,67.85 173.83,66.53 176.28,66.53 177.7,65.11 177.7,64.52 180.06,62.16 191.06,62.16 193.82,64.92 193.82,65.89 194.28,66.36 194.28,67.22 195.72,68.66 199.72,68.66 v1(200.13,68.25) ; v1(148.62,22.38) 148.11,21.87 147.9,21.87 147.37,21.34 145.09,21.34 144.04,22.38 139.85,22.38 132.94,29.29 131.7,29.29 131.39,29.59 130.81,29.59 130.2,28.98 128.42,28.98 128.09,29.31 120.41,29.31 119.52,30.2 119.52,30.95 v3(119.09,31.38)
  IN2 w0.102: v1(201.8,35.11) 201.52,35.11 197.56,31.14 193.91,31.14 189.67,26.9 178.71,26.9 177.01,25.2 177.01,21.54 176.91,21.44 170.21,21.44 170.14,21.51 170.14,21.72 169.9,21.96 161.56,21.96 161.29,22.23 157.4,22.23 157.18,22 157.18,20.7 157.76,20.12 157.76,19.09 157.54,18.87 156.74,18.87 155.77,19.84 152.07,19.84 149.89,22.02 148.97,22.02 v1(148.62,22.38)
  IN3 w0.102: v1(138.3,86.29) 138.3,84.99 141.63,81.66 142.82,81.66 144.73,79.76 147.97,79.76 151.72,76.01 v1(151.72,75.71)
  IN3 w0.127: v1(209.09,69.42) 209.09,65.76 207.48,64.15 207.48,54.45 207.72,53.82 209.36,52.19 209.36,42.56 v1(213.21,38.71)
  BOTTOM w0.076: v3(119.09,31.38) 119.49,31.79 119.49,31.93 120.07,32.51 120.07,32.81 120.04,32.91 120.04,33.17 120.07,33.26 120.07,33.46 120.03,33.57 120.03,33.78 U0400.P3
  BOTTOM w0.102: U6001.1 137.66,86.93 v1(138.3,86.29) ; v1(148.62,22.38) 148.97,22.02 R1520.1
DGPU_PS0: length 17.1
  TOP w0.102: v1(148.93,92.08) 148.93,92.08 151.62,94.77 156.34,94.77 156.87,94.24 156.87,93.65 R6200.2 155.93,92.71 155.93,92.14 156.2,91.87 156.57,91.87 v1(157.12,91.32)
  BOTTOM w0.102: v1(148.93,92.08) R6201.1 147.74,92.08 147.73,92.06 C6200.1 v2(146.02,92.06) ; U6000.AC19 157.62,90.62 157.12,91.11 v1(157.12,91.32)
DGPU_PS1: length 4.8
  TOP w0.102: R6203.2 R6202.1 155.52,92.48 155.54,92.47 C6201.1 156.14,91.39 156.18,91.34 v1(156.39,91.34) 156.39,90.96 v2(156.69,90.66)
  BOTTOM w0.102: v1(156.39,91.34) 156.39,91.06 156.83,90.62 U6000.AD19
DGPU_PS2: length 7
  TOP w0.102: R6205.2 152.65,91.01 R6204.1 153.44,91.01 153.87,90.58 v2(153.87,90.27) 153.57,89.97 153.57,89.79 153.16,89.39 C6202.1 153.16,89.18 153.48,88.86 v1(153.92,88.86)
  BOTTOM w0.102: U6000.AE17 155.63,89.02 154.82,89.02 154.66,88.86 v1(153.92,88.86)
DGPU_PS3: length 7.8
  TOP w0.102: v1(153.98,91.14) 153.9,91.21 153.57,91.21 153.34,91.44 R6207.2 152.15,91.8 152.27,91.93 152.96,91.93 153.09,92.05 C6203.1 153.64,92.38 v2(153.9,92.64) R6206.1
  BOTTOM w0.102: v1(153.98,91.14) 154.05,91.21 155.43,91.21 U6000.AE20
DGPU_PWR_EN: length 359.7
  TOP w0.102: v1(162.74,67.62) 162.1,67.62 161.25,66.77 161.25,65.42 162.33,64.34 162.84,64.34 PR9503.1 ; v1(154.38,18.94) 154.66,18.65 154.66,17.19 v1(152.37,14.9) ; v1(195.08,63.05) 195.02,63.05 193.82,64.25 193.82,65.52 198.99,70.69 206.86,70.69 v1(207.57,71.4) 207.57,76.33 v2(205.78,78.12) 204.37,79.53 204.37,98.12 206.63,100.38 207.98,100.38 v1(208.41,100.82) 207.92,101.3 206.28,101.3 205.89,101.69 205.89,101.93 199.87,107.95 195.89,107.95 195.36,108.47 v1(194.53,108.47)
  IN1 w0.102: v1(162.74,67.62) 163.01,67.34 163.01,65.15 164.88,63.28 164.88,62.2 166.78,60.3 175.79,60.3 177.45,61.95 191.26,61.95 192.89,63.58 194.55,63.58 v1(195.08,63.05) ; v1(213.23,37.49) 213.61,37.87 213.61,41.13 205.31,49.44 205.31,51.38 204.74,51.95 204.74,54.53 205.54,55.33 205.54,60.96 207.95,63.38 207.95,68.07 206.92,69.11 206.92,70.75 v1(207.57,71.4) ; v1(119.11,30.77) 119.11,30.32 120.32,29.11 125.77,29.11 126.37,28.5 127.72,28.5 128.18,28.04 133.83,28.04 136.21,25.67 136.21,22.1 137.19,21.11 147.47,21.11 148.03,21.67 148.84,21.67 149.35,21.16 150.42,21.16 152.3,19.28 154.03,19.28 v1(154.38,18.94)
  IN2 w0.102: v1(152.37,14.9) 153.02,15.54 154.68,15.54 155.77,14.46 165.01,14.46 166.08,13.38 172.22,13.38 173.26,14.42 179.2,14.42 179.9,13.72 182.26,13.72 182.54,14 197.54,14 198.17,13.36 201.25,13.36 209.93,22.04 209.93,34.19 v1(213.23,37.49) ; v1(116.59,105.34) 116.97,104.96 116.97,94.8 120.86,90.91 133.25,90.91 136.3,87.86 139.52,87.86 141.86,85.52 141.86,84.1 142.06,83.9 142.06,82.52 143.91,80.67 144.09,80.67 145.75,79.02 145.75,76.98 148.93,73.79 152.65,73.79 153.36,73.08 156.32,73.08 160.69,68.71 162.27,68.71 162.74,68.24 v1(162.74,67.62)
  BOTTOM w0.076: 118.99,30.89 118.99,30.94 118.7,31.24 118.7,32.49 U0400.U1
  BOTTOM w0.102: v1(194.53,108.47) 194.53,109.03 193.14,110.42 R7004.1 ; v1(208.41,100.82) 208.38,100.85 R7205.1 ; 118.99,30.89 v1(119.11,30.77) ; v1(116.59,105.34) PR9426.1
DGPU_PWROK: length 160.5
  TOP w0.102: v1(137.97,88.6) 137.97,88.84 137.45,89.36 135.69,89.36 134.98,90.07 v1(130.76,90.07) 130.38,90.45 130.22,90.45 v1(128.7,91.97)
  IN1 w0.432: v1(118.28,95.71) 118.28,94.41 121.33,91.35 128.09,91.35 v1(128.7,91.97)
  IN2 w0.076: 129.18,34.09 128.58,34.7 v3(128.58,35.56)
  IN2 w0.102: v1(162.28,68.13) 160.27,66.12 160.27,64.59 157.84,62.16 157.84,55.4 153.24,50.8 153.24,44.58 157.28,40.54 157.28,38.61 156.08,37.42 153.43,37.42 149.57,33.56 141.48,33.56 137.83,29.9 135.51,29.9 134.8,29.19 133.86,29.19 133.53,29.52 131.78,29.52 131.45,29.85 130.73,29.85 130.28,29.39 129.27,29.39 128.37,30.29 128.37,30.63 128.64,30.89 129.37,30.89 130.3,31.82 130.3,32.97 129.18,34.09
  IN3 w0.102: v1(130.76,90.07) 133.86,90.07 134.59,89.33 136.27,89.33 136.63,88.98 136.63,86.36 141.61,81.38 142.8,81.38 144.63,79.56 147.88,79.56 151.3,76.14 151.3,75.55 151.77,75.08 156.2,75.08 162.28,69 v1(162.28,68.13)
  BOTTOM w0.076: U0400.C8 126.91,36.79 127.21,36.5 127.45,36.5 128.38,35.56 v3(128.58,35.56)
  BOTTOM w0.102: v2(141.11,90.48) 141.11,89.94 141.1,89.94 U6903.1 ; U6903.1 139.98,89.21 139.57,88.8 139.57,88.08 139.35,87.86 138.36,87.86 137.97,88.25 v1(137.97,88.6) ; U6903.1 141.1,88.44 141.25,88.29 141.63,88.29 141.75,88.42 U6903.2
  BOTTOM w0.222: PU9400.3 113.67,97.17 114.42,96.43 115.14,96.43 115.99,95.58 116.48,95.58 116.89,95.99
  BOTTOM w0.432: v1(118.28,95.71) 118,95.99 PR9415.2 116.89,95.99
DGPU_TS_A: length 10.1
  BOTTOM w0.102: T6924.1 150.85,87.68 150.85,89.49 151.82,90.45 154.66,90.45 154.94,90.17 155.59,90.17 U6000.AE19
DMIC_CLK: length 115
  IN1 w0.152: v1(24.94,75.21) 25.45,74.7 28.85,74.7 29.03,74.53 32.03,74.53 33.43,73.13 33.99,73.13 35.38,74.53 35.69,74.53 39.45,78.29 42.64,78.29 44.02,79.66 44.02,80.62 43.56,81.08 43.56,85.45 v1(43.41,85.6)
  IN3 w0.152: v1(24.94,75.21) 24.36,74.63 22.81,74.63 18.62,70.44 18.62,58.24 19.84,57.03 19.84,55.47 20.9,54.4 20.9,50.62 24.83,46.69 24.83,42.61 26.11,41.33 26.11,32.9 26.39,32.62 26.39,28.35 v1(25.78,27.74)
  BOTTOM w0.152: v1(43.41,85.6) v2(44.96,85.6) 45.36,85.6 47.65,87.89 47.65,92.67 50.53,95.56 56.99,95.56 59.39,97.95 59.39,98.71 59.63,98.96 59.94,98.96 60.58,99.6 CON3000.10 ; v1(25.78,27.74) 25.55,27.97 24.1,27.97 23.55,27.41 C3816.1 22.38,27.74 R3808.1
DMIC_CLK_R: length 2.8
  BOTTOM w0.152: R3808.2 20.84,28.26 v2(20.75,28.35) 20.38,28.72 20.38,29.68 20.22,29.84 U3800.5
DMIC_DATA: length 117.4
  IN1 w0.152: v1(24.36,75.54) 24.36,75 25.36,73.99 31.8,73.99 33.2,72.6 34.21,72.6 35.61,73.99 35.91,73.99 39.64,77.73 42.84,77.73 44.24,79.13 44.55,79.44 44.55,80.84 44.09,81.3 44.09,86.24 v1(44.32,86.46)
  IN3 w0.152: v1(25.45,29.44) 25.6,29.59 25.6,31.98 24.92,32.67 24.92,41.71 23.8,42.83 23.8,46.97 20.37,50.4 20.37,54.18 19.3,55.25 19.3,56.72 18.09,57.93 18.09,70.66 22.59,75.16 23.98,75.16 v1(24.36,75.54)
  BOTTOM w0.152: R3820.1 25.19,29.18 v1(25.45,29.44) ; CON3000.9 60.08,99.86 59.72,99.49 59.41,99.49 58.85,98.94 58.85,98.17 56.77,96.09 50.27,96.09 47.12,92.94 47.12,90.83 46.96,90.68 46.16,90.68 46.01,90.53 46.01,90.24 46.16,90.09 46.96,90.09 47.12,89.94 47.12,89.63 46.96,89.48 45.98,89.48 45.83,89.33 45.83,89.02 45.98,88.87 46.96,88.87 47.12,88.72 47.12,88.11 v2(46.01,87) 45.47,86.46 v1(44.32,86.46)
DMIC_DATA_R: length 5
  BOTTOM w0.152: U3800.4 20.51,30.24 20.93,29.82 20.93,29.31 21.06,29.18 R3820.2 21.39,29.57 21.54,29.72 23.07,29.72 23.14,29.8 v2(23.65,29.8)
DN1: length 15.2
  TOP w0.102: v1(9.37,82.7) 9.11,82.97 8.95,82.97 8.43,83.48 8.43,84.27 7.82,84.88 7.82,85.77 8.2,86.15 8.48,86.15 8.83,86.51 9.1,86.51 9.1,86.51 9.11,86.51 v1(9.28,86.69)
  BOTTOM w0.102: CON5700.A7 8.73,87.25 v1(9.28,86.69) ; L5700.3 14.36,84.23 14.43,84.31 14.43,84.49 14.23,84.69 13.24,84.69 13.13,84.58 13.13,83.31 12.88,83.06 12.58,83.06 D5700.1 11.86,83.11 9.91,83.11 9.75,82.96 9.63,82.96 v1(9.37,82.7)
DN1_MUX: length 3.4
  BOTTOM w0.102: L5700.4 14.36,81.94 14.51,81.79 14.51,81.32 15.84,79.99 U5702.17
DN2: length 8.9
  TOP w0.102: L5701.2 12.26,87.99 12.07,88.19 11.82,88.19 D5703.1 10.92,88.36 10.78,88.36 9.75,89.39 8.61,89.39 7.9,88.67 7.9,87.52 7.21,86.83 6.82,86.83 CON5700.B7
DN2_MUX: length 16.4
  TOP w0.102: v1(14.88,87.18) 14.96,87.25 14.96,87.86 14.83,87.99 L5701.1
  IN1 w0.109: v1(20.14,81.77) 19.94,81.57 19.94,81.28 19.63,80.97 18.89,80.97 18.34,81.51 18.34,84.45 17.94,84.86 14.64,84.86 14.27,85.23 14.27,86.09 14.7,86.52 14.9,86.52 15.06,86.69 15.06,87 v1(14.88,87.18)
  BOTTOM w0.102: U5702.9 19.38,79.99 19.48,80.09 19.69,80.09 19.96,80.37 19.96,81.59 v1(20.14,81.77)
DP1: length 15.6
  TOP w0.102: v1(9.37,83.34) 9.2,83.17 9.03,83.17 8.64,83.57 8.64,84.35 8.03,84.96 8.03,85.69 8.29,85.95 8.56,85.95 8.92,86.31 9.01,86.31 v1(9.27,86.05)
  BOTTOM w0.102: CON5700.A6 7.88,86.75 8.18,87.05 8.64,87.05 8.88,86.81 8.88,86.16 8.99,86.05 v1(9.27,86.05) ; v1(9.37,83.34) 9.55,83.16 9.67,83.16 9.82,83.31 11.93,83.31 D5701.1 12.61,83.26 12.79,83.26 12.93,83.4 12.93,84.66 13.16,84.89 14.31,84.89 14.91,84.3 L5700.2
DP1_MUX: length 3
  BOTTOM w0.102: L5700.1 14.91,81.99 14.71,81.79 14.71,81.41 15.72,80.39 U5702.18
DP2: length 8.9
  TOP w0.102: L5701.3 11.97,88.54 D5702.1 10.98,88.59 10.84,88.59 9.84,89.59 8.53,89.59 7.7,88.76 7.7,87.6 7.13,87.04 6.95,87.04 CON5700.B6
DP2_MUX: length 16.4
  TOP w0.102: v1(15.55,87.18) 15.16,87.56 15.16,88.24 14.86,88.54 L5701.4
  IN1 w0.109: v1(15.55,87.18) 15.43,87.18 15.27,87.02 15.27,86.6 14.99,86.31 14.78,86.31 14.48,86.01 14.48,85.32 14.73,85.07 18.03,85.07 18.55,84.54 18.55,81.6 18.97,81.18 19.54,81.18 19.73,81.37 19.73,81.68 19.63,81.79 v1(19.53,81.79)
  BOTTOM w0.102: U5702.8 19.41,80.39 19.51,80.29 19.6,80.29 19.76,80.45 19.76,81.57 19.74,81.6 19.74,81.69 19.63,81.79 v1(19.53,81.79)
DP_DDI2_DATA0: length 158.6
  TOP w0.102: C5709.1 31.19,79.78 31.39,79.99 31.8,79.99 v1(31.98,79.81)
  IN1 w0.109: v1(131.2,61.42) 131.2,64.45 129.37,66.28 128.87,66.28 127.74,67.4 127.74,72.55 127.97,72.78 127.97,75.39 128.55,75.97 128.55,81.73 125.92,84.36 116.14,84.36 113.41,87.09 112.37,87.09 106.17,93.3 105.38,93.3 104.13,94.55 102.35,94.55 101.89,95.01 101.89,96.08 101.14,96.83 98.44,96.83 98.02,97.26 85.18,97.26 76.19,106.24 68.86,106.24 67.84,105.21 67.25,105.21 60.88,105.21 58.16,102.5 57.55,102.5 56.92,101.88 56.92,100.4 55.38,98.87 51.48,98.87 45.68,93.08 43.45,93.08 41.54,91.16 34.6,91.16 31.29,87.85 30.38,87.85 29.69,87.16 29.69,85.26 28.97,84.55 28.97,80.69 29.83,79.83 31.95,79.83 v1(31.98,79.81)
  BOTTOM w0.076: U0400.D50 125.72,60.63 126.38,60.63 126.53,60.57 126.77,60.57 126.87,60.61 127.09,60.61 127.22,60.56 128.44,60.56 128.69,60.31 129.15,60.31 129.16,60.29 129.18,60.29
  BOTTOM w0.102: v1(131.2,61.42) 130.61,60.84 130.23,60.84 130.11,60.71 129.97,60.71 129.56,60.29 129.18,60.29
DP_DDI2_DATA0#: length 158.4
  TOP w0.102: v1(31.98,80.5) 31.67,80.19 31.32,80.19 31.19,80.32 C5710.1
  IN1 w0.109: v1(31.98,80.5) 31.53,80.05 29.91,80.05 29.18,80.77 29.18,84.46 29.9,85.18 29.9,87.07 30.46,87.64 31.37,87.64 34.69,90.95 41.62,90.95 43.54,92.86 45.77,92.86 51.56,98.66 55.47,98.66 57.13,100.32 57.13,101.79 57.63,102.29 58.25,102.29 60.96,105 67.17,105 67.92,105 68.95,106.03 76.11,106.03 85.09,97.04 97.93,97.04 98.36,96.62 101.05,96.62 101.68,95.99 101.68,94.92 102.26,94.34 104.04,94.34 105.29,93.09 106.08,93.09 112.28,86.88 113.32,86.88 116.05,84.15 125.83,84.15 128.34,81.65 128.34,76.06 127.76,75.48 127.76,72.86 127.53,72.64 127.53,67.31 128.78,66.07 129.29,66.07 130.99,64.37 130.99,62.04 130.83,61.88 130.45,61.88 130.35,61.78 130.35,61.61 v1(130.55,61.42)
  BOTTOM w0.076: U0400.C50 125.79,61.01 125.72,61.07 125.72,61.18 125.88,61.34 126.14,61.34 126.31,61.17 126.31,60.87 126.37,60.81 126.45,60.78 126.52,60.75 126.56,60.73 126.74,60.73 126.84,60.77 127.12,60.77 127.25,60.72 128.51,60.72 128.76,60.48 129.15,60.48 129.16,60.5 129.18,60.5
  BOTTOM w0.102: 129.18,60.5 129.47,60.5 129.89,60.91 130.02,60.91 130.15,61.04 130.53,61.04 130.64,61.15 130.64,61.33 v1(130.55,61.42)
