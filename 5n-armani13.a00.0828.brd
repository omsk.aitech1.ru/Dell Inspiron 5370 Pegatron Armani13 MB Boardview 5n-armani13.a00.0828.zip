# Allegro board 5n-armani13.a00.0828.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+5V: length 341.2
  TOP w0.254: v1(158.72,39.93) 158.66,39.93 157.48,41.11 157.48,46.99 158.52,48.03 158.52,48.95 v4(160.78,51.21) 161.65,51.21 163.15,52.71 163.15,56.4 162.61,56.94 v1(162.61,58.35)
  TOP w0.356: Q2401.2 24.87,21.24
  TOP w0.432: v1(90.42,14.95) 90.42,13.79 88.11,11.48 v1(88.11,11.23) 88.11,10.77 88.44,10.44 R1920.1 ; v1(18.9,42.35) v2(18.9,42.98) ; PR7811.1 177.65,56.82 177.72,56.9 PR7808.1 178.44,57.23 v1(178.11,57.56)
  TOP w0.508: v1(206.51,67.74) 206.24,68.02 201.24,68.02 200.66,67.44 199,67.44 197.99,66.43 197.99,63.55 196.6,62.16 195.91,62.16 v1(195.81,62.05) ; v1(207.57,86.82) 207.57,85.09 v2(207.65,85.02) ; Q2600.3 23.86,69.11 23.99,69.24 v1(23.99,69.25)
  IN1 w0.508: v1(18.9,42.35) 18.9,39.34 ; v1(207.57,86.82) 207.57,72.29 206.51,71.23 v1(206.51,67.74) 207.44,66.81 207.44,63.55 205.13,61.24 205.13,55.5 204.04,54.41 204.04,51.08 204.57,50.55 v4(204.67,50.55) ; v1(195.81,62.05) 194.81,61.05 190.97,61.05 190.78,61.24 182.12,61.24 178.44,57.56 v1(178.11,57.56) ; v1(156.97,57.51) 157.23,57.76 162.03,57.76 v1(162.61,58.35)
  IN2 w0.432: v1(105.21,101.82) 107.51,104.13 112.18,104.13 112.57,104.52 115.62,104.52 115.7,104.45 v1(115.77,104.45)
  IN2 w0.508: 156.31,26.7 156.31,20.42 v1(157.1,19.64) ; 156.31,26.7 158.8,29.19 158.8,30.51 160.45,32.16 v1(160.45,42.27) 160.2,42.27 159.84,42.63 159.84,43.65 161.51,45.32 166.98,45.32 v1(167.13,45.16) ; 156.31,26.7 144.37,26.7 143.51,27.56 142.9,27.56 v1(142.7,27.36) ; v1(178.11,57.56) 178.11,57.51 176.45,55.86 174.22,55.86 172.67,57.41 163.55,57.41 v1(162.61,58.35) ; v1(23.99,69.25) 22.14,67.4 22.14,59.42 23.22,58.35 23.22,56.53 21.62,54.93 21.62,49.08 18.9,46.36 v1(18.9,42.35) ; v1(156.97,57.51) 156.97,57.76 155.32,59.41 155.32,67.49 155.73,67.9 155.73,70.1 152.49,73.34 148.78,73.34 145.26,76.85 145.26,78.89 143.92,80.24 143.73,80.24 142.24,81.73 141.93,81.73 136.56,87.1 136.45,87.1 134.05,89.5 131.1,89.5 131.02,89.42 129,89.42 127.94,90.48 120.68,90.48 118.19,92.97 117.14,92.97 116.78,93.32 116.78,94.24 114.33,96.7 114.33,98.15 115.06,98.89 115.06,101.86 116.2,103 116.2,104.02 v1(115.77,104.45)
  BOTTOM w0.254: v1(162.61,58.35) 161.47,59.49 161.47,61.34 161.39,61.42 PC8006.1 161.39,62.89 161.16,63.12 PU8001.6 ; PU7900.6 160.45,43.64 159.94,43.13 159.94,42.4 PC7900.1 ; PC7900.1 160.1,41.91 v1(160.45,42.27) ; PC7900.1 159.23,41.68 159.23,40.31 158.85,39.93 v1(158.72,39.93) ; 144.61,29.32 PU8000.6
  BOTTOM w0.356: v1(90.42,14.95) 90.4,14.98 89.07,14.98 87.94,16.11 85.75,16.11 85.55,16.31 84.95,16.31 84.35,16.9 U5100.1
  BOTTOM w0.432: PC8002.1 143.41,28.07 v1(142.7,27.36) ; R3611.1 207.85,87.53 207.57,87.25 v1(207.57,86.82) ; R5824.1 114.4,17.33 114.58,17.51 116.23,17.51 117.55,16.18 R3714.1 120.47,14.81 v1(120.78,14.81) ; R1913.1 18.85,42.75 18.9,42.7 v1(18.9,42.35)
  BOTTOM w0.508: v1(174.75,18.35) 174.75,18.77 174.61,18.91 F5100.1 ; v1(105.21,101.82) 105.21,102.15 105.5,102.44 PR9413.2 ; v1(115.77,104.45) 116.23,103.99 PR9414.1 ; R3600.1 207.57,86.06 v1(207.57,86.82) ; v1(167.13,45.16) 167.62,45.65 PR7801.2 ; 144.61,29.32 144.02,28.73 PC8002.1
  vias: v1(103.4,12.91) v1(104.01,12.91) v4(17.48,37.32) v4(18.36,37.34) v4(21.77,12.68) v4(22.66,12.68) v4(23.55,12.68) v4(204.67,49.67) v4(204.67,48.81)
+5V_3V_VCLK: length 1.5
  BOTTOM w0.102: PU8900.19 202.39,58.81 202.57,58.98 PR8923.2
+5V_3V_VIN: length 6.2
  TOP w0.508: PR8900.2 v2(196.73,61.48) 197.06,61.48 v1(197.99,62.41)
  BOTTOM w0.229: PU8900.12 199.9,61.11 199.7,61.32
  BOTTOM w0.508: v1(197.99,62.41) 198.88,62.41 PC8901.1 199.7,61.6 199.7,61.32
+5V_ANALOG: length 4.4
  BOTTOM w0.229: U3800.40 16.04,32.54 15.52,33.07 15.52,33.61
  BOTTOM w0.432: 15.52,33.61 14.77,34.36 C3819.1 14.28,34.55 14.28,34.9 14.17,35 14.17,35.56
  vias: v2(13.92,36.71)
+5V_CCG4: length 63.1
  TOP w0.432: v2(24.64,63.45) 24.09,62.91 v1(24.09,61.09) 25.1,61.09 25.22,61.22 R5801.2 26.64,61.57 C5814.1 27.31,59.9 26.98,59.57 R5800.2
  IN1 w0.508: v1(29.72,32.24) 29.52,32.44 29.52,34.94 29.26,35.19 29.26,38.89 29.03,39.12 29.03,41.44 27.87,42.6 26.8,42.6 24.84,44.55 24.84,57.82 26.02,58.99 26.02,59.77 24.7,61.09 v1(24.09,61.09)
  IN2 w0.508: v1(29.72,32.24) 30.53,31.42 30.53,29.09 31.79,27.83 31.86,27.83 32.59,27.1 32.59,21.29 35.08,18.8 v1(36.37,18.8)
  BOTTOM w0.508: U5801.5 39.55,20.5 38.91,19.87 37.72,19.87 36.65,18.8 v1(36.37,18.8)
+5V_CCG4_SWITCH: length 95.9
  TOP w0.279: v1(44.32,77.86) 44.24,77.86 44.11,77.99 U5800.8
  TOP w0.432: C5812.1 C5811.1 44.42,77.96 v1(44.32,77.86) ; v1(28.14,58.65) 27.73,58.23 27.73,56.66 27.71,56.64 C5813.1
  IN1 w0.508: v1(30.28,32.6) 30.13,32.75 30.13,35.19 29.87,35.44 29.87,39.15 29.64,39.37 29.64,41.69 25.45,45.88 25.45,57.48 26.62,58.65 v1(28.14,58.65) ; v1(44.32,77.86) 44.93,77.25 44.93,74.61 42.9,72.58 42.9,71.89 41.88,70.87 41.88,68.86 41.15,68.13 37.29,68.13 36.32,69.09 33.6,69.09 32.83,69.86 32.63,69.86 v1(31.9,70.59)
  IN2 w0.508: v1(31.9,70.59) 31.24,70.59 28.88,68.23 28.88,66.02 27.2,64.34 27.2,59.59 v1(28.14,58.65) ; v1(30.28,32.6) 31.93,30.95 31.93,28.65 33.22,27.36 33.22,21.55 35.29,19.48 v1(36.37,19.48)
  BOTTOM w0.508: U5801.1 41.32,20.71 40.6,21.42 38.89,21.42 38.78,21.31 38.2,21.31 v1(36.37,19.48) ; v1(44.32,77.86) v2(43.69,77.86)
+5V_FAN: length 12.3
  BOTTOM w0.102: v2(203.35,85.22) 203.35,83.11 203.81,82.65 205.18,82.65 205.33,82.8 CON3600.1
  BOTTOM w0.381: CON3600.1 205.33,85.7 205.46,85.83 R3600.2
  BOTTOM w0.432: C3601.1 C3600.1 208.43,85.5 207.92,84.99 206.24,84.99 205.97,85.26 R3600.2
+5V_HDD: length 2.9
  BOTTOM w0.432: 111.17,15.31 111.17,16.63 111.33,16.79 C3125.1 111.33,17.83 v2(111.56,18.06)
+5V_HDMI: length 13.4
  TOP w0.432: v2(21.74,73.94) 21.74,73.51 21.59,73.36 R2601.1 21.59,72.8 22.06,72.33 Q2600.2
  TOP w0.508: v2(21.74,73.94) 21.74,74.12 21.3,74.56 20.61,74.56 20.25,74.2 F2600.2 20.25,72.2 18.65,70.6 D2902.3 18.65,66.15 v2(18.52,66.02)
+5V_KB: length 8.7
  BOTTOM w0.432: 172.09,19.37 172.11,19.35 172.11,18.46 172.38,18.19 CON5101.1
  BOTTOM w0.508: 172.09,19.37 C5125.1 172.09,20.23 172.49,20.63 175.55,20.63 F5100.2 v2(177.5,19.76)
+5V_PVDD: length 3.8
  BOTTOM w0.229: U3800.46 18.44,32.42 19.62,33.59 v4(19.62,34.09) ; v4(16.17,33.27) 16.17,32.93 16.44,32.66 U3800.41
  vias: v2(19.94,33.1)
+5V_USB: length 1.3
  BOTTOM w0.102: v2(203.61,43.39) 203.87,43.65 U5101.1
+5VA: length 225.2
  TOP w0.432: v1(141.55,23.85) 143.43,23.85 143.64,23.65 PC9205.1
  TOP w0.508: v2(146.51,15.01) 146.91,15.42 v1(147.04,15.42) ; v1(157.07,12.25) 156.46,11.64 152.86,11.64 152.5,11.99 152.5,13.72 151.71,14.51 v1(151.71,14.9) ; v1(207.33,69.5) v1(200.65,69.5)
  IN1 w0.508: v1(207.33,69.5) 208.36,68.47 208.36,63.1 205.94,60.68 205.94,55.17 205.14,54.37 205.14,52.15 205.71,51.58 205.71,50.47 206.65,49.53 209.45,49.53 211.99,46.99 211.99,43.33 v1(213.23,42.09)
  IN2 w0.508: v1(157.07,12.25) 157.07,12.02 157.48,11.61 165.37,11.61 166,10.98 172.26,10.98 173.07,11.79 178.79,11.79 180.18,10.4 v1(180.18,10.37) 180.74,10.93 181.33,10.93 181.72,10.54 202.21,10.54 203.66,11.99 203.66,14.49 210.97,21.81 210.97,27.08 214.75,30.85 214.75,40.57 v1(213.23,42.09) ; v1(151.71,14.9) 150.03,13.21 148.64,13.21 147.04,14.81 v1(147.04,15.42)
  IN3 w0.508: v1(201.29,62.91) 200.51,63.68 199.03,63.68 198.09,64.62 198.09,67.69 199.26,68.86 200.2,68.86 200.65,69.31 v1(200.65,69.5) 200.76,69.61 200.76,77.35 200.18,77.93 200.18,82.83 200.03,82.98 200.03,104.48 197.27,107.24 194.89,107.24 190.8,111.33 190.12,111.33 v1(190.09,111.36) ; v1(141.55,23.85) 143.36,23.85 144.75,22.46 144.75,17.71 v1(147.04,15.42)
  BOTTOM w0.203: U7000.4 189.61,109.96 190.4,110.75 190.68,110.75 ; v1(141.55,23.85) 140.44,23.85 140.36,23.78 PU9200.4
  BOTTOM w0.229: 200.43,61.75 200.43,61.39 200.3,61.27 PU8900.13 ; PU9101.4 179.71,12.36 PC9101.1
  BOTTOM w0.254: PC9101.1 180.7,11.37 180.7,10.88 180.65,10.83
  BOTTOM w0.432: v1(190.09,111.36) 190.2,111.25 C7001.1 190.88,110.95 190.68,110.75 ; v1(201.29,62.91) 201.29,62.86 200.64,62.21 PC8902.1 200.48,61.8 200.43,61.75 ; v1(180.18,10.37) 180.65,10.83
+5VSB: length 278.2
  TOP w0.203: PU9001.4 37.64,70.13
  TOP w0.254: v1(7.93,93.7) 10,93.7 10.1,93.6 v1(14.5,93.6)
  TOP w0.356: v1(75.95,19.83) 76.29,19.49 76.29,18.56 R1915.1
  TOP w0.432: R5801.1 25.4,60.35 ; v1(38.18,69.85) 38.56,69.85 PC9001.1 38.53,70.44 37.95,70.44 37.64,70.13
  TOP w0.508: v1(102.92,100.75) 102.92,100.81 PR8600.1 ; 25.4,60.35 24.56,59.51 24.56,57.43 22.96,55.83 v2(21.95,55.83) 21.24,55.13 19.57,55.13 v1(18.29,56.42)
  IN1 w0.254: v1(2.11,97.59) 3.23,97.59 3.76,97.06 3.76,96.62 4.01,96.37 4.01,95.61 4.95,94.67 6.96,94.67 v1(7.93,93.7)
  IN1 w0.508: v1(206.12,71.91) 205.9,71.69 205.9,67.49 206.83,66.56 206.83,63.83 204.52,61.52 204.52,55.76 203.43,54.66 203.43,48.85 204.64,47.64 v4(204.71,47.64) ; v1(197.7,51.86) 197.59,51.74 v4(197.59,50.6)
  IN2 w0.508: v1(61.7,19.76) 62.03,20.09 63.35,20.09 63.57,19.87 63.6,19.87 63.62,19.85 69.69,19.85 70.83,18.71 74.82,18.71 v1(75.95,19.83) ; v1(102.92,100.75) 102.49,100.32 101.23,100.32 100.91,100.64 99.19,100.64 94.69,96.14 82.75,96.14 80.96,97.93 58.69,97.93 57.91,97.16 57.2,97.16 57.13,97.09 53.54,97.09 51.39,99.24 49.68,99.24 48.9,100.03 46.36,100.03 41.86,95.53 38.28,95.53 34.87,92.13 34.87,90.38 35.82,89.44 36.22,89.44 36.96,88.7 36.96,87.5 37.92,86.53 37.92,83.88 37.08,83.04 37.08,82.21 35.64,80.76 35.64,76.48 38.2,73.92 38.2,69.88 v1(38.18,69.85) 39.29,68.73 39.29,66.73 38.01,65.44 38.01,57.45 39.01,56.44 39.01,54.56 38.28,53.83 38.28,51.64 38.66,51.26 39.88,51.26 41.25,49.89 v1(41.25,41.15)
  IN3 w0.254: v1(14.5,93.6) 15.47,93.6 15.65,93.42 17.78,93.42 19.61,95.25 v1(23.55,95.25)
  IN3 w0.508: v1(61.7,19.76) 61.6,19.66 55.75,19.66 55.23,20.18 55.23,20.49 51.47,24.25 51.47,26.26 51.12,26.62 50.14,26.62 49.15,27.61 46.08,27.61 44.83,28.86 44.27,28.86 42.67,30.46 42.67,39.73 v1(41.25,41.15)
  BOTTOM w0.254: 205.13,46.26 CON5103.47 ; LED5000.2 2.02,97.51 v1(2.11,97.59) ; 205.12,47.26 CON5103.49 ; 205.13,46.76 CON5103.48 ; 204.83,47.76 CON5103.50
  BOTTOM w0.508: v1(18.29,56.42) 17.81,55.93 17.81,54.34 16.79,53.33 PD7601.2 18.01,52.34 18.13,52.45 19.29,52.45 19.87,53.04 PR7609.1 ; PR8908.2 203.4,69.19 v1(206.12,71.91)
  vias: v1(203.86,46.28) v1(204.62,46.89) v1(205.03,46.38) v4(23.95,92.61) v4(23.98,91.7) v4(24.86,92.83) v4(24.83,91.89) v4(25.73,92.8) v4(195.22,49.25) v4(195.89,48.62) v4(197.51,49.68) v4(198.45,49.71) v4(204.5,45.87)
+5VSB&+3P3VSB_IN: length 21.6
  TOP w0.508: PR8900.1 194.66,60.1 v1(194.55,60.21)
  TOP w2.032: 182.65,42.4 183.27,43.02 183.27,43.08 184.02,43.83 184.02,49.23 185.25,50.45 187.98,50.45
  IN2 w0.508: v4(189.71,53.32) 193.32,56.92 193.32,58.98 v1(194.55,60.21)
  vias: v2(183.57,40.77) v4(179.98,40.03) v4(180.87,40.01) v4(181.76,40.03) v4(182.65,40.01) v4(188.21,52.3) v4(189.03,52.66) v4(189.84,52.3)
+5VSB_BST1_C: length 2.5
  BOTTOM w0.432: PR8902.2 205.56,60.45 205.35,60.24 PC8904.1
  BOTTOM w0.508: v2(206.63,61.23) PR8902.2
+5VSB_BST_C: length 3.1
  BOTTOM w0.229: PU8900.17 202.08,59.61 202.34,59.87 202.34,60.33 v2(202.87,60.86) 202.87,60.86 203.24,61.23 PR8902.1
+5VSB_CS1_A: length 5
  BOTTOM w0.102: v2(204.81,57.47) 204.5,57.15 203.48,57.15 203.07,56.75 PR8909.2
  BOTTOM w0.229: PU8900.1 201.1,57.39 201.3,57.2 201.3,56.97 201.6,56.67 PR8909.2
+5VSB_FB_A: length 4
  BOTTOM w0.229: PR8911.1 PR8910.2 201.73,56.19 201.66,56.25 PC8912.2 200.97,56.49 200.97,57.03 200.7,57.29 PU8900.2
+5VSB_FBR_A: length 42.9
  IN1 w0.254: v1(194.77,50.65) 194.77,49.96 194.62,49.81 194.62,48.47 195.73,47.35 199.77,47.35 203.16,43.95 203.16,41.75 202.64,41.22 v1(202.64,39.82)
  IN2 w0.254: v1(202.64,39.82) 202.64,42.06 203.08,42.5 203.08,43.29 206.27,46.49 206.27,53.11 v1(206.65,53.49)
  BOTTOM w0.203: v1(206.65,53.49) 205.41,54.74 205.41,55.13 205.28,55.26 PC8913.1 ; PJP8900.2 194.54,48.21 194.41,48.34 194.41,49.02
  BOTTOM w0.229: PC8913.1 204.37,54.83 202.63,54.83 PR8910.1 201.73,55.32 201.66,55.39 PC8912.1
  BOTTOM w0.254: v1(194.77,50.65) 194.77,49.96 194.41,49.61 194.41,49.02 ; v1(202.64,39.82) 202.64,40.39 v2(202.54,40.49)
+5VSB_HG_D: length 40.3
  TOP w0.635: v4(201.96,60.81) v2(200.71,60.81)
  IN1 w0.635: v4(183.62,39.17) 183.62,47.82 185.42,49.62 190.61,49.62 191.88,50.89 191.88,53.67 193.78,55.56 193.78,56.82 195.58,58.63 196.29,58.63 197.55,57.37 198.46,57.37 198.6,57.23 199.39,57.23 200.08,57.91 201.03,57.91 201.68,58.56 201.68,60.52 v4(201.96,60.81)
  BOTTOM w0.229: PU8900.16 201.65,60.5 201.83,60.68 201.84,60.68 v4(201.96,60.81)
  BOTTOM w0.635: PR8903.1 183.74,39.3 v4(183.62,39.17)
+5VSB_HGR_D: length 1.2
  BOTTOM w0.508: v2(186.33,38.05) PR8903.2
+5VSB_LG_D: length 31.7
  IN1 w0.635: v4(202.56,61.59) 201.92,62.23 200.3,62.23 199.44,61.37 196.7,61.37 192.58,57.25 192.58,55.99 190.74,54.15 190.74,51.36 190.14,50.76 185.24,50.76 185.08,50.93 v4(183.46,50.93)
  BOTTOM w0.229: v4(202.56,61.59) 202.38,61.4 201.72,61.4 201.1,60.79 PU8900.15
  BOTTOM w0.635: v4(183.46,50.93) 183.72,50.93 184.1,50.55 v2(184.1,49.68) 184.1,48.86 PR8905.1
+5VSB_LGR_D:
  vias: v2(184.91,46.79)
+5VSB_PHASE1_S: length 33.9
  TOP w0.127: v1(203.28,59.7) 202.85,60.12 v2(202.64,60.12)
  IN1 w0.762: v1(203.28,59.7) 203.17,59.59 203.17,57.1 202.03,55.96 198.21,55.96 198.01,56.15 197.35,56.15 196.19,54.99 195.22,54.99 193.09,52.86 193.09,48.62 192.13,47.65 189.54,47.65 185.12,43.23 v1(185.12,42.32)
  BOTTOM w0.229: v1(203.28,59.7) 202.8,59.7 202.31,59.21 PU8900.18
  BOTTOM w0.432: PC8904.2 203.51,59.92 v1(203.28,59.7)
+5VSB_SN_S:
  vias: v2(186.72,46.79)
+5VSB_VO: length 4.1
  BOTTOM w0.229: 200.98,61.37 200.7,61.09 PU8900.14
  BOTTOM w0.432: PR8908.1 202.88,62.65 202.82,62.7 PC8911.1 201.4,62.07 201.4,61.84 201.38,61.83 v2(201.38,61.8) 200.98,61.4 200.98,61.37
+19VADC_VIN:
  vias: v2(45.82,98.63) v4(34.19,96.93) v4(34.8,97.82) v4(35.05,96.95) v4(38.99,98) v4(39.7,97.41) v4(40.31,98.05) v4(41.07,97.59) v4(41.83,98.76) v4(41.96,97.59) v4(42.7,99.09)
+VBATT: length 70.9
  TOP w0.254: v1(201.6,24.11) 202.21,24.11 202.57,23.75 202.57,23.04 v2(201.87,22.34) 201.47,21.95 201.47,18.54 197.56,14.63 165.66,14.63 159.51,20.79 v1(159.51,21.82)
  IN3 w0.254: v1(148.36,23.7) 148.36,24.84 149.73,26.21 155.12,26.21 v1(159.51,21.82)
  BOTTOM w0.254: 147.24,23.7 v1(148.36,23.7) ; PR7715.2 201.18,24.71 201.6,24.28 v1(201.6,24.11)
  vias: v4(121.31,15.65) v4(122.2,15.65) v4(123.09,15.65) v4(124,15.65) v4(124.89,15.65) v4(125.76,15.65) v4(138.76,19.94) v4(139.65,19.94) v4(140.54,19.94) v4(141.45,19.94) v4(142.34,19.94) v4(143.21,19.94)
+VBATT_F:
  vias: v2(127.84,17.76)
+VCC_RTC: length 309
  TOP w0.254: R3804.1 16.18,36.1 16.44,36.1 C3807.1 16.73,38.14 v1(19.64,41.05) ; R2339.1 44.4,55.78 46.23,57.61 R2310.1 46.81,57.82 46.26,58.37 45.85,58.37 v1(45.82,58.35) ; R2308.1 45.76,40.96 v1(46.08,41.28) ; v1(56.08,24.74) 56.08,24.18 56.29,23.98 D3605.2 ; v1(96.93,92.61) 96.93,90.99 102.03,85.88 C3605.1 101.27,83.9 101.22,83.95 D3604.2 ; v1(99.77,13.26) 100.25,12.78 T3600.1
  TOP w0.508: v1(44.81,51.08) v2(44.35,51.54)
  IN1 w0.254: v1(45.82,58.35) 46.13,58.65 46.13,63.15 48.39,65.41 48.39,69.75 50.5,71.86 52.32,71.86 54.89,74.42 56.29,74.42 57.02,75.16 57.02,90.4 61.57,94.95 61.57,96.8 62.87,98.1 77.32,98.1 82.63,92.78 93.07,92.78 94.21,91.65 96.57,91.65 96.93,92 v1(96.93,92.61) ; v1(99.77,13.26) 93.78,13.26 v1(93.47,13.57)
  IN2 w0.254: v1(46.08,41.28) 46.56,41.28 49.23,38.61 49.23,26.97 51.99,24.2 55.65,24.2 56.08,24.64 v1(56.08,24.74)
  IN3 w0.254: v1(45.82,58.35) 46.2,57.97 46.2,53.27 44.81,51.87 v1(44.81,51.08) 44.83,51.08 45.57,50.34 45.57,48.31 46.08,47.8 v1(46.08,41.28)
  BOTTOM w0.254: Q2406.2 102.16,12.02 102.11,11.97 99.09,11.97 98.96,12.09 R2428.2 98.96,13.11 99.11,13.26 v1(99.77,13.26) ; v1(19.64,41.05) 19.63,41.05 19.63,41.05 19.63,41.05 19.69,41.1 20.32,41.1 20.52,41.3 23.24,41.3 25.48,43.54 25.48,47.64 30.93,53.09 40.03,53.09 42.04,51.08 v1(44.81,51.08) ; v1(96.93,92.61) 96.83,92.61 96.29,92.08 83.44,92.08 82.4,91.04 82.4,74.35 76.8,68.75 76.8,32.99 82.32,27.47 82.32,27.09 84.23,25.18 84.23,23.75 84.58,23.4 84.58,22.94 87.2,20.32 87.2,18.77 89.33,16.64 90.41,16.64 91.72,15.33 91.72,15.11 92.61,14.21 92.83,14.21 v1(93.47,13.57)
+VCC_RTC_PCH: length 31.3
  TOP w0.432: v1(108.66,24.28) 108.66,23.59 108.83,23.42 R1623.2 109.32,22.91
  TOP w0.508: v1(102.51,12.68) 104.22,10.98 106.57,10.98 106.99,11.39 106.99,14.12 106.65,14.46 106.65,16.96 107.39,17.7 107.39,20.98 v2(108.8,22.39) 109.32,22.91
  IN1 w0.508: v1(102.46,14.49) 102.51,14.44 v1(102.51,12.68) 101.73,12.68 101.35,13.06 v1(101.35,13.69)
  BOTTOM w0.432: R2415.2 102.99,15.01 v1(102.46,14.49) ; R2428.1 100.49,12.6 Q2406.3 ; R1011.1 R1009.1 R1206.1 109.47,22.86 108.94,23.4 108.94,24 v1(108.66,24.28)
  BOTTOM w0.508: Q2406.3 100.85,13.2 v1(101.35,13.69)
+VCCDSW_3P3: length 58.6
  TOP w0.254: R1622.2 113.21,42.24 v3(113,42.45)
  TOP w0.432: v1(95.38,31.5) 95.38,31.85 95.22,32.01 R1200.1 ; R1209.1 92.1,27.94 92.13,27.92 R1204.1 93.27,27.92 v1(93.35,27.84)
  IN2 w0.508: v1(106.58,24.78) 105.27,26.09 105.27,28.04 103.16,30.14 94.93,30.14 93.35,28.56 v1(93.35,27.84)
  IN3 w0.381: v3(113,42.45) 113.49,42.45 114.17,41.76 114.75,41.76 v3(114.76,41.77) 114.87,41.77 115.28,41.37 115.28,40.78 114,39.5 114,34.11 112.38,32.5 112.38,28.31 112.02,27.94 112.02,27.12 112.53,26.6 112.53,25.64 111.72,24.83 111.72,24.48 110.71,23.47 109.31,23.47 109.09,23.25 108.23,23.25 107.4,24.08 107.14,24.08 106.58,24.64 v1(106.58,24.78)
  BOTTOM w0.254: U0400.AJ17 112.95,42.45 v3(113,42.45) ; U0400.AD18 U0400.AD17 115.15,42.13 114.79,41.77 v3(114.76,41.77)
  BOTTOM w0.432: R1203.1 97.2,32.08 97.16,32.04 R1214.1 96.38,32.04 96.34,32.08 95.78,32.08 95.38,31.68 v1(95.38,31.5)
  BOTTOM w0.508: v1(95.38,31.5) 95.38,31.26 94.98,30.86 94.54,30.86 v2(94.22,30.55) 93.35,29.67 v1(93.35,27.84)
+VCCGT: length 70.8
  TOP w0.254: R0703.2 180.06,51.46 180.06,52.45 179.43,53.09 179.43,58.02 v2(178.62,58.82) v1(177.86,59.58)
  IN1 w0.254: v1(177.86,59.58) 177.42,60.02 176.63,60.02 176.23,59.62 165.18,59.62 163.75,61.04 161.87,61.04 160.27,62.64 156.43,62.64 153.17,65.89 153.17,66.97 152.28,67.86 149.57,67.86 148.39,69.04 144.88,69.04
  IN3 w0.381: v3(128.03,65.1) 127.27,65.86 127.27,66.36 127.86,66.96 127.86,67.17 v3(128.31,67.62)
  IN3 w0.508: 128.3,68.25 128.3,68.26 128.3,68.41 128.95,69.06 v3(128.95,70.13) 128.95,70.16 127.71,71.4 127.71,72.98 127.94,73.21 127.94,76 127.06,76.88 127.06,79.52 125.07,81.51 v4(124.94,81.51)
  BOTTOM w0.178: v3(128.31,67.62) 128.16,67.77 U0400.A62
  BOTTOM w0.203: U0400.A66 127.01,70.28 127.02,70.28 127.08,70.26 128.82,70.26 v3(128.95,70.13)
  BOTTOM w0.229: U0400.A58 127.63,65.29 127.81,65.1 v3(128.03,65.1)
  vias: v1(118.47,79.45) v1(118.47,78.67) v1(118.47,77.98) v1(118.47,77.29) v1(118.49,76.43) v1(121.31,79.78) v1(121.31,78.89) v1(121.31,78.01) v1(121.31,77.12) v1(122.3,76.3) v3(104.48,70.46) v3(108.1,68.77) v3(112.37,67.08) v3(112.4,65.99) v3(112.6,74.91) v3(112.85,64.71) v3(112.85,64.15) v3(112.9,63.22) v3(112.9,62.66) v3(112.93,67.08) v3(113,66.3) v3(113,65.74) v3(114.2,62.09) v3(114.3,66.42) v3(114.22,63.38) v3(114.21,61.53) v3(114.58,67.16) v3(114.61,65.89) v3(114.86,66.42) v3(115.35,63.36) v3(115.49,62.09) v3(115.48,61.53) v3(115.95,67.11) v3(115.95,65.89) v3(116.1,72.37) v3(116.08,71.76) v3(116.13,70.39) v3(116.13,69.78) v3(116.13,68.48) v3(116.43,66.42) v3(116.84,63.35) v3(116.87,62.09) v3(116.88,61.53) v3(116.99,66.42) v3(117.37,67.11) v3(117.35,65.86) v3(117.91,71.05) v3(117.93,73.66) v3(117.96,73.03) v3(117.93,71.68) v3(118,69.71) v3(118,69.16) v3(118.2,63.36) v3(118.2,62.09) v3(118.22,61.53) v3(118.49,66.42) v3(118.77,67.08) v3(118.75,65.86) v3(118.87,73.64) v3(118.87,73) v3(118.85,72.37) v3(118.9,71.73) v3(118.87,71.07) v3(118.87,70.46) v3(118.9,69.73) v3(118.92,69.07) v3(118.95,68.46) v3(119.05,66.42) v3(119.35,63.25) v3(119.76,73.71) v3(119.76,73.03) v3(119.8,70.31) v3(119.79,69.73) v3(119.88,72.36) v3(119.88,71.71) v3(119.86,68.46) v3(119.9,62.64) v3(119.91,63.25) v3(120.07,67.11) v3(120.09,65.86) v3(120.14,66.42) v3(120.7,66.42) v3(120.92,62.32) v3(120.92,61.74) v3(121.54,66.93) v3(121.54,66.37) v3(121.58,65.07) v3(121.58,64.52) v3(121.6,63.43) v3(121.59,62.87) v3(121.56,62.31) v3(121.56,61.75) v4(126.37,84.76) v4(127.08,83.97) v4(127.99,83.09) v4(140.41,72.85) v4(140.59,74.78) v4(140.56,67.95) v4(140.61,73.71) v4(141.22,72.52) v4(141.33,74.22) v4(141.63,67.95) v4(141.76,73.28) v4(142.27,74.22) v4(142.21,72.52) v4(142.67,73.28) v4(143.13,74.25) v4(143.13,72.52) v4(143.18,71.58) v4(143.59,73.26) v4(144.02,74.25) v4(144.04,72.49) v4(144.07,71.58)
+VCCGT_CSN_A: length 70.2
  TOP w0.229: PR7810.2 PC7811.2 PC7813.1 179.65,42.83 v2(180.21,42.83) 180.8,43.41 PR7807.2 180.54,45.97 PC7809.2 PC7810.2 181.31,47.6 181.53,47.38 v1(181.53,46.69)
  TOP w0.254: PR8010.2 142.53,67.03 v1(141.14,65.64)
  IN1 w0.254: v1(141.14,65.64) 141.97,66.47 147.82,66.47 149.78,64.52 153.24,64.52 155.42,62.33 155.42,60.71 156.87,59.26 162.94,59.26 164.66,57.53 173.2,57.53 174.37,58.7 176.28,58.7 177.9,57.08 178.28,57.08 179.45,55.91 179.45,53.24 180.19,52.5 180.19,50.5 181.53,49.16 v1(181.53,46.69)
  BOTTOM w0.254: v1(141.14,65.64) 141.72,66.22 PRT7801.2
+VCCGT_CSP_A: length 62.4
  TOP w0.229: v1(178.08,47.27) 178.71,47.27 179.04,47.6 PC7810.1 PC7809.1 179.68,45.97 PR7807.1 179.93,44.78 v2(180.14,44.58)
  TOP w0.254: v1(141.83,65.64) 142.32,66.12 143.23,66.12 PR8009.2 PR7805.1
  IN1 w0.254: v1(141.83,65.64) 142.32,66.12 147.67,66.12 149.63,64.16 153.04,64.16 154.94,62.26 154.94,60.61 156.64,58.91 162.79,58.91 164.52,57.18 173.35,57.18 174.42,58.24 176.1,58.24 177.62,56.72 178.09,56.72 179.09,55.72 179.09,52.81 179.27,52.63 179.27,48.42 178.13,47.27 v1(178.08,47.27)
  BOTTOM w0.229: v1(178.08,47.27) 177.95,47.27 177.57,47.65 PU7800.19
+VCCGT_FCCM: length 1.3
  BOTTOM w0.254: PU8001.7 160.66,63.13 160.28,62.74 PR8015.2
+VCCGT_HG_D: length 8
  TOP w0.635: v4(159.51,65.59) 159.51,64.57 v2(159.46,64.52)
  IN1 w0.635: v4(157.89,70.39) 159.51,68.76 v4(159.51,65.59)
  BOTTOM w0.508: PR8006.1 157.89,71.37 157.89,70.39 v4(157.89,70.39)
+VCCGT_LG_D: length 25.5
  TOP w0.508: PR8012.1 v2(145.34,73.13)
  TOP w0.635: PR8012.1 146.44,74.01 v4(146.15,74.3)
  IN1 w0.635: v4(146.15,74.3) 147.73,74.3 149,73.03 149,69.78 149.96,68.81 152.68,68.81 154.13,67.36 154.13,66.29 156.79,63.63 161.78,63.63 v4(162.18,63.22)
+VCCGT_PHASE_D: length 9.1
  TOP w0.635: v2(157.43,63.71) v4(157.43,64.82)
  IN1 w0.635: v4(156.11,72.23) 156.11,66.15 v4(157.43,64.82)
+VCCGT_PWM: length 2.4
  BOTTOM w0.254: v2(162.46,66.53) 162.23,66.53 161.99,66.77 PR8016.2 161.16,66.38 PU8001.3
+VCCGT_R_BT_D: length 1.2
  BOTTOM w0.508: v2(157.76,67.8) 157.99,67.8 PR8007.2
+VCCGT_R_HG_D:
  vias: v2(157.1,74.63)
+VCCGT_R_LG_D: length 0.8
  BOTTOM w0.635: 149.96,74.2 150.47,74.7 v2(150.52,74.7)
  vias: v4(149.15,74.33)
+VCCGT_SN_C:
  vias: v2(147.73,71.58)
+VCCIO: length 16.5
  TOP w0.432: R0413.2 124.9,61.45 v3(124.85,61.4)
  TOP w0.508: v1(132.74,25.43) 132.89,25.43 v2(133.36,24.96)
  IN3 w0.762: 111.76,57.3 111.76,60.86 112.09,61.19 113.51,61.19 113.88,60.82 122.9,60.82
  vias: v1(132.36,24.84) v1(132.36,24.23) v1(132.36,23.62) v1(132.36,23.01) v3(110.8,49.54) v3(112.15,49.53) v3(112.5,56.92) v3(112.55,56.29) v3(112.72,50.19) v3(112.71,49.53)
+VCCPGPP: length 2.9
  BOTTOM w0.254: U0400.Y15 116.75,40.83 v3(116.42,41.16) 116.75,41.48 U0400.Y16 ; U0400.T16 118.8,41.19 v3(118.89,41.19) ; v3(113.94,41.15) 113.79,41.15 U0400.AG15 ; U0400.AD15 115.15,40.63 v3(115.52,40.26)
  vias: v2(119.76,30.81)
+VCCPLL_OC: length 117
  TOP w0.508: v4(73.71,24.82) v2(73.71,25.66)
  IN1 w0.762: v4(73.71,24.82) 74.47,25.57 77.44,25.57 83.17,31.3 83.62,31.3 87.08,34.75 91.98,34.75
  IN2 w0.762: v4(47.22,47.06) 47.22,51.77 46.38,52.61 46.38,54.59 47.24,55.45 47.24,62.08 48.67,63.5 48.67,69.95 46.86,71.76 46.33,71.76 45.82,72.27 v4(45.82,72.62)
  IN3 w0.762: v4(47.22,47.06) 47.22,45.69 48.07,44.83 48.16,44.83 49.33,43.66 49.33,28.66 50.63,27.36 51.42,27.36 52.21,26.57 52.21,25.07 52.97,24.31 54.67,24.31 56.7,22.28 63.22,22.28 63.65,21.85 68.54,21.85 70.08,23.38 72.68,23.38 73.71,24.41 v4(73.71,24.82)
  BOTTOM w0.203: v3(112.44,45.93) 112.39,45.88 U0400.AL23
  BOTTOM w0.762: 32.13,68.07 33.68,68.07 v2(34.34,68.73) 36.2,70.59 39.7,70.59 40.08,70.97 43.84,70.97 45.49,72.62 v4(45.82,72.62)
  vias: v1(30.12,68.15) v1(30.99,66.86)
+VCCPRIM_CORE: length 2.1
  TOP w0.432: C1632.1 133.4,20.75
  BOTTOM w0.254: U0400.AF19 114.41,43.43 v3(114.73,43.11) 114.41,42.78 U0400.AF18
  vias: v1(117.22,26.95) v1(117.22,26.34) v1(117.78,26.7) v1(117.78,26.09) v2(126.57,16.82) v3(115.57,45.44) v3(116.12,45.44) v3(116.71,45.44) v4(115.34,20.81) v4(116.23,20.81) v4(117.09,20.81)
+VCCSA: length 41.8
  IN1 w0.254: v1(170.99,42.29) 170.99,43.56 172.65,45.22 172.65,45.9 172.53,46.03 171.6,46.03 171.53,46.1 165.84,46.1 164.77,47.17 163.63,47.17 163.09,46.63 163.09,46.08 162.63,45.62 161.79,45.62 159.58,43.41 149.89,43.41 147.73,41.25 142.25,41.25 141.76,40.76 141.76,40.49 v4(140.64,39.37)
  BOTTOM w0.254: R0608.2 170.38,42.47 170.56,42.29 v1(170.99,42.29)
  vias: v1(141.2,37.95) v1(141.2,36.07) v1(141.22,38.92) v1(141.22,36.98) v2(139.65,39.07) v3(113.08,47.17) v3(113.08,46.59) v3(114.07,46.23) v3(114.66,46.23) v3(115.24,46.23) v3(116.28,46.74) v3(116.97,46.28) v3(117.58,46.28) v3(118.19,46.28) v3(118.7,46.92) v3(119.27,46.92) v3(119.95,46.92) v3(120.54,46.92) v3(121.36,46.92) v3(121.41,47.83) v3(121.69,48.34) v3(121.72,47.35) v4(140.59,36.53) v4(140.64,38.46) v4(140.61,37.44)
+VCCSA_BT_D: length 3.1
  BOTTOM w0.279: 148.72,30.66 148.29,30.66 v2(148.22,30.6) 147.45,29.82 PU8000.2
  BOTTOM w0.508: 148.72,30.66 149.06,31 PR8000.1
+VCCSA_CSN_A: length 46.8
  TOP w0.254: PR7835.1 170.87,43.21 PR7838.1 v2(169.67,42.9) 168.88,42.9 167.87,43.91 167.87,44.5 v1(168.88,45.52) ; v1(163.83,46.69) 164.16,47.02 164.9,47.02 PC7829.1 165.94,46.48 166.17,46.71 PR7831.2 PC7827.2 PC7828.2
  IN1 w0.254: v1(163.83,46.69) 163.83,46.21 162.89,45.27 162.01,45.27 159.46,42.72 159.46,38.92 158.01,37.47 153.59,37.47 149.63,33.51 145.11,33.51 144.42,32.82 144.42,31.99 v1(144.21,31.78)
  IN3 w0.254: v1(163.83,46.69) 164.87,45.65 168.76,45.65 v1(168.88,45.52)
  BOTTOM w0.254: PR8005.2 PRT7802.2 143.99,32 v1(144.21,31.78)
+VCCSA_CSP_A: length 47.7
  TOP w0.254: v1(173.79,45.4) 173.52,45.67 172.94,45.67 172.31,45.05 170.14,45.05 v2(169.72,45.47) 169.03,46.15 168.45,46.15 PC7828.1 PC7827.1 PR7831.1 165.71,45.85 PR7827.1
  IN1 w0.254: v1(161.15,38.33) 159.88,38.33 158.31,36.76 153.89,36.76 149.21,32.08 146.81,32.08 v1(146.48,32.41)
  IN2 w0.254: v1(173.79,45.4) 173.96,45.22 173.96,41.1 170.78,37.92 161.57,37.92 v1(161.15,38.33)
  BOTTOM w0.229: PU7800.27 174.3,46.24 173.79,45.72 v1(173.79,45.4)
  BOTTOM w0.254: PR8004.2 146.46,32.39 v1(146.48,32.41)
+VCCSA_FCCM: length 2.2
  BOTTOM w0.254: PU8000.7 144.84,29.82 144.6,30.05 v2(144.45,30.05) 144.17,30.05 143.84,29.72 PR8013.2
+VCCSA_HG_D: length 7.9
  TOP w0.635: v1(147.55,30.94) 147.55,31.04 150.04,33.53 v2(150.04,34.24) 151.51,35.72 PR8001.1
  BOTTOM w0.279: PU8000.1 147.38,30.32 147.55,30.48 v1(147.55,30.94)
+VCCSA_LG_D: length 8.1
  BOTTOM w0.635: PR8003.1 151.44,30.66 150.75,29.97 150.75,29.74 148.84,27.83 147.79,27.83 147.45,28.17 145.34,28.17
  vias: v2(144.58,27.71)
+VCCSA_PHASE_D: length 8
  TOP w0.508: PR8002.2 PC8004.2 v4(149.23,40.31) v2(149.23,41.1)
  BOTTOM w0.508: 148.11,34.37 148.11,33.61 147.29,32.79 147.29,31.98 PC8000.2 146.74,31.42 146.05,31.42 145.47,30.84 145.36,30.84
+VCCSA_PWM: length 2.4
  BOTTOM w0.279: v2(148.51,28.7) PR8014.2 147.77,29.61 147.49,29.32 PU8000.3
+VCCSA_R_BT_D: length 2
  BOTTOM w0.508: PR8000.2 148.95,32.71 148.69,32.45 148.69,32.01 PC8000.1
+VCCSA_R_HG_D:
  vias: v2(151.87,39.12) v4(150.95,38.94)
+VCCSA_R_LG_D:
  vias: v2(150.98,33.81)
+VCCST: length 251.7
  TOP w0.305: v3(121.36,45.09) 121.59,45.09 C0623.1 C0622.1
  TOP w0.432: v2(42.77,25.4) 42.67,25.3 R2321.2 41.61,25 41.61,24.51 v1(41.12,24.03) ; C0619.1 128.13,43.72 127.96,43.55 v3(127.96,43.1) ; PR7846.2 167.01,50.57 v1(167.44,50.14) 167.44,49.79 167.54,49.68 PC7836.1 167.54,48.92 167.79,48.67 PR7847.2
  TOP w0.508: v1(101.4,15.04) 101.52,15.16 104.26,15.16 104.6,15.5 104.6,17.38 105.28,18.07 v1(105.28,20.68) ; v3(127.96,43.1) 127.96,41.9 128.79,41.07 128.79,39.39 129.41,38.76 v3(129.41,38.08)
  IN1 w0.254: 128.04,44.4 128.58,44.4 128.73,44.55 129.79,44.55 130.33,45.09 130.33,45.98 130,46.31 128.74,46.31 127.79,47.26 127.79,48.92 130.07,51.21 130.07,51.46 130.78,52.17 130.78,52.53 132.74,54.49 132.74,55.48 132.66,55.55 132.66,58.55 v1(133.07,58.96)
  IN2 w0.508: v1(138.1,32.39) 138.12,32.39 138.45,32.72 138.45,33.23 137.79,33.89 135.85,33.89 135.37,33.41 132.42,33.41 130.15,35.68 130.15,36.15 129.37,36.93 129.37,38.03 v3(129.41,38.08) ; v1(167.44,50.14) 165.18,52.4 161.75,52.4 161.52,52.63 159.99,52.63 159.54,52.17 155.55,52.17 153.9,50.52 153.9,45.37 158.04,41.23 158.04,38.13 156.29,36.38 153.4,36.38 148.58,31.55 147.14,31.55 146.96,31.37 145.92,31.37 144.27,29.72 139.98,29.72 139.77,29.93 v1(138.99,29.93) 138.9,29.93 136.88,27.92 132.34,27.92 131.9,27.48 131.9,26.46 129.72,24.27 129.72,22.79 v1(128.35,21.41) 127.53,20.6 124.69,20.6 123.01,22.28 120.14,22.28 119.38,21.52 119.38,20.98 117.46,19.05 115.28,19.05 114.42,19.92 111.84,19.92 111.15,20.6 110.47,20.6 110.39,20.68 v1(105.28,20.68) 104.27,19.66 98.93,19.66 98.7,19.9 91.62,19.9 90.17,18.44 81.28,18.44 79.05,16.21 77.27,16.21 77.14,16.08 73.58,16.08 72.74,15.23 71.19,15.23 70.24,16.18 70.24,16.21 69.96,16.49 69.37,16.49 68.5,17.35 66.28,17.35 65.46,18.16 64.3,18.16 63.69,17.55 62.09,17.55 61.66,17.99 55.54,17.99 53.89,19.64 46.48,19.64 46.26,19.41 44,19.41 41.12,22.29 v1(41.12,24.03)
  IN3 w0.254: v1(136.31,64.44) 135.12,63.25 135.12,61.18 133.07,59.13 v1(133.07,58.96)
  IN3 w0.508: v1(138.99,29.93) 138.1,30.82 v1(138.1,32.39)
  BOTTOM w0.203: v3(127.96,43.1) 127.85,42.99 U0400.A18
  BOTTOM w0.254: R0417.1 134.04,63.71 134.39,64.06 134.85,64.06 R0902.2 135.38,65.05 135.37,65.06 R0601.2 R0602.2 ; v3(121.36,45.09) 121.5,45.09 U0400.K21 U0400.K20
  BOTTOM w0.305: v1(136.31,64.44) 136.16,64.59 R0902.2
  BOTTOM w0.432: R1224.1 98.55,17.05 99.44,16.16 100.84,16.16 101.4,15.6 v1(101.4,15.04)
  BOTTOM w0.508: PR9202.1 133.86,21.67 133.35,22.18 132.46,22.18 131.7,21.41 v1(128.35,21.41)
+VCCSTG: length 89.7
  TOP w0.254: v1(143.03,31.6) 139.98,31.6 139.57,31.19 139.41,31.19 137.57,29.35 137.57,27.51 v1(137.77,27.3) ; R0401.2 R0402.2 130.73,77.37 131.45,76.66 131.45,74.3 130.02,72.87 130.02,69.31 132.15,67.19 v1(132.23,67.19) ; v1(134.52,63.38) 134.86,63.72 v1(136.36,63.72)
  TOP w0.432: v3(127.74,45.41) 127.71,45.41 127.63,45.49 C0620.1
  IN1 w0.254: v1(132.42,58.99) 131.9,58.47 131.9,55.6 132.39,55.12 132.39,54.64 130.43,52.68 130.43,52.33 129.69,51.59 129.69,51.34 127.25,48.9 127.25,45.86 127.71,45.41 v3(127.74,45.41)
  IN3 w0.254: 124.46,44.45 126.06,44.45 127,45.39 127.72,45.39 v3(127.74,45.41) ; v1(132.42,58.99) 134.76,61.33 134.76,63.13 v1(134.52,63.38) 133.94,63.38 132.7,64.61 132.7,66.72 v1(132.23,67.19)
  BOTTOM w0.254: PR9208.1 137.44,27.64 v1(137.77,27.3) ; v3(123.1,44.05) 123.1,43.77 U0400.G20 ; v1(143.03,31.6) 141.5,31.6 139.14,33.96 139.14,38.59 137.81,39.92 137.81,43.11 133.82,47.09 132.08,47.09 131.39,46.41 129.82,46.41 129.49,46.08 128.47,46.08 128.07,45.67 128.01,45.67 127.74,45.41 v3(127.74,45.41) 127.72,45.39 127.04,45.39 U0400.A22 ; R0400.1 136.79,65.19 136.79,64.15 v1(136.36,63.72) v2(134.9,62.26) 134.49,61.85 R0403.2
+VDD: length 6.4
  TOP w0.432: PR7706.1 PR7705.1 196.65,29.01 196.44,28.81 195.3,28.81 v1(194.84,28.35) 194.84,28.02 v2(195.33,27.54)
  BOTTOM w0.229: PU7700.18 194.99,28.21
  BOTTOM w0.254: 194.99,28.21 v1(194.84,28.35)
  BOTTOM w0.508: v1(194.84,28.35) 194.36,28.83 PC7713.1
+VDDC_COMP_A: length 5
  BOTTOM w0.222: 113,96.88 112.98,96.9 112.98,97.67 112.87,97.77 PU9400.5
  BOTTOM w0.254: 113,96.88 113.45,96.44 PC9415.2 113.8,96.09 114.5,95.38 114.63,95.38 v2(114.66,95.35) PR9454.1
+VDDC_COMP_FB_R_A: length 5.2
  BOTTOM w0.222: PU9400.6 112.47,97.47 112.47,97.46 v2(112.47,97.41) 112.47,96.62
  BOTTOM w0.254: 112.47,96.62 112.58,96.51 PC9415.1 112.58,95.33 PR9433.1 PC9416.2 113.84,95.25 PR9432.2
+VDDC_COMP_L_A: length 0.9
  BOTTOM w0.254: PR9432.1 PR9454.2
+VDDC_HG1_2_D:
  vias: v2(130.02,95.43)
+VDDC_IMON_A: length 2.8
  BOTTOM w0.222: 109.85,100.01 PU9400.14
  BOTTOM w0.254: PR9447.2 108.38,100.05 v2(108.97,100.64) 109.22,100.64 109.85,100.01
+VDDC_IMON_L_A: length 58.3
  TOP w0.102: v2(103.25,101.88) 103.25,101.09 103.33,101.02 103.33,100.26 v1(103.18,100.1)
  IN2 w0.254: v1(131.72,84.94) 131.65,85.02 131.14,85.02 130.63,85.52 126.39,85.52 125.51,86.4 118.85,86.4 115.77,89.49 114.76,89.49 114.22,88.95 111.96,88.95 108.26,92.66 105.46,92.66 103.81,94.31 103.81,99.34 103.18,99.98 v1(103.18,100.1)
  BOTTOM w0.254: PRT9401.2 137.99,97.08 137.23,96.32 136.03,96.32 134.15,94.44 134.15,88.86 133.5,88.21 v2(132.89,88.21) 132.49,87.81 132.49,87.25 131.24,86.01 131.24,85.19 131.5,84.94 v1(131.72,84.94) ; PR9445.1 104.22,99.42 103.53,100.1 v1(103.18,100.1)
+VDDC_IMON_R_A: length 2.6
  BOTTOM w0.254: PR9445.2 105.47,99.33 105.51,99.37 PR9446.2 106.16,99.6 107.11,99.6 107.2,99.68 PR9447.1
+VDDC_ISEN1P_R_A: length 18.6
  TOP w0.254: v1(111.31,91.09) 111.31,92.05 109.96,93.4 109.96,93.98 110.21,94.23 v2(110.21,94.72) 110.21,95.78 v1(110.39,95.96)
  BOTTOM w0.222: PU9400.9 111.27,97.81 110.53,97.07
  BOTTOM w0.254: PR9420.1 PR9422.2 108.13,91.37 108.61,90.88 111.1,90.88 v1(111.31,91.09) ; 110.53,97.07 110.53,96.79 109.27,95.53 108.41,95.53 108.26,95.38 PC9410.1 108.71,95.09 108.76,95.04 PC9424.1 PR9419.1 110.11,95.43 110.39,95.71 v1(110.39,95.96)
+VDDC_ISEN2P_R_A: length 8.5
  BOTTOM w0.222: PU9400.7 112.07,97.78 111.96,97.67 111.96,97.03 111.84,96.9 PC9412.1
  BOTTOM w0.254: PC9412.1 PC9425.1 111.39,95.21 111.39,95.21 111,94.83 111,93.67 111.26,93.41 111.44,93.41 PR9429.1 111.51,92.59 111.43,92.59 PR9431.2 PR9424.1
+VDDC_ISEN_A: length 7.1
  BOTTOM w0.222: PU9400.10 110.87,97.9 110.17,97.2
  BOTTOM w0.254: v2(105.49,95.02) 105.54,94.97 PR9428.1 PR9425.1 108.2,95.89 109.13,95.89 110.17,96.93 110.17,97.2
+VDDC_ISN1_A: length 48.6
  TOP w0.254: v1(109.26,93.56) 109.26,92.85 v2(109.25,92.84)
  IN1 w0.254: v1(109.26,93.56) 110.85,91.97 111.1,91.97 112.85,90.22 113.5,90.22 113.81,90.53 115.34,90.53 115.7,90.17 128.09,90.17 129.54,91.62 129.54,95.58 132.72,98.76 138,98.76 139.62,100.39 139.62,103.15 v1(139.7,103.23)
  BOTTOM w0.229: PJP9601.2 139.8,103.13 v1(139.7,103.23)
  BOTTOM w0.254: PR9422.1 PC9411.1 ; PC9411.1 109.07,93.25 109.25,93.42 109.25,93.55 v1(109.26,93.56) 109.26,93.58 109.25,93.59 109.25,94.12 PC9424.2 109.14,94.22 PC9410.2 107.76,94.22 107.65,94.11 PR9425.2 ; PC9411.1 PR9424.2
+VDDC_ISN2_A: length 51.8
  TOP w0.254: v1(111.83,90.56) 111.83,92.47 v2(111.18,93.12) 111.03,93.12 110.56,93.6 v1(110.52,93.6)
  IN1 w0.254: v1(131.6,109.96) 131.55,109.96 130.51,108.91 130.51,104.07 129.46,103.02 126.37,103.02 123.43,100.09 120.92,100.09 114,93.17 110.95,93.17 v1(110.52,93.6)
  BOTTOM w0.229: PJP9603.2 132.13,109.43 v1(131.6,109.96)
  BOTTOM w0.254: PR9431.1 110.52,93.39 v1(110.52,93.6) 110.52,93.76 PR9419.2 110.64,94.71 110.64,95.33 PC9425.2 PC9412.2 ; PR9428.2 106.35,93.58 106.25,93.47 PC9414.1 104.93,91.65 104.93,90.93 105.64,90.22 111.49,90.22 v1(111.83,90.56)
+VDDC_ISP1_A: length 43.8
  TOP w0.254: v2(108.31,94.41) 108.31,93.99 v1(108.64,93.66)
  IN1 w0.254: v1(108.64,93.66) 109.03,94.05 109.46,94.05 109.81,93.69 109.81,93.62 111.11,92.33 111.25,92.33 113,90.58 113.36,90.58 113.66,90.88 115.54,90.88 115.85,90.58 128,90.58 129.18,91.77 129.18,95.73 136.66,103.2 v1(139.09,103.2)
  BOTTOM w0.229: PJP9600.2 v1(139.09,103.2)
  BOTTOM w0.254: PR9420.2 107.88,93.66 v1(108.64,93.66)
+VDDC_ISP2_A: length 33.7
  TOP w0.508: v2(112.92,90.52) 113.23,90.83 v1(113.23,91.14)
  IN1 w0.254: v1(113.23,91.14) 113.23,91.82 121.14,99.73 123.63,99.73 126.52,102.62 129.97,102.62 130.86,103.51 130.86,108.59 v1(131.57,109.3)
  BOTTOM w0.229: PJP9602.2 131.42,109.45 v1(131.57,109.3)
  BOTTOM w0.254: v1(113.23,91.14) 113.13,91.04 112.55,91.04 111.89,91.7 PR9429.2
+VDDC_LG1_2_D: length 2.2
  BOTTOM w0.254: 134.37,96.6 135.66,96.6 135.97,96.9 v2(135.97,97.39)
+VDDC_LG2_2_D: length 0.6
  TOP w0.102: v1(125.83,105.82) v2(126.47,105.82)
+VDDC_PWROK: length 126.2
  TOP w0.102: PR9815.1 193.29,64.42 193.1,64.61 v2(193.1,64.96) 193.1,65.24 v1(193.41,65.55)
  IN1 w0.102: v1(193.41,65.55) 193.41,64.94 190.83,62.36 180.14,62.36 177.9,64.6 177.9,65.2 176.36,66.73 173.92,66.73 172.6,68.05 169.63,68.05 167.78,69.9 166.76,69.9 165.41,71.25 162.25,71.25 159.13,74.37 153.73,74.37 149.82,78.29 148.34,78.29 147.55,77.5 v1(147.24,77.5)
  IN2 w0.102: v1(140.87,87.92) 142.09,86.7 142.09,84.2 142.29,84 142.29,82.61 143.85,81.05 144.04,81.05 145.97,79.12 145.97,77.93 146.41,77.5 v1(147.24,77.5)
  IN2 w0.254: v1(140.87,87.92) 140.05,87.92 139.37,88.6 139.37,88.9 138.84,89.43 135.54,89.43 133.55,91.42 132.77,91.42 131.8,92.38 130.02,92.38 128.85,91.21 121.27,91.21 117.79,94.69 117.79,97.35 118.31,97.87 118.31,101.8 117.83,102.29 117.83,105.74 117.45,106.12 107.34,106.12 105.77,104.55 105.77,104.34 v1(104.89,103.46)
  BOTTOM w0.254: v1(104.89,103.46) 105,103.36 PR9412.2 ; v1(140.87,87.92) 141.98,87.92 142.4,87.49 U6903.4
+VDDC_PWROK_A: length 5.4
  BOTTOM w0.222: PU9400.18 109.77,101.61 109.12,102.26 108.67,102.26 PR9457.2
  BOTTOM w0.254: PR9412.1 106.68,103.36 107.04,103.71 v2(107.47,103.71) 107.95,103.71 108.29,103.37 PR9457.2
+VDDC_SET1: length 4.9
  BOTTOM w0.222: PU9400.13 109.74,99.61 109.09,98.96 v2(109.09,98.86)
  BOTTOM w0.432: v2(109.09,98.86) 108.98,98.75 PR9435.2 108.31,98.63 108.23,98.55 108.22,98.55 107.76,98.1 106.65,98.1 106.58,98.17 PR9438.1
+VDDC_SET1_R1_A: length 7.1
  BOTTOM w0.254: PR9435.1 107.44,98.92 107.13,99.23 106.63,99.23 106.11,98.71 103.97,98.71 103.73,98.94 103.73,99.27 103.51,99.49 102.84,99.49 v2(102.77,99.42) 102.65,99.3 102.65,98.67 102.77,98.55 PR9434.2
+VDDC_SET1_R2_A: length 0.9
  BOTTOM w0.254: PR9437.2 PR9438.2
+VDDC_SN1_A:
  vias: v2(137.68,102.26)
+VDDC_SN2_A:
  vias: v2(130,108.36)
+VDDC_TS_R1_A: length 0.8
  BOTTOM w0.254: PR9440.1 PR9439.2
+VDDC_TS_R2_A: length 2.3
  BOTTOM w0.102: PR9443.2 102.77,96.22 102.39,95.84 102.21,95.84 v2(101.7,95.33)
  BOTTOM w0.254: PR9444.1 PR9443.2
+VDDC_TSEN: length 53.1
  IN2 w0.508: v1(134.44,86.82) 134.19,87.07 127.15,87.07 126.26,87.96 119.49,87.96 115.3,92.15 112.83,92.15 109.88,95.1 106.93,95.1 105.94,96.09 v1(105.94,96.47)
  BOTTOM w0.222: PU9400.12 109.9,99.21 109.6,98.91 109.6,98.53 109.09,98.02
  BOTTOM w0.406: 109.09,98.02 108.43,98.02 107.95,97.54 107.95,97.53 107.9,97.48
  BOTTOM w0.432: v1(105.94,96.47) 106.07,96.6 106.53,96.6 106.63,96.7 PR9442.2 107.44,96.7 107.9,97.16 107.9,97.22 107.9,97.22 107.9,97.48 ; v1(134.44,86.82) v2(135.11,87.49) 135.48,87.86 135.48,89.21 136.14,89.87 138.4,89.87 140.54,92.01 PRT9400.2
+VDDC_TSEN_A: length 1.2
  BOTTOM w0.432: PR9441.2 106.5,97.56 PR9442.1
+VDDC_TSEN_P: length 51.7
  IN2 w0.508: v1(105.33,96.47) 105.31,96.45 105.31,95.81 106.78,94.34 109.35,94.34 109.91,93.78 109.91,93.35 112.73,90.53 113.49,90.53 113.84,90.88 115.65,90.88 119.23,87.3 126.01,87.3 126.87,86.44 132.97,86.44 133.07,86.33 134.03,86.33 v1(134.05,86.35)
  BOTTOM w0.432: PR9441.1 105.31,96.5 v1(105.33,96.47) 105.16,96.29 PR9444.2 PR9440.2 ; PRT9400.1 139.67,96.87 v2(139.94,96.6) 139.95,96.59 139.95,92.18 138.17,90.4 135.92,90.4 134.95,89.43 134.95,88.24 133.87,87.16 133.87,86.53 v1(134.05,86.35)
+VDDC_VGA: length 37.5
  TOP w0.432: C6724.1 159.93,82.58 160.15,82.58 v1(160.4,82.83) 160.61,83.04 C6705.1
  TOP w0.508: 142.67,97.41 135.67,97.41 132.27,94.01 v2(131.09,94.01) 129.02,94.01 127.48,92.47 127.48,91.24 126.94,90.69 119.05,90.69 v1(118.68,91.06)
  BOTTOM w0.432: v1(162.81,87.94) 163.23,87.52 U6000.T15 163.23,87.36 v1(162.79,86.92) ; R7203.2 155,106.91 ; v1(118.68,91.06) 118.25,90.63 115.09,90.63 113.77,91.95 PR9430.2
  vias: v1(157.3,86.29) v1(157.25,85.4) v1(157.86,85.17) v1(158.12,83.87) v1(159.87,86.97) v1(159.91,92.74) v1(159.95,85.93) v1(160.81,86.9) v1(160.91,90.78) v1(160.88,87.96) v1(160.93,91.85) v1(160.99,89.66) v1(162.03,85.96) v1(162.76,83.87) v1(162.84,91.72) v1(162.84,89.69) v1(162.84,85.93) v1(162.84,84.91) v1(163.73,91.85) v1(164.74,89.71) v1(164.74,85.85) v1(165.66,86.92) v1(165.71,92.66) v1(165.76,91.82) v1(165.76,90.68) v1(165.71,89.64) v1(165.71,88.8) v1(165.74,88.01) v1(165.74,84.89) v4(133.81,111.46) v4(134.67,111.46) v4(135.61,111.51) v4(136.25,110.39) v4(136.27,109.48) v4(136.27,107.95) v4(136.7,108.71) v4(137.16,110.39) v4(137.13,109.53) v4(137.16,107.95) v4(137.59,108.71) v4(138.02,110.39) v4(138.02,109.5) v4(138.05,107.95) v4(138.46,108.71) v4(138.89,110.42) v4(138.89,109.5) v4(138.91,107.95) v4(139.37,111.23) v4(139.32,108.71) v4(139.8,110.44) v4(139.78,109.53) v4(139.78,107.95) v4(140.21,108.71) v4(140.64,109.5) v4(140.64,107.95) v4(141.1,108.71) v4(141.53,107.95) v4(142.01,108.77) v4(142.44,107.95) v4(142.65,99.01) v4(143.51,99.01) v4(144.27,102.62) v4(144.32,101.75) v4(144.35,100.89) v4(144.35,100.03) v4(144.37,99.06) v4(145.21,102.67) v4(145.24,101.81) v4(145.24,100.92) v4(145.24,100.05) v4(145.24,99.09) v4(146.1,102.69) v4(146.1,101.78) v4(146.1,100.87) v4(146.1,100) v4(146.1,99.11)
+VDDC_VGA_DISCH_A: length 1.5
  BOTTOM w0.432: R7203.1 156.4,107.77 Q7203.3
+VDDC_VIN: length 6.8
  TOP w0.508: v1(116.84,109.17) 115.37,109.17 115.29,109.25 114.3,109.25 113.23,108.18 v2(112.95,108.18) 112.93,108.18 v1(111.86,107.11)
  BOTTOM w0.508: v1(111.86,107.11) 111.99,107.24 PR9408.2
  vias: v1(116.84,109.78) v1(117.45,109.78) v1(117.45,109.17) v1(118.08,109.78) v1(118.06,109.17) v1(124.82,100.08) v1(124.82,99.47) v1(125.43,100.08) v1(125.43,99.45) v1(126.04,100.07) v1(126.05,99.46)
+VDDP: length 11.4
  TOP w0.508: PR7705.2 194.36,29.62 193.95,29.21 v2(193.95,28.68) v1(193.95,27.74)
  IN2 w0.508: v1(193.95,27.74) 192.58,26.37 192.58,24.74 192.86,24.46 v1(192.86,23.32)
  BOTTOM w0.229: 193.52,23.09 193.93,23.09 194.59,23.75 PU7700.8
  BOTTOM w0.432: v1(192.86,23.32) 192.62,23.08 PC7714.1 193.04,22.61 193.52,23.09
+VDDQ_PWRGD: length 211.1
  TOP w0.089: v1(68.17,9.3) 67.82,8.95 67.82,7.9 67.81,7.89 67.81,7.89 67.67,7.74 v2(67.67,7.34) 67.8,7.2 67.98,7.2 68.4,7.62 R1803.1
  TOP w0.102: PU8600.10 102.28,98.62 103.16,99.49 PC8609.1 103.86,99.8 v1(104.24,100.18)
  IN1 w0.102: v1(68.17,9.3) 68.17,9.76 66.9,11.03 60.3,11.03 59.16,12.17 58.22,12.17 55.56,14.82 49.52,14.82 48.99,14.3 47.56,14.3 46.33,15.52 46.33,16.4 45.2,17.53 44.25,17.53 38.53,23.24 38.39,23.24 34.95,26.68 v1(34.95,26.82) ; v1(104.24,100.18) 104.45,100.38 104.45,101.27 103,102.72 103,105.07 100.42,107.65 96.04,107.65 92.69,111 81.84,111 81.28,110.44 74.19,110.44 71.73,107.98 60.57,107.98 57.42,104.83 55.03,104.83 51.81,101.61 49.93,101.61 48.82,100.5 48.82,97.67 v1(47.42,96.27)
  IN3 w0.102: v1(34.95,26.82) 34.52,27.26 32.95,27.26 31.6,28.61 31.6,32.05 29.65,33.99 29.65,39.39 28.68,40.37 28.68,41.94 28.68,43.97 27.05,45.6 27.05,48.28 27.05,48.29 27.05,55.25 23.85,58.45 23.34,58.45 22.32,59.47 22.32,69.87 23.09,70.64 23.75,70.64 27.54,74.43 27.54,79.59 29.08,81.13 29.08,84.15 31.06,86.13 32,86.13 32.57,86.71 38.33,86.71 40.61,88.99 40.61,91.03 45.85,96.27 v1(47.42,96.27)
AGND: length 27.9
  TOP w0.381: 11.63,26.04 11.63,25.28 ; 11.63,26.04 C3821.1 10.87,26.04 ; 11.63,26.04 11.63,26.39 11.38,26.65
  TOP w0.432: R3817.2 7.72,38.05 v1(7.72,38.51) ; v1(14.24,32.36) 14.24,31.92 14,31.68 R3816.2 ; v1(15.06,45.49) 15.27,45.7 R3815.2 ; C3824.2 13.22,33.35 v1(12.96,33.09) ; R3814.1 13.41,34.34 v1(12.98,33.91)
  TOP w0.508: v2(7.72,39.22) v1(7.72,38.51)
  IN1 w0.635: 7.68,42.39 J3800.5 8.69,43
  IN2 w0.635: 7.68,42.31 J3800.5 8.76,43
  IN3 w0.635: 7.68,42.31 J3800.5 8.76,43
  BOTTOM w0.229: U3800.22 15.64,25.98 15.31,25.65 v1(15.31,25.46)
  BOTTOM w0.381: 12.17,25.61 C3831.2 ; 13.27,23.98 C3825.2 ; C3826.2 15.43,23.98 ; 10.69,26.19 11.25,26.19 11.25,25.72
  BOTTOM w0.432: v1(15.01,41.86) 15.37,41.5 R3818.2 ; C3811.2 5.44,54.43 5.56,54.56 v1(5.94,54.56) ; v1(10.64,27.69) 10.64,27.79 11.58,28.72 C3815.2 ; C3829.2 v1(12.51,37.01)
  BOTTOM w0.457: C3810.2 v1(6.76,39.68)
  BOTTOM w0.508: v1(14.83,35.05) 15.04,35.26 C3820.2 ; C3812.2 15.01,49.53 v1(15.01,48.77) ; C3813.2 12.32,54.54 v1(12.7,54.92)
  BOTTOM w0.635: 7.68,42.31 J3800.5 8.76,43
  vias: v1(3.53,40.85) v1(3.53,39.14) v1(6.86,54.59) v1(7.59,52.73) v1(8.87,26.82) v1(8.92,51.72) v1(9.02,43.08) v1(10.55,26.18) v1(10.67,25.25) v1(11.89,25.2) v1(12.47,42.78) v1(12.57,49.71) v1(12.55,47.53) v1(12.57,45.14) v1(12.65,51.87) v1(13.11,23.85) v1(15.53,24.25)
GND: length 1876
  TOP w0.076: U2500.N2 97.78,19.03 97.78,18.32
  TOP w0.089: v1(97.73,18.21) 97.78,18.27 97.78,18.32
  TOP w0.102: v1(3.05,54.28) 2.95,54.18 2.95,53.42 2.72,53.19 1.3,53.19 0.94,53.55 0.94,54.61
  TOP w0.152: U2300.84 v1(36.1,29.56)
  TOP w0.178: U2300.64 27.73,29.9 v1(28.27,30.44) ; U2300.51 26.1,35.1 25.59,34.58 v1(25.5,34.58)
  TOP w0.191: v1(34.82,45.06) 34.5,44.74 U2300.17
  TOP w0.203: U2500.A6 100.3,25.56 v1(100.3,26.01) ; v1(99.66,23.82) 99.5,23.82 U2500.C4 ; v1(99.04,18.14) 99.04,18.77 U2500.P4 99.03,18.78 U2500.N5 ; U2300.124 40.84,40.7 v1(40.4,41.14) ; v1(100.25,18.14) 100.03,18.36 U2500.P6
  TOP w0.229: v1(36.2,88.27) 36.42,88.05 PU7600.2 ; U6803.N1 187.76,76.01 188.57,76.01 U6803.N3 ; v1(100.66,22.53) 100.66,23.15 U2500.E7 ; 44.35,30.15 44.35,30.63 43.89,31.1 U2300.100 ; U6801.E14 187.75,95.77 188.56,95.77 U6801.E12 ; PU8600.3 100.48,95.96 100.61,95.84 v1(100.61,95.18) ; U2500.H10 101.95,21.86 101.23,21.86 v1(100.8,21.43) 100.79,21.42 100.79,21.02 U2500.K8 ; v1(99.62,100.03) 99.67,100.03 100.08,99.61 PU8600.14 ; U2500.G5 99.33,22.48 v1(99.03,22.48) ; PU8600.1 99.68,95.85 99.37,95.53 v1(99.37,95.46) ; v1(100.15,21.44) 99.99,21.28 U2500.J5 ; PU8600.11 101.28,99.35 101.45,99.52 101.78,99.52 v1(101.96,99.34)
  TOP w0.254: U3701.7 155.28,20.74 ; v1(11.46,80.86) 11.54,80.77 U5701.3 13.59,80.77 13.94,80.42 v1(13.94,80.16) ; U3701.5 153.65,20.06 ; U3701.6 154.15,20.12 ; U3701.8 155.32,21.24 ; U6801.C13 188.23,93.7 188.88,93.7 U6801.C12 ; v1(13.56,84.25) 13.51,84.31 U5700.3 11.63,84.31 v1(10.92,85.02)
  TOP w0.279: v1(37.23,58.31) U3901.32 37.23,59.57 U3901.33 ; U3901.33 34.23,60.07 U3901.23 v1(32.46,60.07) ; U3901.33 33.73,63.07 U3901.16 v1(33.73,64.32) ; U3901.33 37.23,63.07 U3901.9 37.23,64.2 v1(37.35,64.32)
  TOP w0.305: U6801.E1 197.94,95.56 v1(198.36,95.56) ; v1(198.28,76.1) 198.06,76.1 U6803.N14 ; U6801.T10 v1(190.97,103.77) 191.01,103.73 191.01,103.03 U6801.P10 ; U6803.B10 U6803.C11 ; U6803.C11 195.4,84.4 v1(195.76,84.76) 196.12,84.4 U6803.C12 ; U6803.C11 195.37,84.36 v1(194.96,83.96) ; U6801.N12 v1(188.58,101.4) ; v1(195.68,72.75) 196.14,73.2 U6803.U12 ; U6801.F10 190.67,96.18 v1(191.12,96.63) 190.78,96.98 U6801.G10 ; U6803.R11 195.51,74.65 196.02,74.65 U6803.R12 ; U6803.R11 195.35,74.8 v1(194.97,74.42) 194.97,74.4 U6803.T10 ; U6803.R11 U6803.P10 ; v1(193.88,96.1) 193.95,96.18 U6801.F5 ; v1(185.8,94.62) 185.8,94.08 186.11,93.78 U6801.C14 ; U6803.L5 190.79,78 191.2,77.59 v1(191.2,77.49) 190.91,77.2 U6803.M5 ; v1(196.58,86.54) 196.58,86.41 U6803.A12 ; U6803.F10 194.28,82 v1(193.6,82.68) ; v1(186.04,97.27) 186.55,97.78 U6801.H14 187.46,97.88 188.06,97.88 U6801.H13 ; U6803.B5 190.57,85.17 v1(190.96,84.77) ; v1(189.23,72.7) 188.97,72.96 U6803.U3 ; v1(86.86,8.31) 87.25,7.92 J5300.3 ; U6803.E1 187.07,82.8 v1(186.61,83.26) ; v1(189.33,94.97) 189.33,95.01 U6801.E12 ; U6803.K1 187.37,78.81 v1(187.76,79.2) ; U6803.U1 v1(187.84,72.73) ; U6801.B5 v1(194.98,93.4) U6801.C4 195.45,93.69 196.07,93.69 U6801.C3 ; U6803.N1 186.71,76.4 v1(186.69,76.42) ; U6801.H1 197.37,98.17 v1(197.37,98.19) 196.97,97.78 U6801.H2 ; U6801.U12 188.63,105.31 v1(188.63,105.41) ; U6801.G5 194.11,97.43 v1(194.09,97.43) ; U6801.R12 188.96,103.37 v1(189.36,102.96) 189.76,103.36 U6801.R11 ; C6619.2 v1(195.72,105.41) U6801.U3 ; v1(198.17,92.59) U6801.A1 ; U6803.K2 188.17,78.8 v1(187.76,79.2) ; U6803.L10 194.43,77.87 194.43,77.33 U6803.M10 193.57,77.2 v1(193.12,76.74) ; U6801.R14 187.75,102.99 v1(187.78,102.99) ; v1(48.1,43.84) 48.05,43.79 C2319.2 ; v1(196.56,84.76) 196.92,84.4 U6803.C13 ; v1(197.34,99) 196.96,99.38 U6801.K2 ; U6801.K1 198.23,99.85 v1(198.25,99.85) ; U6801.L5 194.14,100.18 v1(193.99,100.33) 193.99,100.41 U6801.M5 ; v1(187.76,79.2) 187.37,79.6 U6803.J1 ; v1(151.36,92.84) 151.36,92.53 151.51,92.38 C6203.2 ; v1(198.3,73) 198.11,73.2 U6803.U14 ; v1(196.54,95.76) 196.16,95.38 U6801.E3 ; U6803.D10 194.47,83.7 193.94,83.7 v1(193.58,84.06) ; U6803.C1 186.92,84.4 v1(186.8,84.52) ; v1(186.03,103.01) 186.91,102.13 187,102.13 U6801.N14 ; U6801.C1 198.08,94.1 v1(198.26,94.1) ; U6801.U14 187.08,105.26 186.44,105.26 186.03,104.85 v1(186.03,104.5) ; U6801.K13 U6801.K14 186.86,99.38 v1(186.46,98.99) ; v1(191.14,93.25) 190.87,92.98 U6801.B10 U6801.C11 U6801.C12 ; U6803.N12 196.17,76.38 v1(195.79,76) ; v1(198.29,105.36) 198.14,105.36 U6801.U1 ; Q2901.1 28.79,66.45 28.48,66.14 v1(28.14,66.14) ; v1(194.01,105.03) 194.01,104.73 U6801.T5 ; U6803.H2 U6803.H1 186.83,80.4 v1(186.81,80.37) ; v1(198.15,85.58) 198.15,85.61 U6803.A14 ; v1(198.16,80.77) 197.8,80.4 U6803.H14 197.65,80.28 197.09,80.28 U6803.H13 ; U6803.E12 196.18,82.8 v1(196.57,82.4) ; v1(198.23,103.65) 198.03,103.65 U6801.R1 ; v1(186.25,85.45) 186.25,85.5 186.75,86 U6803.A1 ; U6803.E14 197.74,82.8 v1(197.35,82.41) ; v1(195.9,91.7) 195.9,91.92 U6801.A3 ; U6803.G10 194.18,81.2 v1(194,81.02) ; U6801.N3 196.17,101.78 v1(196.55,101.4) ; U6801.R3 195.78,103 v1(195.73,103) 195.36,103.37 U6801.R4 ; U6803.K13 U6803.K14 197.85,78.8 v1(198.27,78.38) ; v1(188.56,82.41) 188.95,82.8 U6803.E3 ; J5301.9 41.09,64.57 40.74,64.92 v1(40.74,65.31) 40.77,65.31 41.04,65.57 J5301.11 ; U6803.F5 U6803.G5 190.91,80.86 v1(191.02,80.86) ; U6803.A3 189.06,86.09 189.12,86.09 189.52,86.49 v1(189.52,86.54) ; Q2401.4 28.99,20.59 v1(29.32,20.92) ; U6803.C4 189.75,84.4 v1(189.37,84.78) 189.35,84.78 U6803.C3 ; J5300.6 v1(88.75,7.83) ; U6801.A12 188.53,91.75 187.79,91.75 U6801.A14 186.44,92.18 186,92.61 v1(186,92.92) ; U6801.D10 190.81,94.83 v1(191.06,94.83) ; U6803.C14 197.77,84.37 v1(198.18,83.96) ; U6801.N1 v1(197.36,102.18) ; J5300.8 v1(89.75,7.83) ; U6801.L10 190.63,100.18 v1(190.97,100.53) 190.97,100.56 U6801.M10 ; v1(186.69,74.83) 186.72,74.8 U6803.R1 ; U6803.R14 v1(198.33,74.8) ; U6803.R3 189.11,74.65 189.62,74.65 U6803.R4 U6803.T5 v1(190.19,73.62)
  TOP w0.356: v1(60.64,26.94) 60.86,27.16 C2000.2 ; PQ7605.3 69.75,104.23 v1(69.76,104.23) ; PQ7610.3 33.84,108.9 v1(33.96,109.02) ; PQ7603.1 v1(67.15,99.9) ; PQ7608.1 30.71,102.95 30.15,102.39 v4(30.15,102.21) ; PQ7612.1 v1(33.68,107.78) ; v1(63.45,28.86) 63.39,28.81 62.13,28.81 61.7,28.37 C2006.2 ; v1(50.89,28.15) 50.89,27.52 51.54,26.88 52.17,26.88 C2107.2 ; C5703.2 27.94,76.15 27.46,75.67 v1(26.9,75.67) ; v1(19.02,49.51) 19.06,49.54 Q2400.4 ; v1(23.09,54.26) 22.89,54.05 20.85,54.05 20.36,53.56 Q2400.1 ; v1(45.26,59.46) 45.15,59.57 J5301.13 ; PQ7612.4 v1(35.99,106.48) ; v1(46.43,74.33) 46.34,74.24 PU9000.3 ; PQ7603.4 65.19,97.24 64.62,96.67 v1(64.62,96.52)
  TOP w0.381: v1(39.95,48.49) 39.47,48.01 C2301.2 39.9,47.58 39.93,47.6 R2341.1 ; v1(59.77,25.35) C2209.2
  TOP w0.406: v1(85.55,5.48) 85.25,5.19 J5300.13 ; J5300.14 v1(92.75,5.34)
  TOP w0.432: v1(44.58,81.89) 44.45,82.02 R5826.2 ; C3913.2 30.48,59.13 30.28,58.93 v1(30.28,58.73) C3905.2 ; C6705.2 159.73,84.19 159.08,84.84 v1(158.98,84.84) ; C6715.2 157.25,83.83 v1(157.25,83.19) ; R2328.1 45.54,35.51 45.9,35.16 R2315.2 C2314.2 44.55,34.8 44.09,35.25 v1(44.09,35.33) ; v1(50.7,78.57) 50.55,78.57 C2239.2 ; R3819.1 13.67,55.91 v1(13.46,56.11) ; C2220.2 62.48,24.99 62.2,24.72 v1(61.65,24.72) 61.54,24.82 C2221.2 ; v1(68.45,24.11) 68.73,23.83 C2242.2 ; PC9001.2 v1(40.34,70.13) ; v1(112.42,114) 112.17,114.25 PR8810.2 ; v1(178.51,41.81) 178.18,42.14 PC7832.2 ; R0415.1 127.71,28.65 v1(127.93,28.87) ; C6720.2 150.65,88.91 150.27,88.52 150.27,87.38 v1(150.8,86.85) ; TR3700.2 C3707.2 106.2,47.7 v3(106.43,47.93) ; v1(100.57,102.33) 100.15,101.91 PR8611.1 ; v1(111.3,28.7) 110.85,28.7 R1508.2 ; C5704.2 31.3,86.8 v1(31.3,87.04) ; C1629.2 119.52,28.31 v1(119.93,28.31) ; PC7836.2 168.66,49.71 v1(168.66,50.17) ; C2307.2 v1(27.36,25.22) 27.46,25.12 R2344.2 ; v1(41.78,15.22) 41.45,15.55 41.43,15.55 41.3,15.67 PC8802.2 ; v1(71.09,24.69) 71.09,24.44 70.49,23.83 C2243.2 ; v1(93.78,43.92) 93.56,43.7 C1002.2 ; C2306.2 C2300.2 v1(33.2,48.11) ; C2315.2 40.97,24.74 40.51,24.28 v1(40.51,24.04) ; C0619.2 128.91,44.58 129.8,43.68 v1(129.8,43.1) ; R6300.2 179.91,77.65 179.6,77.35 v1(179.6,77.29) ; C2203.2 67.84,30.47 v1(67.82,30.44) ; v1(225.36,19.26) C3100.2 ; v1(118.76,21.25) 119.18,21.67 C1630.2 ; v1(58.32,8.94) 58.44,8.83 C5126.2 ; PC8811.2 106.55,113.82 v1(106.55,113.64) ; v1(35.6,90.52) 35.6,90.49 35.59,90.47 PC7603.2 ; v1(101.52,102.29) 101.52,102.26 101.12,101.86 PC8600.2 ; R0900.2 124.99,65 v3(124.95,64.96) ; PC8605.2 103.21,95.81 102.97,95.57 v1(102.97,95.42) ; v1(64.74,62.87) 64.74,63.35 63.32,64.77 C2011.2 ; v3(123.6,66.04) 123.3,66.04 R0407.1 ; v1(27.61,105.43) 27.85,105.18 PR7638.2 ; v1(160.97,84.8) 160.97,84.72 C6717.2 ; v1(175.52,54.43) 175.52,53.89 PR7823.2 ; PC9808.2 191.24,70.69 v1(190.7,70.16) ; PR7646.2 72.02,111.22 v1(72.03,111.23) ; v1(67.62,58.07) 67.62,58.24 68.2,58.83 C2226.2 ; v1(185.8,99.01) 185.57,99.24 C6802.2 R6809.2 ; C5805.2 46.24,76.06 v1(46.48,75.82) ; C5120.2 v1(83.61,8.15) ; v1(104.93,100.15) 104.93,100 104.72,99.8 PC8609.2 ; v1(37.41,56.19) 37.47,56.24 C3910.2 ; PR7645.2 38.15,107.8 v1(37.57,107.8) ; R6937.1 141.17,80.57 v1(140.31,80.57) ; C0620.2 126,45.49 v3(125.73,45.23) ; C2504.2 C2501.2 91.24,25.07 v1(91.64,25.48) ; PR7824.1 172.26,55.98 171.93,55.65 v1(171.93,54.64) ; v1(179.15,41.81) 179.15,42.14 179.1,42.19 PC7813.2 ; v1(25.25,70.06) 25.71,69.6 25.71,68.53 C2908.2 ; v1(149.28,22.43) 149.78,22.94 C3703.2 ; PC9205.2 143.87,26.18 v1(143.2,26.84) ; PC8801.2 39.8,19.69 v1(39.7,19.59) 39.32,19.2 PR8802.2 ; R2103.2 48.3,48.84 v1(48.06,48.6) ; C6800.2 201.61,79.1 v1(201.7,79) ; v1(56.93,24.74) 56.93,24.92 C2232.2 ; R2005.2 60.7,49.57 60.43,49.84 v1(60.43,50.27) ; v1(10.8,87.45) 11.27,86.98 D5703.2 ; R5706.2 25.1,76.66 v1(25.5,76.25) ; v1(51.89,47.55) 51.91,47.57 C2211.2 ; v1(151.45,88.18) 151.61,88.33 C6733.2 152.31,88.79 152.3,88.8 C6202.2 152.3,89.69 152.76,90.15 R6204.2 ; C1204.2 91.54,29.52 v1(91.69,29.38) ; v1(18.17,35.77) 18.17,35.81 C3807.2 ; v1(63.32,65.96) 63.22,65.96 62.98,65.71 C2002.2 ; v1(42.77,57.84) 43,58.07 C5301.1 ; C0704.2 128.79,54.73 v1(129.51,54.73) ; v1(201.65,57.56) 201.35,57.86 PR8912.1 ; PC9515.2 169.37,111.33 PU9501.15 ; v1(56.54,6.86) 56.59,6.91 C5129.2 ; 65.53,60.83 C2231.2 ; v1(27.84,62.26) 27.84,61.9 C5814.2 ; C5116.2 v1(80.82,8.18) ; C2309.2 23.44,33.23 v1(23.06,33.23) ; C3901.2 38.46,56.24 v1(38.41,56.19) ; C2233.2 57.58,24.75 v1(57.58,24.74) ; 1.92,93.76 CON5700.22 3.2,93.07 ; v1(92.18,25.81) 91.67,26.32 C1205.2 R1226.2 ; C1905.2 73.81,17.83 74.12,18.14 74.32,18.14 v1(74.38,18.08) ; PR7856.1 PC7824.1 173.14,54.37 v1(173.14,54.55) ; R6202.2 154.66,92.46 154.67,92.45 C6201.2 v1(154.03,91.99) ; R0411.1 R1018.2 125.73,24.51 125.73,23.86 v1(125.6,23.73) ; C1611.1 111,30.57 v1(111.32,30.57) ; C5811.2 44.42,77.09 v1(44.32,77) ; C3701.2 11.68,56.03 v1(12.27,56.03) ; C1904.2 29.18,55.93 v1(28.42,56.7) ; v1(31.17,50.18) 31.27,50.08 R2413.2 ; R6206.2 152.27,93.47 152.12,93.32 151.84,93.32 v1(151.36,92.84) ; C2009.2 60.67,50.95 v1(60.5,50.95) ; PC9809.2 190.88,63.27 v1(190.58,62.97) ; C2100.2 C2222.2 C2223.2 C2208.2 ; PC9007.2 32.18,71.17 v1(32.08,71.17) ; R1030.2 v1(102.74,29.42) ; v1(8.23,36.58) 7.98,36.83 R3817.1 ; v1(162.43,46.1) 164.06,46.1 164.44,46.48 PC7829.2 ; R1212.2 127.48,23.73 v1(127.48,22.8) ; v1(60.45,47.12) 60.45,47.4 60.72,47.67 C2010.2 ; v1(109.59,26.56) 108.78,26.56 C2003.2 C2004.2 ; C1606.2 120.52,43.03 v3(120.6,43.11) ; C1903.2 40.37,84.84 v1(40.83,84.38) ; C1003.2 93.95,41.81 94.26,42.12 95.17,42.12 v1(95.53,41.76) ; PR7833.2 170.18,46.48 PR7832.2 169.62,47.27 169.57,47.32 v1(168.88,47.32) ; v1(34.7,81.56) 35.51,80.75 R5716.2 R5720.2 ; v1(161.66,66.18) 161.66,65.53 PC9507.2 ; C5803.2 38.05,71.81 37.59,72.27 C5802.2 v1(37.59,73.28) ; v1(59.82,47.2) 59.83,47.2 R2006.2 ; v1(33.71,56.2) 33.66,56.25 R3911.2 ; v1(168.42,80.78) 168.42,80.65 168.58,80.5 R6936.1 ; R3609.2 62.41,24.11 v1(62.79,23.73) ; v1(37.67,109.07) 37.69,109.1 PR7637.2 ; C3003.2 56.05,100.33 v1(55.5,100.33) ; R1607.2 117.64,24.74 v1(117.67,24.72) ; v1(12.33,77.11) 12.33,77.56 12.52,77.75 D2600.2 14,77.75 R2602.1 ; C3705.2 C3704.2 154.08,23.57 v1(154.58,23.07) ; PC8621.2 107.12,98.45 v1(106.83,98.74) ; R2332.2 45.71,40.03 v1(46.14,40.46) 46.15,40.46 46.56,40.87 C2308.2 ; 64.67,52.96 64.67,53.73 v1(64.64,53.76) ; R6309.2 167.16,76.7 R6308.2 167.95,77 v1(168,77.05) ; C3906.2 C3908.2 40.54,62.82 v1(40.79,62.56) ; C5111.2 v1(79.9,8.17) ; v1(31.39,69.88) 31.51,69.76 PC9002.2 ; C2105.2 C2103.2 C2106.2 C2101.2 58.73,27.26 58.88,27.1 58.88,26.06 v1(59.22,25.72) ; C3110.2 v1(225.34,17.25) ; R1218.2 65.23,13.77 65.1,13.64 v1(65.1,13.62) ; v1(45.26,67.91) 45.26,67.52 44.82,67.07 J5301.14 ; C2201.2 68.83,63.14 68.4,63.58 v1(68.4,63.83) ; v1(31.32,60.89) 30.94,60.51 C3903.2 ; C2110.2 48.6,46.98 48.52,47.06 v1(48.06,47.06) ; v1(42.15,72.54) 41.82,72.54 C5800.2 ; v1(27.89,63.82) 28.19,63.52 C2909.2 ; C6749.2 169.9,85.96 169.67,86.19 v1(169.67,86.44) ; C2502.2 C2506.2 97.19,14.72 v1(97.31,14.84) ; C5119.2 v1(81.75,8.15) ; v1(23.06,38.97) C2305.2 ; R2405.2 17.93,53.55 v1(18.36,53.98) ; PC8616.2 100.44,93.21 100.42,93.21 v1(100.27,93.05) ; PC8612.2 105.08,94.06 v1(105.18,94.16) 105.23,94.21 105.23,94.72 104.98,94.97 PR8610.2 ; v1(182.03,80.71) 181.7,80.71 C6300.2 ; R3703.2 149.96,20.45 v1(149.68,20.45) ; C3109.2 v1(225.4,18.24) ; v1(225.37,22.15) C3101.2 ; 4.5,93.07 CON5700.21 ; v1(45.49,63.81) 45.9,63.4 C2102.2 ; D5102.2 56.85,11.3 v1(56.85,11.66) ; v1(183.54,93.31) 183.6,93.25 C6626.2 ; C3911.2 C3904.2 40.67,61.83 v1(40.77,61.93) ; R2104.2 47.78,52.68 v1(47.78,53.14) ; R5827.2 v1(42.98,82.59) ; R1028.2 v1(114.23,29.58) ; C1201.2 v1(65.58,9.88) ; C2005.2 70.56,27.59 70.51,27.54 C2012.2 C2001.2 72.11,26.01 72.54,25.58 v1(72.54,24.72) ; v1(93.6,34.04) 93.55,34.09 C1102.2 ; v3(128.55,59.08) 128.55,59.67 C0711.2 ; R2408.2 23.04,51.03 v1(23.09,51.03) ; v1(44.07,37.98) 44.37,38.28 C2304.2 46.1,38.28 46.18,38.36 R2325.2 ; v1(36.37,90.52) 36.37,90.45 36.6,90.22 PR7612.2 ; v1(164.75,84.94) 164.64,84.83 C6727.2 ; R1027.2 113.58,28.05 R1023.2 112.66,27.65 112.56,27.55 v1(112.56,27.34) ; v1(66.23,9.89) 66.23,10.15 C1202.2 ; v1(34.7,25.61) 34.93,25.38 C2303.2 ; C3702.2 151.77,18.42 v1(152.02,18.16) ; R1029.2 114.71,27.58 v1(114.76,27.52) ; R5710.2 26.95,87.01 v1(26.96,87.01) ; v1(29.26,85.82) 29.26,85.97 29.76,86.46 C5701.2 ; C5806.2 v1(46.39,78.82) ; v1(34.1,75.11) 34.12,75.09 35.15,75.09 R5822.2 ; v1(97.88,79.29) 98.4,79.81 R3614.2 ; v1(218.9,15.45) R3102.2 ; C2107.2 C2104.2 ; C5127.2 50.81,6.92 50.8,6.91 v1(50.8,6.81) ; v1(67.72,61.59) 67.72,61.34 68.25,60.81 C2207.2 ; C1632.2 133.83,23.04 v1(134.04,23.04) ; v1(92.76,30.46) 92.76,30.45 C2505.2 ; v1(16.33,47.27) 16.13,47.07 R3815.1 ; PC9005.2 v1(45.9,69.34) ; C6724.2 159.27,83.14 v1(159.27,83.62) 158.88,84.01 C6742.2 ; C3117.2 v1(225.02,1.5) ; PR7623.2 75.29,111.2 v1(75.31,111.23) ; v1(46.06,48.61) 46.1,48.56 C2311.2 ; C2108.2 46.21,51.45 v1(46.21,51.58) ; v1(46.62,77.08) 46.6,77.09 C5812.2 ; v1(160.96,85.95) 161.06,85.95 C6714.2 ; v1(54.92,110.42) PR7626.2 ; C6706.2 163.02,83.11 v1(162.71,83.11) ; C3102.2 v1(225.36,20.27) ; C2234.2 58.34,62.79 v1(58.83,63.27) 58.83,63.35 57.94,64.24 C2217.2 ; 94.1,24.83 C2500.2 ; 94.1,24.83 C2503.2 ; 94.1,24.83 94.12,24.83 94.46,24.83 v1(94.76,24.54) ; C6616.2 183.62,94.26 v1(183.54,94.19) ; v1(170.76,88.95) 169.88,88.95 169.38,88.46 C6753.2 ; R2414.2 v1(30.96,21.11) ; v1(18.82,35.84) 18.83,35.83 C3805.2 ; C3801.2 v1(19.38,23.88) ; v1(21.54,77.14) 21.54,77.98 21.7,78.14 R5704.2 22.98,78.14 C5702.2 ; v1(96,31.5) 96,31.97 96.11,32.08 C1618.2 ; R3904.2 v1(40.74,59.97) ; PU8800.13 44.65,14.33 PC8814.2 ; v1(78.98,8.18) C5113.2 ; C5114.2 v1(76.22,8.18) ; v1(21.93,86.85) 22.25,86.52 C5700.2 ; C3902.2 36.45,56.21 v1(36.42,56.19) ; v1(53.49,6.81) 53.59,6.91 C5128.2 ; v1(225.11,4.42) C3119.2 ; R6818.1 201.35,75.92 v1(201.47,76.05) ; C5813.2 v1(26.85,56.82) ; v1(39.47,72.79) 39.78,72.48 C5801.2 ; R0702.2 v1(178.78,51.77) ; C3817.1 19.36,24.72 v1(19.38,24.74) ; v1(91.54,34.01) 91.57,34.04 C1100.2 ; v1(77.14,8.18) C5115.2 ; v1(42.49,70.05) 42.39,70.16 PR9005.2 ; C2228.2 v1(63.35,37.36) ; v1(58.78,50.85) 58.52,50.85 58.42,50.75 C2235.2 ; 68.48,74.63 68.5,74.65 C2224.2 ; C6305.2 182.98,78.51 v1(182.98,78.56) ; C1603.2 C1602.2 118.33,30.04 117.86,30.51 v3(117.86,30.97) 117.35,30.97 C1612.2 ; R1517.2 92.43,32.57 92.86,33 93.35,33 v1(93.55,33.2) ; v1(93.14,21.01) 93.17,21.03 R2512.1 R2509.2 ; v1(92.74,34.04) 92.61,34.17 C1101.2 ; v1(24.66,23.37) 24.71,23.32 C2400.2 ; C2318.2 41.96,45.14 v1(41.86,45.04) ; C3605.2 102.9,84.74 v1(102.87,84.76) ; C3909.2 40.69,58.14 v1(40.77,58.07) ; C3108.2 v1(225.35,16.26) ; v1(34.75,77.57) 34.77,77.57 34.85,77.65 R5821.1 ; v1(44.09,29.9) 44.35,30.15 ; C3914.2 v1(34.95,66.33) ; v1(141.76,26.88) PR9207.2 ; v1(56.1,97.7) 55.93,97.53 R3009.2 ; v1(54.94,62.67) 54.94,61.65 56.24,60.35 57.05,60.35 ; PR9805.1 192.66,65.69 193.5,66.53 v1(193.88,66.53) ; PR7616.2 v1(68.58,102.9) ; R2423.2 v1(30.94,24.26) ; v4(76.23,105.01) 75.36,105.87 75.36,106.58 74.21,107.74 PR7621.2 ; v1(48.08,47.92) C2111.2 ; C2200.2 62.84,78.2 v1(63.32,78.68) ; C5118.2 v1(82.68,8.15) ; v1(112.93,29.72) 112.23,30.42 R1608.2 ; C1800.2 v1(13.34,18.04) ; v1(43.38,44.25) 43.31,44.17 C2312.1 ; C3907.2 v1(35.87,66.35) ; v1(225.36,21.21) C3103.2 ; C5130.2 v1(59.08,11.58) ; R0406.1 128.09,77.59 127.91,77.76 v1(127.91,78.01) ; v1(46.48,79.99) 45.87,79.99 ; R5907.2 12.22,90.38 11.91,90.68 11.91,91.27 D5707.2 ; PR9001.2 v1(40.28,69.07) ; D5103.2 v1(57.81,11.66) ; v1(78.06,8.18) C5112.2 ; v1(29.49,49.61) R2322.2 ; v1(143.14,79.16) R6941.1 ; v1(142.75,21.54) PR9201.2
  TOP w0.457: v1(201.88,78.04) 201.83,78.08 R6805.2 ; v1(225.02,3.48) C3118.2 ; v1(154.71,109.21) 154.39,108.9 C6721.2 ; R6803.1 185.95,97.18 v1(186.04,97.27) ; v4(149.83,102.01) 150.06,102.24 R6939.1 ; R6940.1 149.1,102.49 v4(149.05,102.44) ; v1(219.15,2.69) 219.07,2.61 R3107.2 ; v1(70.54,99.56) 70.54,98.74 PR7618.2 ; v1(225.02,2.49) C3116.2 ; v1(152.96,109.21) 153.25,108.92 C6734.2 ; v1(222.07,7.39) 222.22,7.24 C3115.2 ; C1103.2 v1(94.46,34.04)
  TOP w0.508: v1(184.46,58.8) 183.79,58.8 183.44,58.45 183.44,57.3 ; PU8900.22 200.9,59.62 PC8921.2 ; C2227.2 63.2,87.73 v1(63.32,87.86) ; C0600.2 107.11,51.39 v3(107.34,51.39) ; v1(36.93,10.14) 36.63,10.44 36.25,10.44 ; 56.85,58.78 55.58,58.78 55.3,59.06 v1(55.3,59.52) ; v1(74.35,23.88) 74.3,23.83 C1906.2 ; v1(176.93,115.02) 176.92,115 176.94,114.99 PC9516.2 ; D2901.2 16.27,66.19 v1(16.43,66.03) ; v1(55.14,85.64) 55.15,85.62 C2218.2 ; C0602.2 108.74,49.58 v3(108.78,49.62) ; v1(115.62,88.9) 115.62,88.42 115.85,88.19 ; C2316.2 26.4,45.01 26.4,44.02 v1(26.41,44) ; v1(34.49,47.17) C2310.2 ; 117.55,12.25 v1(117.55,11.66) ; v4(40.72,98.94) 40.72,99.57 PC7607.2 ; C2206.2 63.46,69.83 v1(63.5,69.88) ; PD7602.1 v1(44.55,95.54) ; v1(68.22,51.13) 68.96,51.13 C2205.2 ; v1(221.44,15.55) 221.44,14.53 ; R1807.2 69.14,15.62 v1(68.89,15.88) ; 6.17,91.04 6.59,90.62 CON5700.B1 5.94,90.2 5.92,90.22 ; v1(51.82,43.6) 51.82,44.1 C2219.2 ; v1(10.74,91.76) 10.76,91.78 D5707.2 ; C2229.2 69.62,85.28 v1(69.04,85.87) ; v3(106.34,57.97) 106.58,58.21 C0601.2 ; v1(56.19,89.89) 57.35,89.89 ; v1(56.27,42.6) 56.88,42.6 C2241.2 ; v1(64.57,61.55) 64.57,61.4 65.13,60.83 65.53,60.83 C2225.2 ; v3(123.69,44.02) 123.98,43.73 C1621.2 125.37,43.73 C1624.2 ; C2223.2 45.27,24.24 v1(44.98,23.95) ; 210.95,36.45 v1(211.73,37.24) ; PC7915.2 149.78,64.11 ; v1(12.14,87.1) 12.65,86.59 D5704.2 ; v1(51.71,10.98) 51.7,10.99 D5100.2 ; C2401.2 v1(31.27,48.16) ; v1(16.33,70.84) 16.33,70.65 D2900.2 ; v1(63.35,32.97) 62.64,33.68 ; v1(85.86,24.51) 85.29,23.94 85.29,22.17 86.56,20.9 86.56,20.63 89.21,17.99 89.21,14.3 87.64,12.73 86.87,12.73 86,11.86 v1(86,11.18) ; v1(10.67,90.55) 11.31,89.91 D5702.2 ; C2204.2 69.12,46.35 68.69,46.78 v1(68.63,46.78) ; v1(25.25,70.06) 25.25,70.97 25.69,71.42 Q2601.2 ; C6907.2 155.7,85.97 v1(155.7,86.36) ; PC7826.2 180.54,49.13 v1(180.37,49.3) ; v1(53.59,11.71) 53.24,11.36 D5101.2 ; 68.48,74.63 67.74,73.89 v1(67.74,73.43) ; 88.62,102.57 v4(88.62,101.75) ; v1(131.69,88.89) 131.69,88.25 ; C2105.2 C2240.2 ; v3(109.37,46.84) 109.32,46.79 C0603.2 ; C2238.2 51.29,42.12 v1(50.81,42.59) ; v1(56.29,75.28) 57.02,75.28 C2237.2 ; CON5700.21 5.79,93.76 ; v1(148.03,32.59) 147.37,33.25
  TOP w0.635: 8.12,81.84 CON5700.15 7.04,82.52 ; CON2600.22 13.14,59.15 ; CON2600.22 10.62,59.15 ; CON2600.22 11.88,60.05 ; CON2600.22 11.88,58.25 ; 6.59,82.9 CON5700.B12 ; 5.33,75.57 5.32,75.55 CON2600.21 3.68,76.39 ; CON2600.20 5.12,57.25 ; CON5700.14 7.07,80.92 ; CON5700.13 1.92,80.24
  IN1 w0.635: 6.59,82.9 CON5700.B12 ; CON2600.22 13.32,59.15 ; CON2600.22 11.88,58.25 ; CON2600.22 11.88,60.05 ; 1.92,93.76 CON5700.22 3.2,93.07 ; 7.07,80.92 CON5700.14 5.79,80.24 ; 7.04,82.52 CON5700.15 8.12,81.84 ; 13.32,73.65 CON2600.23 11.88,74.55 ; CON5700.B1 6.59,91.1 ; 5.68,98.95 H5215.1 5.68,95.45 ; 3.68,56.41 CON2600.20 5.12,57.25 ; CON5700.20 9.2,91.47 ; CON5700.20 8.12,92.16 ; CON5700.20 7.04,91.47 ; 1.92,80.24 CON5700.13 3.2,80.92 ; 7.07,93.07 CON5700.21 5.79,93.76 ; CON2600.21 3.68,76.39
  VCC w0.508: 92.99,85.73 92.96,85.73
  IN2 w0.432: 99.93,68.55 H5201.1 ; H5201.1 99.93,73.55 ; H5201.1 97.43,71.05 ; H5201.1 102.43,71.05 ; 97.43,37.05 H5202.1 ; H5202.1 99.93,39.55 ; H5202.1 102.43,37.05 ; H5202.1 99.93,34.55
  IN2 w0.635: H5215.1 3.93,97.2 ; H5215.1 5.68,98.95 ; H5215.1 5.68,95.45 ; 5.12,57.25 CON2600.20 3.68,56.41 ; 3.2,93.07 CON5700.22 1.92,93.76 ; 6.59,82.9 CON5700.B12 ; CON2600.21 3.68,76.39 ; 11.88,59.99 CON2600.22 ; CON2600.22 13.32,59.15 ; CON2600.22 11.88,58.31 ; 8.12,81.84 CON5700.15 7.04,82.52 ; CON5700.13 1.92,80.24 ; CON5700.B1 6.59,91.1 ; CON5700.20 8.12,92.16 ; CON5700.20 9.2,91.47 ; CON5700.20 7.04,91.47 ; CON5700.14 5.79,80.24 ; 5.79,93.76 CON5700.21 7.07,93.07 ; 11.88,74.49 CON2600.23 ; CON2600.23 13.14,73.65 ; CON2600.23 10.62,73.65
  IN3 w0.635: 11.88,59.99 CON2600.22 ; CON2600.22 11.88,58.31 ; CON2600.22 13.32,59.15 ; 8.12,81.84 CON5700.15 7.04,82.52 ; 5.12,57.25 CON2600.20 3.68,56.41 ; 11.88,74.49 CON2600.23 ; 6.59,82.9 CON5700.B12 ; 8.12,92.16 CON5700.20 7.04,91.47 ; 5.79,80.24 CON5700.14 7.07,80.92 ; 3.2,80.92 CON5700.13 1.92,80.24 ; CON2600.21 3.68,76.39 ; 1.92,93.76 CON5700.22 3.2,93.07 ; 5.68,98.95 H5215.1 5.68,95.45 ; CON5700.B1 6.59,91.1 ; 7.07,93.07 CON5700.21 5.79,93.76
  BOTTOM w0.102: U0400.A5 126.99,34.67 126.5,34.67 126.19,34.97 U0400.C5 126,33.62 125.86,33.48 125.86,33.17 125.96,33.07 125.96,33.07 U0400.C1 ; 106.83,52.1 106.96,52.22 106.96,52.61 ; v3(125.71,55.11) 125.69,55.09 125.69,54.58 125.87,54.4 126.12,54.4 126.17,54.44 126.46,54.44 126.49,54.41 128.3,54.41 128.79,53.92 130.55,53.92 131.39,54.76 v1(131.83,54.76)
  BOTTOM w0.127: CON5700.A1 7.04,84.25 CON5700.B12
  BOTTOM w0.152: v3(103.92,46.68) 104.09,46.85 104.52,46.85 104.53,46.85 U0400.BB26 ; U6000.F10 170.88,83.97 170.88,84.7 171.23,85.05 U6000.F12
  BOTTOM w0.178: v3(122.97,73.72) 123.08,73.61 U0400.H71 ; U0400.BB38 103.95,54.19 v3(103.84,54.07) ; U0400.BB34 104.12,51.84 v3(104.09,51.8) ; U0400.AW57 106.69,65.51 105.97,65.51 U0400.BA57
  BOTTOM w0.191: v1(171.41,77.15) 171.22,77.35 171.22,78.41 U6000.F2
  BOTTOM w0.203: U6000.B22 174.36,93.22 v1(174.53,93.39) ; U6000.B18 174.28,90.02 v1(174.35,89.95) ; v3(106.85,31.93) 106.85,32.07 107.15,32.38 U0400.AV1 ; v1(112.93,29.72) 113.06,29.72 113.84,30.5 113.84,30.98 113.96,31.11 113.96,32.91 U0400.AF1 U0400.AF2 ; U0400.AR53 109.08,62.67 109.2,62.56 109.2,62 U0400.AR52 ; U5702.11 18.48,78.43 18.8,78.11 v1(18.8,78.01) ; v3(103.58,69.27) 103.73,69.12 104.23,69.12 104.34,69.07 104.8,68.91 U0400.BB64 ; U0400.BB6 U0400.BA6 106.2,35.85 v3(106.28,35.92) ; U6000.K2 168.03,77.09 v1(168,77.05) ; U0400.BB43 104.86,56.79 104.85,56.79 104.01,56.79 v3(103.86,56.95) ; v3(104.14,66.58) 104.15,66.56 U0400.BB60 ; v3(104.38,63.72) 104.75,63.72 U0400.BB55 ; U6000.H2 169.63,77.26 v1(169.74,77.14) ; 106.64,60.15 105.87,60.15 U0400.BA49 ; U0400.AM71 110.83,73.82 111.17,74.16 v3(111.17,74.35) ; v3(114.13,74.65) 114.13,74.65 113.48,74 113.48,73.15 113.48,73.14 U0400.AG71 ; v3(103.68,48.92) 103.84,49.08 104.22,49.08 104.35,49.21 U0400.BB30 ; v1(174.16,88.27) 174.01,88.42 U6000.B16 ; U6000.G31 170.43,100.26 v1(170.66,100.5) ; U6000.B20 v1(174.53,91.62) ; U6000.B14 v1(174.34,86.82) ; U5702.5 18.48,82.08 18.69,82.3 v1(19,82.3) ; v1(170.84,91.23) 171.22,91.62 U6000.F20 ; U6000.B10 174.27,83.62 v1(174.34,83.55) ; PU9100.11 201.12,51.58 v1(201.23,51.69) ; U7000.11 186.79,109.96 186.64,110.11 186.64,110.52 v1(186.42,110.73) ; PU9200.11 136.91,23.78 v1(136.69,23.56) ; v3(128.91,71.12) 127.69,71.12 127.48,70.92 U0400.A67 ; v3(106.2,55.4) 106.11,55.49 U0400.BA41 ; v1(174.62,96.68) 174.35,96.42 U6000.B26
  BOTTOM w0.229: 16.74,78.46 16.88,78.6 U5702.15 ; U6801.E14 187.75,95.77 188.56,95.77 U6801.E12 ; U6803.N3 189.37,75.99 190.73,75.99 191,75.72 191.35,75.72 v1(191.96,75.11) ; CON5102.1 89.63,11.4 v1(89.43,11.2)
  BOTTOM w0.254: U0400.B10 126,38.03 v3(125.73,37.76) 125.58,37.76 U0400.D10 125.3,38.67 U0400.D11 ; 118.08,68.46 U0400.U63 ; 118.08,68.46 U0400.U64 ; 118.08,68.46 v3(118.05,68.46) ; v3(105.15,74.15) 105.13,74.12 U0400.BA71 ; U6000.B12 173.27,85.26 v1(174.38,85.26) ; v1(15.14,77.88) 15.65,78.39 16.66,78.39 16.74,78.46 ; C0900.1 126.54,27.6 126.62,27.67 126.62,29.3 124.97,30.95 124.97,31.99 124.45,32.51 U0400.F1 U0400.F2 124.45,33.95 v3(124.23,34.17) 124.45,34.38 U0400.F4 125.3,35.51 U0400.D6 ; U0400.U67 118.37,70.73 v3(118.05,70.41) 118.37,70.08 U0400.U66 ; v1(173.79,94.72) 173.69,94.82 U6000.B24 ; U0400.AH67 112.8,70.73 U0400.AK68 ; v1(205.16,35.97) 205.37,35.76 CON5103.26 ; v1(20.37,89.94) 20.12,90.19 U5900.6 ; U6000.J31 169.02,99.41 169.02,100.2 v1(169.12,100.3) ; U6000.J27 v1(169.23,97.62) ; U0400.G5 122.91,35.73 v3(122.91,35.79) 122.91,35.92 U0400.G6 ; v1(128.6,22.74) 128.6,22.74 128.78,22.91 131.17,22.91 131.39,23.14 131.39,25.3 131.24,25.45 X0900.4 ; v1(13.01,61.39) 13.15,61.24 U2601.3 15.2,61.24 v1(15.35,61.39) ; U0400.F13 124.23,39.63 v3(124.23,39.45) 124.23,39.36 U0400.E11 ; v1(195.94,20.35) 195.82,20.23 CON5104.12 ; v1(205.16,28.35) 205.25,28.26 CON5103.11 ; v1(170.83,96.06) 170.87,96.06 U6000.F26 ; v3(128.02,52.86) 128.02,52.88 128.33,53.19 129.72,53.19 129.95,52.96 v1(129.95,52.61) 129.95,52.43 130.84,51.54 v1(130.84,51.46) 130.84,51.29 131.12,51.01 131.45,51.01 131.6,50.85 C1000.1 ; U6000.C1 172.83,77.63 172.96,77.5 v1(173.71,77.5) ; v3(111.5,36.4) 111.64,36.4 U0400.AK8 ; U0400.AJ18 112.52,42.67 111.91,42.67 U0400.AK18 111.3,42.29 v3(111.3,42.24) ; U6000.F6 171.38,80.27 v1(171.38,79.87) ; U0400.A70 127.36,72.93 v3(127.36,73.56) 127.06,73.56 U0400.B71 ; U0400.B34 125.97,52.9 v3(125.78,52.71) 125.59,52.9 U0400.D34 ; v3(112.85,61.9) 112.57,61.9 112.1,61.43 U0400.AL52 ; v1(205.15,25.59) 205.15,25.59 205.32,25.76 CON5103.6 ; v1(130.25,26.72) 130.53,26.44 v1(130.84,26.44) ; U0400.C1 125.88,32.26 125.88,31.26 v1(126.38,30.76) 126.71,30.43 127.81,30.43 128.37,29.87 129.13,29.87 130.18,28.83 130.18,27.82 C0901.1 ; U0400.G10 123.6,37.78 v3(123.6,37.57) 123.6,37.52 U0400.F8 124.26,36.86 v3(124.26,36.76) 124.26,36.6 U0400.E6 ; v3(122.06,53.23) 122.1,53.2 U0400.J35 ; v1(191.92,69.27) 191.93,69.26 PU9800.11 ; U6803.R3 189.09,74.68 189.65,74.68 U6803.R4 U6803.T5 v1(190.19,73.62) ; U0400.AD62 v3(115.21,68.29) ; CON5104.9 194.32,20.16 v1(194.16,20.32) ; U0400.BA18 U0400.BB18 104.45,43.11 v3(104.39,43.06) ; v1(105.46,76.05) 105.46,75.08 107.08,73.46 U0400.AV71 U0400.AV70 U0400.AV69 ; U0400.AL35 v3(110.21,52.28) ; v1(157,46.43) 157,46.28 156.87,46.15 PR7829.2 ; v3(128.14,69.5) 127.88,69.5 127.8,69.57 U0400.A65 ; v1(21.72,88.46) 21.72,88.46 21.72,88.8 C5905.2 ; U0400.AW8 107,36.98 107,36.28 106.94,36.22 U0400.AW6 106.3,35.89 v3(106.28,35.92) ; v1(63.86,102.87) 64.08,102.65 CON3000.17 ; v1(191.74,20.73) 191.74,20.3 191.82,20.22 CON5104.4 ; v1(134.24,51.3) v1(135.42,51.3) 136.12,51.3 v1(136.47,51.65) v1(136.47,54.16) 136.47,55.43 136.35,55.55 v1(136.35,55.58) 136.35,56.11 135.84,56.62 133.96,56.62 v1(133.15,55.81) 132.82,55.81 132.54,55.53 C1001.1 ; PC8713.2 176.58,38.56 176.38,38.36 PU8700.16 ; U0400.AT2 108.54,34.01 v3(108.76,34.23) 108.76,34.44 U0400.AT4 108.54,34.82 U0400.AR5 ; U0400.A5 127.36,34.97 v3(127.79,34.55) ; v1(127.11,26.55) 127.15,26.51 127.15,23.86 127.26,23.75 X0900.2 ; v1(174.68,78.59) 173.86,78.59 U6000.A3 ; U0400.AL55 111.49,63.26 U0400.AM55 v3(110.58,63.26) ; CON5103.1 205.5,23.26 v1(205.16,23.6) ; U0400.AN58 v3(110.84,65.08) U0400.AL58 ; U0400.N68 119.91,71.06 v3(119.88,71.06) ; v1(174.35,99.11) 174.19,99.11 173.9,98.82 U6000.A30 ; v1(171.65,98.4) 172.03,98.02 U6000.E28 ; U0400.AA65 116.29,69.14 v3(116.15,69.14) ; v1(169.37,92.46) 169.37,92.08 U6000.H20 ; v3(124.2,61.4) 124.2,61.34 U0400.E50 ; U6000.AG12 153.91,84.7 v1(153.91,84.09) ; U0400.AA68 116.26,71.07 v3(116.13,71.07) ; U6000.C32 172.83,99.84 v1(172.44,100.23) ; v1(16.43,66.03) 16.39,66.07 U2600.3 12.9,66.07 v1(12.75,66.21) ; U6000.F22 171.51,93.5 v1(171.73,93.5) ; v1(170.81,97.6) U6000.G27 ; U0400.L4 122.01,34.44 v3(122.01,34.2) 122.01,33.9 U0400.L2 ; U6000.J7 168.83,81.18 v1(168.42,80.78) 168.06,80.42 U6000.K6 ; U0400.AL32 v3(110.13,50.45) ; CON2100.252 50.24,28.57 50.57,28.91 51.32,28.91 51.94,29.53 v1(51.94,29.6) ; U0400.BA45 v3(106.34,57.97) ; U0400.BB67 104.45,70.92 103.91,71.46 v3(103.91,71.83) ; v1(168.4,84.18) 168.4,84.25 U6000.K11 ; U0400.B39 125.98,55.38 v3(125.71,55.11) 125.45,55.38 U0400.D39 ; U0400.D62 v3(125.79,67.77) U0400.B62 ; v3(122.03,55.03) 122.04,55.03 U0400.J38 ; U0400.F68 U0400.D69 124.95,72.1 v3(124.99,72.14) ; v3(104.89,32.21) 105.05,32.37 105.05,32.63 U0400.BA1 105.13,33.17 U0400.BA2 ; v3(111.96,71.88) 112.15,72.08 U0400.AK69 ; U6000.B8 173.42,81.83 174.26,81.83 v1(174.47,81.61) ; U0400.AP10 109.73,38.01 v3(109.37,37.65) 109.37,37.48 U0400.AR8 ; v3(106.21,67.75) 106.19,67.74 U0400.BA62 ; U0400.AL38 110.01,54.11 110,54.1 v3(109.98,54.1) ; U0400.AR16 U0400.AR15 108.79,40.56 v3(108.79,40.46) ; PU7901.9 160.53,54.38 160.9,54.75 PU7901.4 161.47,55.86 162.1,55.86 v1(162.26,55.7) ; U6803.U1 v1(187.84,72.73) ; PU8700.4 175.88,34.28 175.76,34.16 v1(175.49,34.16) ; U0400.AR11 108.91,38.85 v3(108.91,38.56) ; v3(119.86,37.7) 120.04,37.7 U0400.N10 ; U6803.U3 189.23,72.94 v1(189.23,72.7) ; U0400.J8 121.51,36.74 U0400.L8 121,36.42 v3(120.88,36.42) ; U0400.T2 119.14,34.05 v3(119,34.19) 119.14,34.33 U0400.T4 119.14,35.26 U0400.R6 119.47,35.28 120.23,35.28 U0400.N6 ; U0400.AT71 108.55,73.09 108.55,73.85 v3(108.35,74.05) ; v1(171.9,86.87) 171.85,86.82 U6000.F14 ; U0400.J32 v3(122.09,51.37) ; v1(171.69,88.81) 171.62,88.81 U6000.F16 ; CON5103.21 205.38,33.26 v1(205.13,33.51) ; U0400.G55 123.62,64.06 v3(123.62,64.09) ; v1(205.12,30.98) 205.34,30.76 CON5103.16 ; U6000.F24 171.62,95.2 v1(171.65,95.2) ; U6000.H14 169.63,86.47 v1(169.67,86.44) ; v3(119.88,69.11) 119.91,69.11 U0400.N65 ; v1(171.78,83.62) U6000.F10 ; U0400.E71 124.88,73.69 v3(125.01,73.82) ; v1(174.51,79.94) 174.16,80.29 173.36,80.29 U6000.B6 ; v3(121.69,49.54) U0400.J28 ; U0400.AM8 111.04,37.32 v3(110.7,37.65) ; v3(110.64,59.59) 110.8,59.44 110.8,59.38 U0400.AM46 111.05,59.14 U0400.AL48 ; U0400.BA53 v3(106.38,62.78) ; U0400.U70 118.3,72.68 v3(117.98,72.37) 118.32,72.03 U0400.U69 ; U6803.R1 186.75,74.8 186.72,74.83 v1(186.69,74.83) ; v3(123.71,47.71) U0400.J25
  BOTTOM w0.279: PU7900.9 160.5,45.11 160.95,45.56 PU7900.4 160.95,46.61 v1(160.96,46.62) ; v1(147.89,29.02) 147.69,28.82 PU8000.4
  BOTTOM w0.305: CON2000.26 63.15,86.07 63.32,85.91 v1(63.37,85.91) ; v1(50.6,74.09) 50.58,74.07 CON2100.78 ; v1(198.33,74.8) U6803.R14 197.64,74.92 197.09,74.92 U6802.C13 ; CON5700.17 8.59,86 v1(9.19,85.4) ; v1(63.32,46.84) 63.06,46.57 CON2000.176 ; CON2100.248 50.7,29.57 v1(50.72,29.59) ; v1(198.29,105.36) 198.14,105.36 U6801.U1 ; v3(106.34,57.97) U0400.AW45 ; v1(68.43,92.03) 68.43,91.57 68.67,91.32 CON2000.5 ; v1(63.78,92.23) 63.62,92.07 CON2000.2 ; v1(56.25,37.06) 56.52,37.32 CON2100.217 ; U6000.K22 168.43,93.41 v1(168.43,93.55) ; v1(52.71,92.33) 52.71,92.86 52.5,93.07 CON2100.2 ; v1(198.36,95.56) 197.94,95.56 U6801.E1 ; v1(68.96,73.45) 69.09,73.32 CON2000.77 ; CON2100.106 50.57,67.07 50.59,67.09 v1(50.67,67.09) ; CON2000.243 66.96,29.82 66.32,29.19 v1(66.32,28.56) ; CON2000.56 63.22,78.57 v1(63.32,78.68) ; v1(193.12,76.74) 193.57,77.2 U6803.M10 194.35,77.42 194.35,77.78 U6803.L10 ; U0400.AK68 111.96,71.58 v3(111.96,71.88) ; v1(214.83,9.97) 214.94,9.85 CON3100.45 217.62,9.85 v1(217.86,10.09) ; CON2100.1 56.44,93.32 v1(56.13,93.63) ; v1(50.65,47.6) 50.62,47.57 CON2100.176 ; CON2000.256 62.08,26.57 61.01,26.57 v1(60.64,26.94) ; v1(217.2,14.23) 217.07,14.35 CON3100.27 ; v1(69.04,80.61) 69.25,80.82 CON2000.47 ; U6801.M5 193.99,100.41 v1(193.99,100.33) 194.14,100.18 U6801.L5 ; v1(198.3,73) 198.11,73.2 U6803.U14 ; v1(50.77,37.32) 50.53,37.07 CON2100.218 ; v1(56.29,72.34) 56.31,72.32 CON2100.85 ; v1(50.81,42.59) 50.79,42.57 CON2100.196 ; CON2100.86 51.64,72.07 v1(52.63,73.06) ; CON2000.244 64.59,29.57 64.74,29.42 v1(64.74,28.88) ; v1(157.25,95.2) U6000.AC24 ; CON2000.10 63.15,90.07 v1(63.37,90.3) ; CON2000.65 69.27,76.32 v1(69.04,76.56) ; U6801.R4 195.36,103.37 v1(195.73,103) 195.78,103 U6801.R3 ; CON2100.188 51.02,44.57 51.82,43.78 v1(51.82,43.6) ; v1(69.04,66.93) 69.14,66.82 CON2000.103 ; v1(50.76,30.78) 50.55,30.57 CON2100.244 ; v1(67.79,87.84) 67.79,88.14 68.48,88.82 CON2000.15 ; v1(55.01,84.03) 55.01,84.28 55.55,84.82 CON2100.35 ; CON2000.1 69.22,92.32 69.09,92.46 v1(69.09,92.69) ; v1(54.81,89.08) 54.81,88.67 55.66,87.82 CON2100.23 ; v1(50.57,81.57) CON2100.48 ; v1(64.59,78.65) 64.59,78.31 63.86,77.57 CON2000.60 ; U6000.AE14 156.03,86.69 v1(155.7,86.36) ; v1(69.04,40.12) 69.24,40.32 CON2000.201 ; CON2100.43 55.51,82.82 54.79,82.1 v1(54.79,81.88) ; CON2000.238 63.3,31.07 v1(63.37,31.14) ; U6800.J1 197.76,98.59 v1(198.14,98.97) ; CON2100.81 55.66,73.32 55.04,72.71 v1(55.04,72.35) ; v1(50.57,43.59) 50.55,43.57 CON2100.192 ; CON2100.93 56.41,70.32 56.41,70.34 v1(55.96,70.79) ; v1(63.58,84.67) 63.58,84.77 63.27,85.07 CON2000.30 ; CON2000.231 71.6,32.82 71.71,32.72 v1(71.72,32.72) ; U6000.M6 166.43,79.84 v1(166.37,79.78) ; CON2000.23 68.5,86.82 67.79,86.11 v1(67.79,85.88) ; v1(55.02,75.3) 55.02,74.89 55.58,74.32 CON2100.77 ; v1(54.28,79.34) 54.28,80.07 55.03,80.82 CON2100.51 ; v1(53.67,31.7) 53.67,31.14 53.99,30.82 CON2100.243 ; v1(214.77,17.54) 214.96,17.35 CON3100.15 ; CON2000.180 63.42,45.57 63.58,45.42 64.07,45.42 64.49,45.84 v1(64.49,45.93) ; v1(51.26,50.68) 51.26,50.27 51.06,50.07 CON2100.166 ; CON2000.202 63.2,40.07 v1(63.32,39.96) ; CON2000.247 69.11,28.82 68.85,28.56 v1(67.59,28.56) ; U6803.C3 188.99,84.4 v1(189.37,84.78) 189.75,84.4 U6803.C4 ; v1(68.76,45.52) 68.95,45.33 70.27,45.33 CON2000.181 ; v1(67.77,43.36) 67.77,43.87 68.22,44.32 CON2000.185 ; v1(50.62,70.34) 50.35,70.07 CON2100.94 ; CON2000.22 63.6,87.07 64.62,86.06 v1(64.62,85.88) ; CON2000.94 63.72,69.07 64.14,69.49 v1(64.14,69.88) ; v1(170.85,83.23) 170.46,83.62 U6000.G10 ; CON2100.175 55.66,47.82 54.25,46.42 v1(54.25,46.09) ; v1(191.06,94.83) 190.8,94.58 U6801.D10 ; CON2100.36 50.55,84.57 v1(50.57,84.59) ; v1(157.25,83.19) 157.62,82.82 U6000.AC9 ; v1(56.27,28.85) 56.29,28.82 CON2100.251 ; 106.31,53.01 U0400.BA36 ; v1(52.55,79.06) 52.2,79.41 50.6,79.41 50.43,79.57 CON2100.56 ; v1(193.6,82.68) 194.28,82 U6803.F10 ; CON2000.40 63.31,82.57 v1(63.37,82.51) ; v1(186.8,84.52) 186.92,84.4 U6803.C1 ; CON2100.99 56.43,68.82 v1(56.16,69.1) ; U6801.C1 198.08,94.1 v1(198.26,94.1) ; v1(63.32,87.86) 63.11,88.07 CON2000.18 ; CON2100.73 56.34,75.32 56.3,75.28 v1(56.29,75.28) ; v1(50.75,35.09) 50.73,35.07 CON2100.226 ; CON2000.197 68.97,41.32 68.81,41.49 v1(68.81,41.61) ; v1(66.9,78.64) 66.9,79.35 67.38,79.82 CON2000.51 ; v1(63.45,80.61) 63.41,80.57 CON2000.48 ; v1(50.72,32.04) 50.69,32.07 CON2100.238 ; U6801.T10 v1(190.97,103.77) 191.33,103.41 191.33,103.35 U6801.P10 ; v1(55.05,28.85) 55.05,28.95 55.92,29.82 CON2100.247 ; CON2000.260 61.11,25.57 60.88,25.35 v1(60.88,24.77) ; v1(69.01,69.82) 69.01,69.45 69.13,69.32 CON2000.93 ; U6803.R12 195.98,74.61 195.56,74.61 U6803.R11 ; v1(67.15,99.9) 67.08,99.97 CON3000.23 ; CON2100.201 54.67,41.32 53.77,42.23 v1(53.77,42.63) ; v1(64.72,80.61) 64.72,80.84 63.98,81.57 CON2000.44 ; CON2000.82 63.79,72.07 64.64,71.22 v1(64.64,71.12) ; v1(165.16,80) 165.16,80.08 U6000.P6 ; CON2000.6 64.33,91.07 64.64,90.76 v1(64.64,90.3) ; U6803.T10 194.57,74.02 v1(194.97,74.42) 194.99,74.42 U6803.R11 ; v1(53.84,77.46) 54.98,76.32 CON2100.69 ; CON2100.14 v1(50.65,90.07) ; U6000.H17 169.16,89.88 v1(169.16,90) ; PR8706.2 172.87,40.41 v1(172.59,40.41) ; v1(186,92.92) 186,92.64 186.46,92.18 U6801.A14 187.79,91.75 188.53,91.75 U6801.A12 ; CON2100.210 50.7,39.07 v1(50.72,39.09) ; v1(56.29,39.34) 56.31,39.32 CON2100.209 ; U6801.H2 196.97,97.78 v1(197.37,98.19) 197.37,98.17 U6801.H1 ; U0400.BB70 v3(104.67,74.6) ; CON3000.26 68.58,102.9 v1(68.58,102.9) ; CON3100.3 216.91,20.35 v1(217.27,19.99) 217.53,20.25 217.53,20.58 217.25,20.85 CON3100.1 ; v1(56.26,67.84) 56.28,67.82 ; 56.28,67.82 CON2100.103 ; 56.28,67.82 56.28,67.04 56.49,66.82 CON2100.107 ; v1(67.35,46.77) 67.35,46.85 68.14,47.63 69.12,47.63 69.31,47.82 CON2000.171 ; v1(195.72,105.41) U6801.U3 ; v1(186.69,76.42) 186.71,76.4 U6803.N1 ; U6801.T5 194.01,104.73 v1(194.01,105.03) ; v1(67.01,102.34) 66.01,102.34 65.58,101.91 CON3000.20 ; U6801.F10 190.67,96.18 v1(191.12,96.63) 190.78,96.98 U6801.G10 ; U6803.C14 198.18,83.99 v1(198.18,83.96) ; CON3101.4 115.68,11.94 v1(115.57,11.83) ; v1(186.04,97.27) 186.55,97.78 U6801.H14 187.46,97.88 188.06,97.88 U6801.H13 ; CON2100.231 56.38,33.82 56.16,33.61 56.16,33.59 55.85,33.28 55.3,33.28 55.03,33.55 v1(55.03,33.78) 55.03,33.89 55.5,34.37 55.7,34.37 56.16,34.82 CON2100.227 ; CON2000.192 63.85,42.57 64.57,41.86 v1(64.57,41.61) ; v1(50.62,91.07) CON2100.10 ; CON2100.230 50.7,34.07 v1(50.72,34.09) ; U6801.B5 v1(194.98,93.4) U6801.C4 195.45,93.69 196.07,93.69 U6801.C3 ; v1(50.72,41.07) CON2100.202 ; U6803.C12 195.81,84.76 v1(195.76,84.76) 195.73,84.76 U6803.C11 ; v1(198.28,76.1) 198.06,76.1 U6803.N14 ; v1(193.58,84.06) 193.93,83.71 194.46,83.71 U6803.D10 ; CON2000.72 64.15,74.58 65.33,73.4 v1(65.33,73.33) ; v1(68.63,46.78) 68.68,46.82 CON2000.175 ; v1(50.62,89.07) CON2100.18 ; U6000.G8 U6000.F8 v1(171.76,82.02) ; CON2100.44 51.73,82.57 52.48,81.83 v1(52.48,81.62) ; v1(162.72,80.93) U6000.T6 ; v1(185.8,94.62) 185.8,94.11 186.13,93.78 U6801.C14 ; U6803.K13 197.11,78.66 197.63,78.66 U6803.K14 197.85,78.8 v1(198.27,78.38) ; CON2100.102 v1(50.68,68.07) ; v1(64.59,39.09) 64.59,38.64 64.03,38.07 CON2000.210 ; CON2000.69 69.03,75.32 69.01,75.34 v1(68.94,75.34) ; CON2000.189 69.05,43.32 v1(69.01,43.36) ; v1(159.36,96.09) 159.83,95.62 U6000.Y25 ; CON2000.251 69.22,27.82 69.19,27.79 68.84,27.79 68.43,27.38 v1(68.43,27.31) ; v1(56.19,89.89) 56.26,89.82 CON2100.15 ; CON2100.223 56.15,35.82 v1(55.4,35.08) ; v1(51.47,92.32) 51.04,91.88 50.51,91.88 50.32,92.07 CON2100.6 ; CON2000.78 63.06,73.07 v1(63.31,73.32) ; v1(189.52,86.54) 189.52,86.49 189.12,86.09 189.06,86.09 U6803.A3 ; v1(64.64,82.51) 64.64,82.73 63.8,83.57 CON2000.36 ; 189.36,102.97 v1(189.36,102.96) ; 189.36,102.97 189.36,102.98 U6801.R12 ; 189.36,102.97 189.76,103.37 U6801.R11 ; CON2000.81 68.24,72.32 67.74,72.83 v1(67.74,73.43) ; CON2100.90 v1(50.58,71.07) ; U6803.N12 196.17,76.38 v1(195.79,76) ; U6803.R11 U6803.P10 ; U6803.B10 U6803.C11 ; U6803.C11 195.37,84.36 v1(194.96,83.96) ; CON2000.107 69.1,65.82 68.4,66.53 v1(68.4,66.91) ; CON2100.72 v1(50.58,75.57) ; v1(69.04,87.84) 69.06,87.82 CON2000.19 ; v1(188.63,105.41) 188.63,105.31 U6801.U12 ; v1(52.01,37.29) 52.01,37.67 51.6,38.07 CON2100.214 ; v1(56.19,48.92) 56.19,48.9 56.26,48.82 CON2100.171 ; v1(54.89,93.65) 54.89,93.3 55.86,92.32 CON2100.5 ; v1(116.23,16.64) 117.18,15.69 CON3101.1 ; U6803.B5 190.57,85.17 v1(190.96,84.77) ; v1(153.63,100.71) U6000.AH32 ; v1(50.72,33.07) CON2100.234 ; v1(60.99,101.55) 61.08,101.46 CON3000.11 ; U1204.3 96.03,15.11 96.25,15.33 96.25,17.59 v1(96.37,17.71) ; CON3100.71 214.98,3.35 v1(214.76,3.13) 215.03,2.85 CON3100.73 ; U6000.AD6 157.2,80.79 v1(157.2,80.83) ; U6803.E14 197.74,82.8 v1(197.35,82.41) ; CON2100.222 50.7,36.07 v1(50.75,36.03) ; v1(66.52,85.88) 66.52,85.32 67.02,84.82 CON2000.31 ; CON2100.52 v1(50.58,80.57) ; v1(186.25,85.45) 186.25,85.5 186.75,86 U6803.A1 ; v1(158.04,80.83) 158.43,80.43 U6000.AB6 ; v1(153.91,84.09) 153.91,83.9 U6000.AH10 ; CON2000.234 63.97,32.07 64.59,32.69 v1(64.59,32.97) ; U6801.K2 196.96,99.38 v1(197.34,99) ; v1(64.01,49.58) 64.01,49.43 63.65,49.07 CON2000.166 ; v1(56.08,89.08) 56.34,88.82 CON2100.19 ; v1(54.99,37.07) 54.99,37.5 55.81,38.32 CON2100.213 ; v1(69.04,38.41) 69.12,38.32 CON2000.209 ; U6000.F18 171.14,89.93 v1(170.7,89.93) ; v1(67.82,30.44) 67.82,31.42 68.22,31.82 CON2000.235 ; v1(198.16,80.77) 197.8,80.4 U6803.H14 197.62,80.25 197.12,80.25 U6803.H13 ; v1(50.65,45.6) 50.63,45.57 CON2100.184 ; v1(63.32,65.96) 63.21,66.07 CON2000.106 ; CON2000.248 63.32,28.57 63.45,28.7 v1(63.45,28.86) ; v1(155.07,100.74) 155.23,100.58 U6000.AF32 ; v1(63.37,39.09) 63.35,39.07 CON2000.206 ; CON2100.47 56.1,81.82 v1(56.08,81.84) ; v1(156.45,81.64) 156.45,81.64 U6000.AD8 ; U6801.N14 187,102.13 186.91,102.13 v1(186.03,103.01) ; v1(63.5,69.88) 63.3,70.07 CON2000.90 ; U6000.Y10 v1(159.27,83.62) U6000.AB10 ; CON2000.64 63.3,76.57 v1(63.32,76.56) ; CON2100.206 51.1,40.07 51.94,39.23 v1(51.94,39.08) ; CON2000.35 68.56,83.82 67.67,82.93 v1(67.67,82.53) ; v1(55,42.63) 55,42.79 55.53,43.32 CON2100.193 ; v1(56.27,42.6) 56.54,42.32 CON2100.197 ; U6000.AC27 v1(158.14,96.7) ; CON3101.7 114.18,14.03 113.77,13.62 v1(113.44,13.62) ; CON2000.61 68.43,77.32 67.74,76.64 v1(67.74,76.57) ; v1(50.57,88.09) 50.55,88.07 CON2100.22 ; v1(48.06,48.6) 48.08,48.57 CON2100.172 ; v1(56.21,31.75) 56.28,31.82 CON2100.239 ; CON2100.27 56.26,86.82 v1(56.21,86.87) ; CON2000.9 68.95,90.32 v1(68.94,90.31) ; CON3100.21 216.85,15.85 v1(217.15,15.55) ; CON2000.205 69.32,39.32 69.24,39.25 68.11,39.25 67.77,38.91 v1(67.77,38.4) ; v1(158.82,97.63) U6000.AA27 ; v1(63.35,37.36) 63.07,37.07 CON2000.214 ; CON2100.82 50.58,73.07 v1(50.6,73.09) ; CON2100.60 v1(50.7,78.57) ; CON2000.98 63.29,68.07 v1(64.97,69.75) ; CON2000.223 68.99,34.82 v1(68.94,34.78) ; CON2100.9 56.41,91.32 56.23,91.14 v1(55.95,91.14) ; CON2000.193 68.43,42.32 67.92,41.81 v1(67.92,41.61) ; CON2000.73 67.44,74.32 67.02,74.74 v1(67.02,75.35) ; CON2100.205 55.76,40.32 55.02,39.59 v1(55.02,39.36) ; CON2100.61 56.41,78.32 v1(56.26,78.47) ; v1(195.68,72.75) 196.14,73.2 U6803.U12 ; v1(56.26,79.35) 56.28,79.32 CON2100.57 ; v1(65.86,78.65) 65.86,79.02 65.31,79.57 CON2000.52 ; v1(69.04,71.6) 69.31,71.32 CON2000.85 ; CON2100.167 56.31,49.82 55.63,50.51 v1(55.63,50.86) ; U6801.N3 196.17,101.78 v1(196.55,101.4) ; CON2000.188 63.35,43.57 v1(63.46,43.47) ; v1(111.74,16.4) 111.74,16.51 112.19,16.96 C3125.2 ; U6000.AB24 158.96,94.49 v1(159.16,94.49) ; CON3000.5 58.08,101.32 58.18,101.41 v1(58.18,101.83) ; U6801.M10 190.97,100.56 v1(190.97,100.53) 190.9,100.53 U6801.L10 ; U6000.AH28 153.62,98.02 v1(153.23,98.41) ; v1(217.81,6.38) 217.33,6.85 CON3100.57 ; CON2000.184 64.04,44.57 64.74,43.87 v1(64.74,43.44) ; 187.76,102.99 187.75,102.99 U6801.R14 ; 187.76,102.99 U6800.C13 ; 187.76,102.99 v1(187.78,102.99) ; CON5700.18 8.93,88 v1(9.2,87.73) ; v1(68.96,82.53) 69.26,82.82 CON2000.39 ; v1(197.36,102.18) U6801.N1 ; v1(194.09,97.43) 194.54,96.98 U6801.G5 ; CON2100.235 56.57,32.82 56.38,32.64 55.7,32.64 55.3,32.24 54.96,31.9 v1(54.96,31.73) ; CON2100.168 51.45,49.57 v1(51.46,49.58) ; v1(198.15,85.58) 197.77,85.96 U6803.A14 ; v1(64.54,87.86) 64.54,88.29 63.76,89.07 CON2000.14 ; U6801.C12 U6801.C11 U6801.B10 190.87,92.98 v1(191.14,93.25) ; U6801.E12 189.33,95.01 v1(189.33,94.97) ; v1(156.79,100.26) 156.83,100.22 U6000.AD32 ; v1(67.82,80.61) 67.82,80.72 68.79,81.69 69.16,81.69 69.3,81.82 CON2000.43 ; CON2100.89 55.73,71.32 55.6,71.2 v1(55.22,70.82) ; U6801.E3 196.16,95.38 v1(196.54,95.76) ; v1(214.82,2.3) 214.87,2.35 CON3100.75 ; v1(196.58,86.54) 196.17,86.12 U6803.A12 ; CON2100.98 v1(50.57,69.07) ; v1(50.63,87.07) CON2100.26 ; v1(186.03,104.5) 186.03,104.85 186.46,105.29 187.02,105.29 187.33,104.98 U6801.U14 ; v1(193.88,96.1) 193.95,96.18 U6801.F5 ; U6000.U9 162.52,83.11 v1(162.71,83.11) ; CON2000.89 68.5,70.32 68.37,70.2 v1(68.37,69.83) ; v1(217.09,12.85) CON3100.33 ; v1(51.89,47.55) 51.89,47.04 51.31,46.46 50.51,46.46 50.39,46.57 CON2100.180 ; v1(186.81,80.37) 186.83,80.4 U6803.H1 U6803.H2 ; U6000.AC26 v1(157.24,96.03) U6000.AD25 ; v1(71.58,30.46) 71.21,30.82 CON2000.239 ; CON2000.86 63.3,71.07 v1(63.32,71.09) ; v1(170.08,80.02) 170.03,80.02 U6000.H6 ; v1(64.57,65.96) 64.57,66.35 63.84,67.07 CON2000.102 ; U6803.L5 190.69,78 v1(191.2,77.49) 190.91,77.2 U6803.M5 ; v1(63.35,32.97) 63.24,33.07 63.2,33.07 CON2000.230 ; v1(214.83,8.03) 214.83,8.07 215.1,8.35 CON3100.51 ; v1(68.05,35.97) 68.05,36.83 68.54,37.32 CON2000.213 ; CON3100.9 v1(214.78,18.85) ; v1(198.23,103.65) 198.03,103.65 U6801.R1 ; CON2000.222 64.14,35.07 64.17,35.11 64.59,35.11 65.01,34.68 v1(65.01,34.6) 65.01,34.51 64.38,33.89 63.23,33.89 63.04,34.07 CON2000.226 ; U6000.P9 164.64,82.82 v1(165.26,82.82) ; U6803.K1 187.37,78.81 v1(187.76,79.2) 188.17,78.8 U6803.K2 ; v1(188.56,82.41) 188.95,82.8 U6803.E3 ; CON2100.39 56.45,83.82 v1(56.26,84.02) ; v1(153.92,96.98) 154.16,97.22 U6000.AG27 ; v1(198.17,92.59) U6801.A1 ; v1(69.04,85.87) 69.08,85.82 CON2000.27 ; v1(186.61,83.26) 187.07,82.8 U6803.E1 ; U6803.E12 196.18,82.8 v1(196.57,82.4) ; v1(55,44.38) 55,44.48 55.69,45.17 56.37,45.17 56.52,45.32 CON2100.185 ; v1(67.16,66.93) 67.16,67.34 67.65,67.82 CON2000.99 ; CON2100.65 56.42,77.32 v1(56.24,77.51) ; CON2000.57 69.13,78.32 68.9,78.56 v1(68.9,78.64) ; CON2100.64 51.67,77.57 52.5,76.75 v1(52.5,76.54) ; CON2100.181 56.5,46.32 56.33,46.15 v1(56.26,46.15) ; CON2100.30 v1(50.6,86.07) ; U6803.G10 194.18,81.2 v1(194,81.02) ; v1(50.58,83.57) CON2100.40 ; CON2100.31 55.33,85.82 v1(55.14,85.64) ; U6801.N12 v1(188.58,101.4) ; v1(64.74,49.56) 63.76,48.57 CON2000.168 ; v1(64.57,46.87) 64.57,47.02 64.01,47.57 CON2000.172 ; v1(67.67,32.88) 67.67,33.32 68.18,33.82 CON2000.227 ; v1(186.46,98.99) 186.86,99.38 U6801.K14 U6801.K13 ; U6803.F5 U6803.G5 190.91,80.86 v1(191.02,80.86) ; CON2000.217 71.4,36.32 v1(71.91,36.83) ; CON2000.252 63.89,27.57 64.14,27.33 v1(64.14,26.95) ; CON2100.256 50.51,27.57 50.89,27.95 v1(50.89,28.15) ; U6801.K1 198.23,99.85 v1(198.25,99.85) ; v1(64.59,76.57) 64.59,76.15 64.02,75.57 CON2000.68 ; v1(195.9,91.7) 195.9,91.92 U6801.A3 ; U6000.AC17 157.63,89.69 v1(157.89,89.94) ; v1(63.32,41.6) 63.3,41.57 CON2000.196 ; v1(68.96,49.15) 68.96,48.95 69.09,48.82 CON2000.167 ; U6000.AE7 v1(155.63,80.82) ; CON3100.39 v1(217.09,11.35) ; CON2100.68 v1(50.62,76.57) ; v1(155.62,97.63) U6000.AE27 ; CON2000.218 63.78,36.07 64.62,36.91 v1(64.62,37.37) ; CON2100.189 v1(56.24,44.32)
  BOTTOM w0.356: U1200.3 96.37,28.43 v1(96.12,28.17) ; C5808.2 17.83,68.28 18.64,68.28 19.51,69.14 v1(19.51,69.7) ; Q5102.1 45.89,4.51 46.26,4.89 v1(46.26,5.22) ; v1(74.38,18.08) 74.07,18.08 73.62,18.53 U1201.3 ; U1202.3 72.48,15.97 72.36,15.84 v1(72.21,15.84) ; v1(98.7,31.5) 98.78,31.57 R1207.2 ; Q3101.1 154.23,15.1 v1(154.42,14.91) ; v1(99.66,23.82) 99.66,23.95 100.1,24.4 U1203.3 ; v1(157.51,17.07) 157.26,17.31 Q3101.4 ; U1800.3 78.93,18.66 v1(78.46,19.13) ; Q5002.1 16.09,86.54 v1(16.42,86.21) ; v1(137.26,88.6) 136.9,88.23 U6001.3 ; v1(17.93,84.28) 17.93,84.36 17.66,84.63 Q5002.4 ; U3700.5 132.31,91.19 v1(131.6,91.9) ; C3841.2 14.87,55.7 v1(15.11,55.46) ; v1(142.86,89.91) 142.4,89.45 U6903.3
  BOTTOM w0.381: v1(112.56,27.34) 112.79,27.57 112.79,28.06 R1411.2 ; C3601.2 C3600.2 v1(209.3,84.94) ; v1(147.29,80.16) 147.29,80.55 147.68,80.93 PC9422.2
  BOTTOM w0.406: v1(133.93,62.66) 133.81,62.79 R0420.1
  BOTTOM w0.432: R1301.2 108.12,27.97 108.13,27.96 v1(108.17,27.96) ; C5117.2 70.62,16.24 v1(70.84,16.46) ; v1(71.6,15.85) 71.56,15.81 C5123.2 ; C1105.2 98.78,29.52 v1(98.68,29.42) ; v1(202.57,64.21) 202.57,64.1 PC8911.2 ; v1(20.32,77.14) R5700.2 R5701.2 ; R6307.2 164.14,102.72 v1(164.21,102.64) ; v1(59.45,96.86) 59.45,97.1 59.77,97.41 C3002.2 60.35,97.41 C3001.2 ; PC8919.2 177.67,58.6 v1(178.11,58.17) ; 183.93,97.36 183.93,98.39 C6801.2 ; v1(63.07,96.47) 63.07,96.65 62.33,97.39 62.33,97.46 C3011.2 ; U6000.V11 161.04,84.8 v1(160.97,84.8) ; v1(102.97,95.42) 103.04,95.35 103.73,95.35 PC9402.2 ; R6006.2 161.95,73.38 PC9503.2 ; PU8600.25 101,96.51 101.22,96.29 PR9443.1 ; v1(190.58,62.97) 190.58,63.3 PR9808.1 ; PC8903.2 200.28,55.22 200.69,54.82 v1(200.69,54.71) ; v1(146.58,91.62) 147,91.2 C6200.2 ; U6000.N11 164.75,84.9 v1(164.75,84.94) U6000.R11 ; D3001.2 55.73,98.07 v1(56.1,97.7) ; v1(17.76,56.96) 17.76,57.23 18.26,57.74 PR7610.2 ; C3839.1 22.8,30.21 v1(22.88,30.28) ; v1(148.55,90.43) 148.27,90.71 R6201.2 ; v1(115.57,103.62) 115.19,104 PC9413.2 ; v1(13.03,75.57) 13.41,75.57 13.51,75.67 C5809.2 ; U6000.Y20 159.94,91.7 v1(159.94,91.85) ; PC9105.2 178.77,17.91 v1(178.44,18.24) ; v1(125.68,88.57) 125.91,88.57 C3700.2 ; v1(103.14,98.9) 103.53,98.5 PR9437.1 ; v1(127.11,26.55) 126.77,26.55 126.54,26.78 C0900.1 ; C6601.2 v1(183.54,94.19) ; v1(19.38,23.88) 19.3,23.8 C3802.2 ; v1(176.99,43.54) 176.91,43.54 176.28,44.17 PC7831.2 ; U6000.Y15 160.43,87.43 v1(159.99,87.86) 159.44,88.42 U6000.AA16 ; PC9406.1 118.54,102.52 118.58,102.48 119.22,102.48 v1(119.52,102.78) ; PC8002.2 142.55,28.27 141.76,27.49 v1(141.76,26.88) ; PC8808.2 106.6,113.69 v1(106.55,113.64) ; U6000.R12 164.23,85.43 v1(163.78,85.88) 163.24,86.42 U6000.T13 ; v1(144.48,78.03) 144.48,77.52 144.6,77.4 R6914.2 ; PC9605.2 135.18,97.59 v1(134.95,97.82) ; v1(149.68,20.45) 149.35,20.78 R1520.2 ; v1(172.49,56.64) 172.67,56.82 172.73,56.82 PC7815.2 ; v1(180.37,49.3) 180.29,49.38 PC7814.2 ; v1(164.71,91.85) 164.71,91.7 U6000.R20 U6000.N18 ; C1207.2 96.57,25.89 v1(96.39,26.06) ; PC7820.2 v1(174.75,56.67) 174.85,56.77 PC7841.2 ; C5108.2 68.74,15.76 68.86,15.88 v1(68.89,15.88) ; C5102.2 83.34,14.58 83.34,15.14 v1(83.35,15.14) ; R1225.1 101.52,27.64 C1200.2 102.06,26.93 v1(102.11,26.98) ; C5132.2 81.61,14.51 v1(81.61,15.12) ; PC9201.2 135.01,24.08 v1(134.67,24.08) ; PC7713.2 194.36,30.23 194.46,30.33 v1(194.46,30.51) ; C0901.1 130.63,27.1 v1(130.25,26.72) ; v1(21.72,88.46) 21.91,88.46 22.02,88.34 22.05,88.34 22.38,88.01 R5903.1 ; R1410.2 111.58,28.09 111.3,28.37 v1(111.3,28.7) ; PC8917.2 203.94,58.27 v1(203.91,58.3) PR8923.1 ; v1(84.21,15.14) 84.21,14.93 84.31,14.83 C5101.2 ; R1400.2 115.19,27.23 114.9,27.52 v1(114.76,27.52) ; v1(179.32,10.39) 179.4,10.39 179.94,10.94 179.95,10.94 180.02,11.01 PC9101.2 ; PR9104.2 178.71,10.85 v1(178.71,10.37) ; v1(167.08,67.86) 167.5,67.86 168.12,67.24 PR9502.2 ; C5110.2 66.79,15.83 v1(66.84,15.88) ; v1(177.62,43.54) 177.62,43.87 PC7835.1 ; PR9457.1 107.29,102.53 PC9405.1 106.81,101.63 v1(106.72,101.72) ; v1(201.85,31.02) 201.65,31.22 PR7709.2 ; U6000.M12 v1(165.73,85.92) U6000.N13 ; v1(162.08,53.04) 161.7,52.66 PC7909.2 ; v1(22.96,74.15) 22.71,73.89 R5820.2 ; C5122.2 v1(69.71,15.88) ; v1(134.24,51.3) 133.79,50.85 C1000.1 ; R2416.2 99.72,14.15 100.23,13.64 v1(100.23,13.67) ; v1(109.63,21.92) 109.55,21.85 C1006.2 ; 158.88,87.02 158.88,86.97 159.43,86.42 U6000.AA13 ; 158.88,87.02 v1(158.88,87.02) ; 158.88,87.02 158.87,87.02 158.83,87.02 U6000.AB15 ; U6000.T16 163.35,88.42 v1(163.73,88.04) 163.73,87.92 U6000.R15 ; v1(118.76,21.25) 118.76,21.87 R1512.2 ; U6000.AA11 159.01,84.84 v1(158.98,84.84) ; v1(86.01,15.17) 86.1,15.08 86.1,14.84 86.14,14.8 C5104.2 ; v1(97.31,14.84) 97.31,15.78 C1206.2 ; v1(158.71,40.57) 158.6,40.68 PC7900.2 ; PC9110.2 195.81,50.02 v1(195.3,50.02) ; PC7721.2 PR7716.2 201.35,28.23 v1(201.71,28.23) ; PC7823.2 175.52,54.02 v1(175.52,54.43) ; C5109.2 85.23,14.75 85.23,15.01 v1(85.07,15.17) ; R1019.2 107.7,23.78 107.19,24.29 v1(107.19,24.9) ; v1(131.83,54.76) 132.34,54.76 C1001.1 ; C3840.2 22.49,34.5 v1(23.03,34.5) ; D3806.2 16.38,39.45 v1(16.92,39.98) ; v1(173.48,18.35) 173.47,18.35 172.96,18.86 C5125.2 ; v1(194.51,62.66) 194.51,63.25 194.59,63.33 PR9806.1 194.08,63.6 194.06,63.58 PR9807.1 ; v1(175.44,32.24) 175.9,32.24 PC8705.2 ; v1(165.79,104.51) 165.93,104.37 R6303.1 ; v1(53.63,9.32) 53.73,9.43 CON5100.5 ; U6000.V18 161.98,89.67 v1(161.98,89.66) 161.98,89.66 U6000.U17 ; v1(22.73,25.91) 22.71,25.93 C3816.2 22.07,26.55 C3814.2 ; C1900.2 104.41,17.55 v1(103.87,18.1) ; v1(144.53,81.23) 144.63,81.13 PR9459.2 ; U6000.V13 v1(160.96,85.95) ; U6000.N21 164.84,92.61 v1(164.72,92.61) ; C1004.2 96.47,44.68 v1(96.37,44.78) ; C6604.2 v1(195.72,105.41) ; PC9419.2 117.53,93.44 v1(117.39,93.58) 116.99,93.58 PR9436.2 ; C7008.2 v1(184.05,109.37) ; v1(13.72,20.91) 13.49,21.14 R3822.2 ; PC9102.2 179.71,17.78 v1(179.25,18.24) ; PC8622.1 79.71,104.12 79.91,104.32 79.91,104.93 v1(79.38,105.46) ; v1(148.36,85.78) 148.06,86.08 147.75,86.08 147.68,86.16 C6901.2 ; v1(201.38,75.18) 201.34,75.14 R6819.1 ; C5100.2 v1(82.48,15.14) ; U6000.Y17 160.43,89.23 v1(159.99,89.66) ; v1(146.81,81.82) 146.56,82.07 PC9421.2 ; C6900.2 148.49,89.16 v1(148.95,88.7) ; v1(178.36,43.56) 178.23,43.69 PR7849.1 ; v1(159.44,75.57) 159.44,75.52 159.33,75.42 159.33,74.93 160.3,73.97 R6907.1 ; PC8713.2 v1(177.17,39) ; 4.5,93.07 CON5700.21 ; v1(198.4,63.07) PC8901.2 ; v1(163.75,84.89) 163.7,84.89 U6000.T11 ; v1(12.65,20.55) 12.24,20.55 12.01,20.78 C3843.2 ; v1(134.67,23.47) 135.19,23.47 PC9204.2 ; PC7806.2 178.02,54.79 v1(177.54,54.79) ; C7006.2 C7005.2 190.3,107.93 v1(190.14,108.08) ; v1(105.56,91.01) 106.25,91.7 PC9414.2 ; C6606.2 v1(183.54,76.35) ; PC7716.2 195.07,30.2 v1(195.07,30.5) ; PC9418.2 112.83,91.59 v1(112.75,91.52) ; U6000.U20 161.94,91.71 v1(161.94,91.85) ; PC9411.2 109.07,91.49 109.19,91.37 110.67,91.37 v1(110.8,91.49) ; C6302.2 v1(163.53,104.4) ; v1(86.87,15.16) 86.97,15.06 86.97,14.64 C5106.2 ; 191.74,111.81 C7001.2 ; X0900.4 130.84,25.91 v1(130.84,26.44) ; PC7714.2 192.18,21.74 191.87,22.05 v1(191.87,22.41) ; v1(15.29,52.91) 15.36,52.85 D3802.1 ; C3603.2 207.86,88.57 v1(207.86,88.55) ; v1(173.14,54.55) 173.25,54.43 PC7812.1 ; v1(164.74,87.99) 165.17,88.42 U6000.N16 ; PC8902.2 v1(199.8,63.07) ; R7003.2 191.24,110.42 190.96,110.14 v1(190.65,110.14) ; PC7822.2 181.43,49.76 181.53,49.86 PC7816.1 182.17,50.29 v1(182.22,50.24) ; R6305.2 168.48,103.38 168.08,103.77 v1(168.08,104.05) 168.35,104.32 C6301.2 ; v1(142.7,83.14) 142.67,83.14 142.8,83.01 PR9458.2 ; v1(16.36,41.76) 16.23,41.63 R3818.1 ; v1(203.2,25.4) 203.2,25.53 202.79,25.94 PC7723.2 ; PC9404.2 111.38,105.13 111.48,105.03 v1(111.48,104.7) ; C5107.2 65.87,15.76 v1(65.99,15.88) ; PR9101.2 181.25,10.49 v1(181.08,10.32) ; C5121.2 v1(67.7,15.9) ; v1(113.98,107.06) PC9403.1 ; C1901.2 18.92,49.61 v1(19.02,49.51) ; C6016.2 140.06,88.22 v1(140.25,88.41) ; PR9460.2 146.46,79.25 146.63,79.07 v1(146.63,78.31) 146.62,78.32 PC9423.2 ; 176.35,31.52 175.01,31.52 v1(174.9,31.42) ; v1(130.28,30) 130.59,29.68 C1610.2 ; U6000.T21 163.23,92.3 v1(162.81,92.71) ; U6000.R17 v1(163.77,89.68) U6000.T18 ; C1104.2 C1617.2 99.72,29.44 v1(99.7,29.42) ; C0400.2 132.69,75.52 v1(132.18,76.02) ; v1(183.54,93.31) 183.61,93.31 183.67,93.25 C6612.2 ; v1(201.75,79.99) R6816.1 ; C3803.2 19.36,24.77 v1(19.38,24.74) ; v1(159.49,60.86) 159.44,60.91 PR7830.1 ; v1(80.98,15.12) 80.6,14.74 C5103.2 ; C5105.2 v1(64.93,15.89) ; v1(184,110.09) 184.48,110.09 C7007.2 ; C3833.2 22.61,33.27 22.65,33.23 v1(23.06,33.23) ; v1(21.93,86.85) 21.44,86.85 R5900.2 ; PC7801.2 169.44,48.57 v1(169.28,48.73) ; v1(104.21,103.46) 104.21,103.33 104.57,102.97 PC9420.2 ; v1(21.62,68.89) 22.23,68.89 C5810.2 ; PC9505.2 v1(159.41,72.8) ; D3002.2 58.34,98.84 v1(57.79,99.39) ; R0901.2 126.82,77.83 127,78.01 v1(127.91,78.01) ; U6000.V16 161.81,88.04 v1(161.94,88.04) 161.94,87.91 U6000.U15 ; C3800.2 v1(22.9,31.17)
  BOTTOM w0.457: 184.3,74.12 184.3,74.7 v1(184.18,74.83) ; v1(201.47,76.05) 201.45,76.08 R6817.1 ; v1(201.7,79) 201.64,79.07 C6803.2 ; v1(205.94,63.83) C3602.2 ; v1(125.6,23.73) 125.63,23.73 125.65,23.75 R1505.2 ; R1511.2 117.71,24.8 ; R1300.1 131.2,41.34 131.6,40.95 v1(131.6,40.44)
  BOTTOM w0.508: v1(59.93,5.51) CON5100.9 ; CON5101.5 173.93,14.4 173.71,14.18 v1(173.71,13.79) ; v1(135.42,51.3) 135.45,51.32 X1000.4 ; CON3100.77 218.49,1.25 v1(218.75,1.5) ; R6805.2 201.83,78.08 v1(201.88,78.04) ; v1(143.99,90.15) 143.98,90.14 X6900.4 ; v1(80.02,97.32) 79.93,97.41 R3005.2 ; v1(58.45,11.66) 58.45,11.81 59.03,12.4 59.45,12.4 59.83,12.78 CON3602.4 ; X0900.2 128.17,23.16 v1(128.6,22.74) ; Q3601.2 108.63,81.05 111.02,83.44 v1(111.91,83.44) ; v1(206.35,82.55) 206.33,82.57 CON3600.2 ; PC8701.2 174.27,30.79 v1(174.9,31.42) ; v1(146.2,9.96) 146.74,10.5 CON3601.12 148.13,8.76 148.23,8.66 ; PC8909.2 203.17,38.25 v1(203.33,38.1) ; R5110.2 170.32,18.5 170.46,18.37 v1(170.46,18.35) ; D5700.2 12.76,81.87 v1(13.54,82.65) ; v1(122.02,27.12) 121.5,27.64 C1634.2 ; v1(164.69,71.68) 164.36,71.35 PC9504.2 ; PC7705.2 162.71,34.22 v4(162.26,34.67) ; v1(62.51,19.41) 62.51,19.89 62.03,20.37 CON3602.3 ; D3800.1 4.97,36.79 v1(5.08,36.68) ; v1(133.15,55.81) 133.75,55.21 X1000.2 ; D5706.2 12.49,79.43 v1(12.03,78.97) ; D5701.2 11.7,85.02 v1(10.92,85.02) ; 198.96,14.25 198.97,14.27 CON5104.23 ; U5802.2 19.25,71.86 19.61,71.5 v1(19.61,70.61) ; v1(161.7,58.37) 161.3,58.37 PCE8000.2 ; PC7710.2 190.39,25.23 v1(190.27,25.35) ; v1(109.63,21.92) 109.68,21.87 C1005.2 ; U5801.2 39.88,19.76 v1(39.7,19.59) ; v1(168.88,47.32) 169.45,47.32 PC7804.1 ; v1(202.41,42.52) 202.92,43.03 U5101.2 ; CON5104.21 201.02,17.33 ; CON5104.21 203.12,17.33 ; CON5104.21 202.22,15.41 ; CON5104.21 202.22,19.17 ; 204.37,112.11 Q7201.2 v1(205.37,112.11) ; CON5700.14 4.54,80.92 ; 197.22,15.38 CON5104.23 ; CON5104.23 198.97,16.55 ; CON5104.23 200.85,15.38 ; CON3100.76 217.4,21.95 218.24,22.79 v1(219.28,22.79) ; CON5104.22 187.92,15.18 ; CON5104.22 187.92,19.22 ; CON5104.22 187.07,17.33 ; CON5104.22 189,17.33 ; Q6901.2 145.1,75.31 v1(144.93,75.14) ; Q1000.2 110.32,19.63 111.07,18.87 v1(111.07,18.82) ; Q3600.2 148.72,17.84 148,17.12 146.65,17.12 146.15,16.61 146.15,16.23 ; Q7203.2 160.4,106.17 v1(160.71,105.87) ; Q2403.2 99.88,17.77 v1(100.25,18.14) ; U7000.15 v1(188.24,108.18) ; v1(47.85,14.7) 48.23,15.08 PC8806.2 ; C3000.2 49.95,97.92 v1(49.52,97.49) ; v1(192.48,30.46) 192.48,29.8 PC7712.2 ; D3603.2 140.72,18.31 v1(140.72,17.4) ; CON5104.24 191.17,14.26 ; CON5104.24 192.9,15.38 ; CON5104.24 189.42,15.38 ; CON5104.24 191.17,16.63 ; PC7717.2 PC7719.2 201.5,22.89 201.93,23.31 v1(201.93,23.5) ; v1(119.89,10.52) 119.89,10.95 119.64,11.2 CON3101.13 ; 3.2,93.07 CON5700.22 1.92,93.76 ; CON2600.22 11.88,60.05 ; PQ7602.2 16.54,55.96 v1(16.54,55.64) ; D5705.2 12.63,80.29 12.78,80.14 13.92,80.14 v1(13.94,80.16) ; v1(113.18,18.85) 113.18,18.95 113.69,19.46 C1628.2 ; v4(156.91,67.78) 156.91,67.38 157.3,66.99 PC8007.2 ; v1(17.27,50.12) 17.27,50.55 PD7601.1 ; v1(197.59,30.51) 197.59,30.94 197.31,31.22 PR7710.2 ; CON3800.8 v1(11.63,17.88) ; v1(61.14,16.68) 61.14,17.25 61.71,17.82 CON3602.1 ; R6807.2 183.26,97.36 v1(183.19,97.28) ; v1(146.25,30.76) 146.25,30.76 PU8000.9 ; v1(16.96,74.15) 16.72,74.15 Q5800.2 ; X6900.2 v1(146.63,86.63) ; v1(98.43,41.28) C1203.2 ; Q5100.2 162.18,16.69 v1(161.09,17.78) ; v1(43.38,21.21) 43.38,20.26 43.66,19.98 PC8800.2 ; U3100.2 106.72,12.51 v1(106.38,12.85) ; v1(49.25,5.49) 48.53,6.21 CON5100.10 ; v1(206.82,105.79) 206.82,107 Q7202.2 ; CON5103.51 203.86,22.36 203.12,23.09 v1(203.12,23.62) ; v1(201.55,101.22) 201.52,101.2 R6802.1 ; CON5103.53 208.8,18.99 208.53,18.72 v1(208.53,17.82) ; v1(207.49,112.11) Q7200.2 208.57,112.11 ; C6610.2 185.6,104.93 v1(186.03,104.5) ; v1(208.04,51.91) 208.8,51.16 CON5103.54 ; v1(41.43,28.3) CON2100.264 ; v1(110.03,13.54) 109.88,13.39 CON3101.14 ; CON3800.5 9.33,21.13 8.81,21.64 v1(8.2,21.64) ; v1(19.13,58.37) 19.13,58.27 PC7608.2 ; R6801.1 201.45,102.14 v1(201.5,102.09) ; v1(20.57,43.44) 20.09,42.95 C1902.2 ; v1(146.05,19.54) 145.61,19.54 144.9,18.82 R3606.2 ; v1(206.78,48.66) CON5103.52 ; PC9503.2 160.12,72.8 v1(160.11,72.78) ; 163.07,49.79 163.07,49.79 PC8707.2 ; U1900.4 96.86,22.68 v1(97,22.83) ; v1(135.38,18.95) 135.17,18.74 135.17,18.51 D3601.2 ; CON5101.6 167.74,14.4 v1(168.35,13.79) ; D3602.2 137.2,18.66 137.54,19 v1(137.54,19.33) ; Q7204.2 206.85,103.93 v1(206.86,103.94) ; Q0400.2 135.3,74.96 v1(134.93,74.96) ; C5724.2 17.09,76.28 v1(16.92,76.1) ; CON3601.11 v1(122.83,10.5) ; v1(113.7,24.48) 113.41,24.77 C1633.2 ; v1(48.01,99.34) 48.23,99.57 U3000.2 ; PC7709.2 190.92,28.3 191.36,27.87 v1(191.69,27.87) ; Q3100.2 158.89,11.32 158.52,11.69 v1(158.52,12.22) ; PC8710.2 v1(175.44,32.24) ; R0504.2 v1(95.25,115.01) ; CON5700.21 5.79,93.76 ; v1(96.42,42.62) R1213.2 ; C1607.2 v1(132.58,26.67)
  BOTTOM w0.635: 5.12,57.25 CON2600.20 3.68,56.41 ; PC7906.2 156.31,55.14 v4(156.68,55.5) ; CON2600.21 3.68,76.84 ; v4(156.74,45.37) 156.74,44 157.32,43.42 PC7913.2 ; CON5700.14 7.34,80.92 ; CON2600.23 11.88,74.55 ; CON2600.23 11.88,72.75 ; CON2600.23 13.14,73.65 ; CON5700.13 1.92,80.24 ; 11.88,58.25 CON2600.22 13.32,59.15 ; 6.59,82.9 CON5700.B12
  vias: v1(0.76,99.52) v1(0.76,98.48) v1(3.4,54.79) v1(3.53,36.68) v1(3.53,35.87) v1(3.53,25.91) v1(3.53,23.57) v1(3.53,21.47) v1(3.53,19.05) v1(3.53,14.94) v1(3.53,13.16) v1(3.53,10.87) v1(4.52,9.48) v1(4.8,21.67) v1(5.94,21.64) v1(7.16,9.43) v1(7.24,21.64) v1(8.92,90.71) v1(8.93,90.08) v1(9.04,83.95) v1(9.35,94.21) v1(9.35,9.43) v1(9.96,94.21) v1(10.57,94.21) v1(10.59,86.62) v1(11.18,94.21) v1(11.18,9.43) v1(11.91,94.24) v1(12.52,94.24) v1(12.52,65.64) v1(12.83,9.35) v1(13.16,94.24) v1(13.45,69.15) v1(13.55,63.95) v1(13.77,94.24) v1(13.8,87.26) v1(14.38,94.24) v1(14.48,8.74) v1(15.01,94.26) v1(15.39,74.1) v1(16.05,93.91) v1(16.5,34.81) v1(17.81,95.99) v1(18.86,95.85) v1(18.82,87.76) v1(19.47,95.86) v1(19.46,87.76) v1(19.79,82.37) v1(19.94,65.69) v1(20.08,95.86) v1(20.17,96.52) v1(20.22,67.92) v1(20.65,66.08) v1(20.65,63.19) v1(20.65,61.14) v1(20.68,58.96) v1(20.75,95.86) v1(21.36,95.86) v1(21.95,96.52) v1(21.95,91.82) v1(22.07,95.86) v1(22.05,3.23) v1(22.58,91.82) v1(22.68,95.86) v1(22.75,65.73) v1(22.76,63.76) v1(23.32,63.5) v1(23.39,60.53) v1(23.46,58.97) v1(23.52,61.45) v1(23.83,96.62) v1(24.15,73.7) v1(24.14,67.93) v1(24.48,2.79) v1(24.71,66.25) v1(25.35,97.23) v1(25.81,66.04) v1(26.34,75.21) v1(26.57,98.33) v1(27.02,2.79) v1(27.61,107.72) v1(27.61,103.18) v1(27.61,100.94) v1(28.78,109.86) v1(28.8,101.15) v1(28.8,100.51) v1(28.78,97.06) v1(29.24,97.49) v1(29.44,2.8) v1(29.69,97.89) v1(30.18,111.2) v1(31.31,2.79) v1(31.98,79.07) v1(32.79,83.47) v1(32.84,111.23) v1(33.85,2.79) v1(34.98,111.23) v1(35.33,82.58) v1(35.33,71.94) v1(35.56,68.48) v1(35.97,71.91) v1(36.22,68.33) v1(36.39,2.79) v1(37.57,111.23) v1(38.93,2.79) v1(39.98,111.23) v1(41.47,2.79) v1(41.83,86.18) v1(42.67,111.23) v1(42.85,87.68) v1(42.98,83.2) v1(43.61,2.8) v1(44.12,88.04) v1(44.65,111.23) v1(44.86,89.49) v1(45.48,2.79) v1(46.56,66.42) v1(46.77,85.3) v1(46.84,111.23) v1(46.81,84.64) v1(46.89,66.96) v1(47.17,66.4) v1(47.17,65.56) v1(47.22,67.52) v1(47.63,30.56) v1(48.08,61.17) v1(48.1,54.92) v1(48.1,54.23) v1(48.02,2.79) v1(48.39,111.2) v1(49.02,111.2) v1(49.63,111.23) v1(49.63,20.66) v1(50.24,111.23) v1(50.24,20.66) v1(50.56,2.79) v1(50.85,20.66) v1(51.86,54.6) v1(51.97,67.12) v1(51.94,51.55) v1(52.04,111.23) v1(52.02,53.17) v1(52.48,56.19) v1(52.58,45.58) v1(52.68,61.12) v1(52.83,58.64) v1(52.96,59.52) v1(53.1,2.79) v1(53.54,55.65) v1(53.75,47.46) v1(54.1,53.72) v1(54.08,50.84) v1(54.2,52.11) v1(54.38,111.23) v1(54.89,64.3) v1(55.65,67.86) v1(55.64,2.79) v1(56.34,111.23) v1(57.86,110.19) v1(57.99,2.8) v1(58.88,111.23) v1(59.77,110.16) v1(59.86,2.79) v1(60.53,110.16) v1(61.21,110.19) v1(61.42,111.23) v1(62,110.16) v1(62.43,2.8) v1(62.84,111.23) v1(64.16,9.15) v1(64.39,111.2) v1(64.97,52.07) v1(64.94,2.79) v1(65.08,58.02) v1(65.41,39.98) v1(65.43,56.06) v1(65.43,31.17) v1(65.46,9.12) v1(65.94,111.2) v1(65.96,53.76) v1(66.09,9.12) v1(66.24,52.07) v1(66.5,96.52) v1(66.9,34.78) v1(66.95,51.16) v1(67.48,2.79) v1(67.69,111.2) v1(67.72,49.15) v1(67.77,40.12) v1(68.15,95.86) v1(68.5,57.03) v1(69.57,111.2) v1(70.02,2.79) v1(70.13,95.84) v1(72.21,95.79) v1(72.29,2.8) v1(73.58,111.2) v1(73.73,91.2) v1(74.16,2.79) v1(74.37,91.2) v1(74.75,24.77) v1(75.04,91.2) v1(75.36,24.77) v1(76.7,2.79) v1(77.72,111.2) v1(79.24,2.79) v1(80.34,111.33) v1(81.78,2.79) v1(81.81,112.73) v1(83.39,112.73) v1(83.59,52.15) v1(84.32,2.79) v1(84.81,48.57) v1(85.22,112.73) v1(85.6,52.77) v1(86.11,49.94) v1(86.54,2.8) v1(86.83,57.62) v1(87.09,112.72) v1(87.25,50.98) v1(88.02,43.96) v1(88.41,2.79) v1(88.51,65.2) v1(88.52,52.33) v1(88.85,63.26) v1(89.36,75.66) v1(89.35,45.29) v1(89.45,57.62) v1(89.63,112.72) v1(89.69,70.77) v1(89.78,65.2) v1(90.6,75.66) v1(90.83,63.26) v1(90.95,2.79) v1(91.19,44.43) v1(91.26,10) v1(91.59,112.73) v1(92.53,45.75) v1(92.61,8.66) v1(92.79,9.25) v1(92.84,111.86) v1(93.5,112.47) v1(93.45,111.86) v1(93.49,2.79) v1(93.54,65.2) v1(93.62,114.76) v1(94.11,75.64) v1(95.33,74.93) v1(95.68,45.85) v1(95.99,75.62) v1(96.03,2.79) v1(96.11,94.95) v1(96.8,94.95) v1(97.61,114.96) v1(98.35,115.01) v1(98.6,110.92) v1(98.63,50.32) v1(99.14,115.01) v1(99.21,110.98) v1(99.82,115.01) v1(99.97,46.52) v1(100.15,61.57) v1(100.51,50.32) v1(100.48,45.32) v1(100.64,2.82) v1(100.89,59.57) v1(101.6,51.8) v1(101.66,45.2) v1(102.36,115.01) v1(102.5,2.81) v1(102.54,50.32) v1(103.48,79.23) v1(103.76,4.52) v1(104.01,7.5) v1(104.65,115.01) v1(104.8,77.88) v1(105.69,8.99) v1(106.45,115.01) v1(106.63,77.32) v1(106.88,75.47) v1(107.38,16.62) v1(107.99,16.62) v1(108.03,9.12) v1(108.61,75.92) v1(108.99,115.01) v1(110.09,107.08) v1(110.1,75.49) v1(110.95,8.66) v1(111.56,115.01) v1(111.89,113.57) v1(111.91,112.93) v1(112.5,113.39) v1(112.55,76.79) v1(112.7,82.68) v1(113,8.46) v1(113.13,82.22) v1(113.59,81.79) v1(114.02,81.33) v1(114.12,114.99) v1(114.5,80.85) v1(114.78,76.94) v1(114.99,80.37) v1(115.62,8.47) v1(115.88,115.01) v1(115.93,76.61) v1(116.18,24.56) v1(117.6,115.01) v1(118.16,8.47) v1(119.53,115.01) v1(119.76,16.61) v1(119.94,80.42) v1(119.94,79.76) v1(119.94,79.1) v1(119.94,78.49) v1(119.94,77.88) v1(119.94,77.27) v1(120.09,85.85) v1(120.09,85.24) v1(120.57,88.6) v1(120.7,85.85) v1(120.7,85.24) v1(120.7,8.47) v1(121.21,88.6) v1(121.84,88.62) v1(122.15,115.01) v1(122.48,88.62) v1(123.11,88.65) v1(123.24,8.47) v1(123.75,88.67) v1(124.1,78.41) v1(124.1,77.78) v1(124.11,77.17) v1(124.1,76.56) v1(124.38,88.67) v1(124.69,115.01) v1(125.78,8.47) v1(127.76,88.61) v1(128.37,88.61) v1(128.32,8.47) v1(128.99,88.6) v1(129.6,88.6) v1(129.64,55.93) v1(130.21,88.6) v1(130.25,48.82) v1(130.43,59.08) v1(130.53,115.01) v1(130.66,57.98) v1(130.66,8.46) v1(131.42,55.83) v1(131.83,43.77) v1(132.72,32.54) v1(132.92,44.02) v1(133.12,115.02) v1(133.5,8.49) v1(133.63,44.94) v1(133.75,115.02) v1(134.04,43.79) v1(134.39,115.02) v1(134.39,49.05) v1(134.32,44.96) v1(134.54,29.59) v1(134.72,48.47) v1(134.72,47.4) v1(135.02,115.02) v1(135.51,46.66) v1(135.66,115.02) v1(135.99,48.44) v1(135.97,46.26) v1(136.12,8.49) v1(136.29,115.02) v1(136.25,84.43) v1(136.32,62.16) v1(136.31,61.55) v1(136.31,60.94) v1(136.31,60.33) v1(136.78,32.44) v1(136.93,115.02) v1(137.56,115.02) v1(137.59,55.58) v1(137.58,54.97) v1(137.69,83.21) v1(138.2,115.02) v1(138.28,82.07) v1(138.4,41.87) v1(138.66,8.49) v1(138.76,21.77) v1(138.83,115.02) v1(139.36,40.93) v1(139.37,21.77) v1(139.47,115.02) v1(139.53,30.63) v1(139.98,21.77) v1(140.1,115.02) v1(140.74,115.02) v1(141.2,8.49) v1(141.37,115.02) v1(141.79,32.85) v1(142.01,115.02) v1(142.24,32.41) v1(142.64,115.02) v1(143.28,115.02) v1(143.74,8.44) v1(144.14,12.83) v1(145.42,115.01) v1(146.36,8.44) v1(147.19,8.44) v1(147.42,115.01) v1(149.76,115.01) v1(150.14,99.52) v1(150.36,54.24) v1(150.98,54.23) v1(152.22,115.01) v1(152.58,9.2) v1(153.92,89.54) v1(154.07,115.02) v1(154.03,88.04) v1(154.08,9.25) v1(154.13,105.31) v1(154.81,105.32) v1(155.5,20.47) v1(155.6,113.72) v1(155.52,21.08) v1(155.7,111.58) v1(155.73,104.83) v1(155.85,9.25) v1(156.81,75.43) v1(157.23,109.53) v1(157.35,105.36) v1(157.56,104.79) v1(157.84,9.25) v1(158.8,100.26) v1(159.08,109.07) v1(159.33,105.03) v1(159.36,95.13) v1(160.03,100.26) v1(160.2,105.32) v1(160.45,96.75) v1(160.73,9.25) v1(160.83,97.79) v1(161.04,109.88) v1(161.57,96.62) v1(161.52,95.96) v1(161.63,100.27) v1(161.65,95.25) v1(162.03,111.36) v1(162.15,113.21) v1(162.28,44.71) v1(162.28,44.1) v1(162.43,115.03) v1(162.53,61.52) v1(162.79,97.67) v1(162.89,44.71) v1(162.89,44.1) v1(162.92,95.99) v1(162.97,9.25) v1(163.23,100.36) v1(163.58,112.65) v1(164.19,112.65) v1(164.39,115.01) v1(164.77,9.25) v1(164.82,112.65) v1(164.83,100.28) v1(165.13,96.72) v1(165.35,66.98) v1(165.77,99.86) v1(165.94,105.23) v1(166.22,66.25) v1(166.75,115.01) v1(166.75,87.89) v1(166.9,9.25) v1(167.03,47.91) v1(167.06,47.3) v1(167.47,99.78) v1(167.62,97.61) v1(169.25,94.41) v1(169.24,9.25) v1(169.37,115.01) v1(170.43,104.07) v1(171.32,9.25) v1(172.01,43.16) v1(172.19,115.01) v1(172.11,42.55) v1(172.54,37.67) v1(172.62,42.95) v1(173.13,9.25) v1(173.41,109.91) v1(173.41,43.44) v1(173.71,101.5) v1(174.04,109.88) v1(174.17,76.63) v1(174.17,75.53) v1(174.45,115.01) v1(175.16,41.84) v1(175.26,9.25) v1(175.49,100.03) v1(175.54,66.09) v1(175.54,65.46) v1(175.79,41.84) v1(175.87,110.47) v1(176.1,99.04) v1(176.07,65.76) v1(176.07,65.15) v1(176.3,90.88) v1(176.28,85.27) v1(176.33,111.33) v1(176.68,65.15) v1(176.78,86.59) v1(176.81,13.79) v1(176.99,83.52) v1(176.94,41.84) v1(177.01,90.15) v1(177.04,80.39) v1(177.32,9.25) v1(177.42,93.32) v1(177.42,13.79) v1(177.57,41.84) v1(178.11,115.02) v1(178.03,13.79) v1(178.16,86.21) v1(178.54,65.15) v1(178.61,98.38) v1(178.71,115.02) v1(179.15,65.15) v1(179.3,93.32) v1(179.35,115.02) v1(179.48,80.42) v1(179.53,9.25) v1(179.76,65.15) v1(179.96,115.02) v1(179.98,41.86) v1(180.37,65.15) v1(180.62,41.86) v1(181.48,14.12) v1(182.02,9.25) v1(182.5,115.01) v1(183.11,103.94) v1(183.29,85.75) v1(183.31,86.39) v1(184.51,115.01) v1(184.46,9.25) v1(186.69,115.01) v1(187.38,9.25) v1(189.33,115.01) v1(190.12,9.25) v1(190.5,56.26) v1(190.63,111.94) v1(191.14,56.26) v1(191.34,24.56) v1(191.44,115.01) v1(191.77,56.26) v1(192.56,114.1) v1(192.86,9.25) v1(192.94,114.94) v1(193.68,113.44) v1(193.85,30.51) v1(193.93,54.76) v1(194.41,71.61) v1(194.79,111.84) v1(194.97,114.89) v1(194.95,113.79) v1(195.15,9.25) v1(195.4,112.68) v1(195.33,55.78) v1(195.35,51.79) v1(195.48,56.72) v1(195.55,53.39) v1(195.94,56.29) v1(196.06,114.48) v1(196.57,111.66) v1(196.77,113.21) v1(197.38,64.42) v1(197.54,9.25) v1(197.66,112.83) v1(198.02,111.66) v1(198.83,112.6) v1(199.24,69.55) v1(199.24,54.71) v1(199.36,111.71) v1(199.31,49.93) v1(199.49,82.4) v1(199.54,80.44) v1(199.85,113.26) v1(199.85,54.71) v1(199.95,49.93) v1(199.97,9.25) v1(200.36,112.65) v1(200.53,114.15) v1(201.47,104.42) v1(201.5,103.81) v1(201.47,103.13) v1(201.47,95.33) v1(201.47,94.47) v1(201.5,93.58) v1(201.5,73.89) v1(201.5,73.23) v1(201.57,92.51) v1(201.6,91.85) v1(201.78,85.07) v1(201.78,84.2) v1(201.78,83.59) v1(201.78,82.96) v1(201.73,30.13) v1(202.06,115.01) v1(202.34,9.25) v1(202.44,32.49) v1(202.62,28.3) v1(202.72,35) v1(202.74,27.26) v1(202.95,114.05) v1(203.2,56.01) v1(203.2,36.81) v1(203.17,33.35) v1(203.2,28.96) v1(203.28,28.32) v1(203.78,30.46) v1(203.91,56.01) v1(204.5,26.14) v1(204.65,51.46) v1(204.67,27.28) v1(204.75,34.9) v1(204.88,9.55) v1(205.13,37.11) v1(205.16,29.62) v1(205.46,115.01) v1(205.74,80.22) v1(205.74,79.56) v1(205.97,96.04) v1(206.07,94.13) v1(207.67,97.89) v1(207.8,92.46) v1(207.9,55.53) v1(208.36,99.8) v1(208.64,80.34) v1(208.64,79.68) v1(208.94,57.81) v1(209.07,53.22) v1(209.52,115.01) v1(209.58,98.12) v1(209.75,114.2) v1(209.75,112.83) v1(209.75,111.31) v1(209.75,109.63) v1(209.75,107.77) v1(209.75,106.05) v1(209.75,104.42) v1(209.75,102.72) v1(209.75,100.26) v1(209.82,18.68) v1(209.98,17.6) v1(210.85,58.7) v1(210.95,91.3) v1(210.95,88.76) v1(210.95,86.22) v1(210.95,83.68) v1(210.95,81.14) v1(210.95,78.6) v1(210.95,76.56) v1(210.95,74.41) v1(210.95,71.87) v1(210.96,69.34) v1(210.95,66.83) v1(210.95,64.75) v1(210.95,63.58) v1(210.95,62.04) v1(210.95,60) v1(211.1,52.61) v1(211.3,16.97) v1(211.51,9.1) v1(212.4,9.35) v1(212.6,15.83) v1(212.8,11.36) v1(213.13,12.35) v1(213.23,7.06) v1(213.82,4.88) v1(213.85,2.4) v1(214,48.29) v1(214.1,11.41) v1(214.17,12.85) v1(214.17,12.17) v1(214.88,0.79) v1(215.01,46.33) v1(216.18,44.4) v1(217.78,42.12) v1(218.44,8.49) v1(218.75,7.93) v1(218.8,7.27) v1(218.97,40.64) v1(219.41,0.79) v1(220.07,38.13) v1(220.07,35.71) v1(220.07,33.17) v1(220.07,30.89) v1(220.04,28.88) v1(220.07,26.6) v1(220.24,24.46) v1(222.12,23.45) v1(224.69,0.76) v1(225.43,23.45) v1(226.06,21.34) v1(226.04,18.85) v1(226.06,16.31) v1(226.06,13.77) v1(226.06,11.48) v1(226.06,8.71) v1(226.06,6.2) v1(226.06,3.51) v3(101.88,46.33) v3(101.98,66.63) v3(102.03,61.65) v3(102.29,65.18) v3(102.69,63.73) v3(102.79,59.51) v3(102.83,67.08) v3(104,65.14) v3(106.22,50.37) v3(106.22,38.43) v3(106.36,40.67) v3(106.66,70.56) v3(107.24,41.23) v3(107.46,55.01) v3(107.47,44.02) v3(107.44,38.61) v3(108.1,53.22) v3(108.08,40.46) v3(108.13,66.01) v3(108.66,68.73) v3(108.73,66.01) v3(108.76,60.58) v3(108.79,59.6) v3(108.76,53.19) v3(108.81,58.69) v3(108.85,57.75) v3(109.28,68.73) v3(109.41,49.63) v3(109.42,55.08) v3(109.47,53.2) v3(109.42,51.39) v3(109.65,71.63) v3(109.98,55.05) v3(110.1,68.73) v3(110.03,53.22) v3(110.08,51.39) v3(110.06,43.96) v3(110.13,49.58) v3(110.58,70.58) v3(110.55,66) v3(110.66,68.73) v3(110.66,67.77) v3(110.67,48.67) v3(110.69,46.71) v3(110.77,57.76) v3(110.79,56.85) v3(110.8,47.71) v3(111.28,44.07) v3(111.51,45.21) v3(111.47,39.5) v3(111.43,34.23) v3(112.24,41.15) v3(112.47,45.34) v3(112.52,68.46) v3(112.98,45.7) v3(113.38,68.55) v3(113.37,39.62) v3(113.38,39.02) v3(113.39,38.4) v3(113.37,37.12) v3(113.41,36.48) v3(113.44,35.89) v3(113.47,35.16) v3(113.78,53.53) v3(113.92,48.25) v3(114.26,60.11) v3(114.26,58.85) v3(114.22,57.6) v3(114.35,71) v3(114.35,70.42) v3(114.35,69.75) v3(114.35,69.11) v3(114.35,53.53) v3(114.48,48.25) v3(114.55,39.02) v3(114.53,36.93) v3(114.63,65.29) v3(114.63,64.73) v3(115.06,48.25) v3(115.14,74.88) v3(115.19,73.03) v3(115.28,53.55) v3(115.5,60.11) v3(115.49,57.58) v3(115.53,58.85) v3(115.57,38.25) v3(115.6,36.44) v3(115.62,48.25) v3(115.85,53.56) v3(115.98,65.29) v3(115.98,64.73) v3(116.33,48.25) v3(116.4,44.39) v3(116.66,40.24) v3(116.69,34.17) v3(116.8,53.55) v3(116.88,60.11) v3(116.9,58.85) v3(116.89,57.6) v3(116.89,48.25) v3(117.36,65.29) v3(117.37,64.73) v3(117.37,53.56) v3(117.6,48.25) v3(117.75,39.73) v3(117.74,39.06) v3(117.73,38.48) v3(117.74,37.91) v3(118.06,60.11) v3(118.19,58.85) v3(118.16,57.6) v3(118.16,48.25) v3(118.38,53.56) v3(118.75,65.29) v3(118.75,64.73) v3(118.87,48.25) v3(118.89,40.22) v3(118.85,38.36) v3(118.94,53.56) v3(118.99,45.33) v3(118.92,44.38) v3(119.43,48.25) v3(119.88,52.92) v3(119.83,40.21) v3(119.99,48.25) v3(120.09,65.26) v3(120.09,64.7) v3(120.49,52.92) v3(120.55,48.25) v3(120.88,38.45) v3(121.6,68.44) v3(121.62,71.86) v3(121.62,70.41) v3(121.62,69.85) v3(121.72,74.01) v3(122.35,39.42) v3(122.5,69.85) v3(122.6,31.11) v3(122.95,40.3) v3(122.94,38.56) v3(123.6,62.31) v3(123.55,55.03) v3(123.56,53.27) v3(123.59,51.28) v3(123.6,36.73) v3(123.63,59.53) v3(123.65,58.68) v3(123.64,57.72) v3(123.7,45.9) v3(123.71,48.61) v3(123.93,69.85) v3(124.2,59.53) v3(124.23,62.31) v3(124.54,67.86) v3(124.87,59.53) v3(124.87,49.61) v3(124.94,55.04) v3(125.12,41.73) v3(125.78,63.05) v3(125.83,70.34) v3(125.88,60.13) v3(125.81,58.02) v3(125.87,47.74) v3(127.43,38.25) v3(128.25,48.69) v3(128.47,51.36) v3(128.91,47.58) v3(129.03,51.36) v3(129.41,47.86) v3(129.85,45.34) v3(130.59,47.02) v4(29.87,103.61) v4(38.94,98.94) v4(39.78,102.52) v4(39.83,98.94) v4(40.31,101.83) v4(40.87,102.52) v4(41.43,101.83) v4(42.09,102.49) v4(53.06,106) v4(53.95,106) v4(54.86,106) v4(55.73,106) v4(66.07,105.92) v4(67.01,105.92) v4(77.52,109.58) v4(78.38,109.58) v4(79.27,109.58) v4(80.14,109.58) v4(81,109.58) v4(84.35,102.42) v4(85.09,101.75) v4(85.98,101.73) v4(86.84,101.75) v4(87.73,101.75) v4(123.65,112.07) v4(124.13,111.28) v4(124.18,105.67) v4(124.26,104.47) v4(124.64,112.07) v4(125.07,111.28) v4(128.12,103.66) v4(129.24,103.66) v4(131.78,103.69) v4(132.64,103.13) v4(138.68,14.02) v4(139.12,41.63) v4(139.57,13.92) v4(140.03,41.58) v4(140.12,40.69) v4(140.46,13.9) v4(140.91,41.62) v4(141,40.71) v4(141.61,92.89) v4(143.66,92.89) v4(143.92,114.18) v4(143.99,54.79) v4(144.3,14.2) v4(144.86,114.18) v4(144.96,92.86) v4(145.16,14.18) v4(145.85,114.18) v4(145.87,113.29) v4(145.87,112.37) v4(145.87,111.43) v4(145.82,92.86) v4(146.05,14.15) v4(146.69,112.07) v4(147.29,111.43) v4(147.9,112.07) v4(148.01,55.58) v4(148.08,95.58) v4(148.51,111.43) v4(149.05,101.55) v4(149.02,98.83) v4(149.05,55.6) v4(149.12,112.07) v4(149.73,111.43) v4(149.73,54.79) v4(149.94,114.25) v4(149.96,113.36) v4(149.96,112.4) v4(150.09,67.24) v4(150.09,66.37) v4(150.14,65.5) v4(150.19,55.58) v4(150.6,41.84) v4(150.62,111.43) v4(150.62,40.95) v4(150.67,40.06) v4(150.88,54.97) v4(151,114.25) v4(150.95,67.24) v4(150.95,66.37) v4(151.01,65.5) v4(151.03,113.34) v4(151.03,112.45) v4(151.03,42.6) v4(151.51,111.43) v4(151.51,41.86) v4(151.59,40.97) v4(151.64,55.37) v4(151.61,40.06) v4(151.84,54.34) v4(151.92,110.67) v4(152.12,112.07) v4(152.27,102.24) v4(152.27,101.35) v4(152.5,55.15) v4(152.48,40.97) v4(152.48,40.08) v4(152.53,111.31) v4(152.6,33.58) v4(152.83,54.33) v4(152.98,112.07) v4(153.04,32.08) v4(153.16,102.26) v4(153.21,32.97) v4(153.37,40.97) v4(153.37,40.06) v4(153.44,111.31) v4(153.52,34.72) v4(153.59,33.81) v4(153.87,112.07) v4(153.95,32.08) v4(154.1,110.7) v4(154.33,35.26) v4(154.74,114.23) v4(154.71,113.34) v4(154.71,112.45) v4(154.74,111.56) v4(154.84,32.08) v4(155.09,110.72) v4(155.73,32.08) v4(156.62,32.08) v4(157.84,26.37) v4(158.45,25.66) v4(158.78,26.47) v4(158.88,24.89) v4(159.44,25.83) v4(159.79,24.89) v4(166.43,22.74) v4(166.64,23.8) v4(167.31,22.74) v4(167.51,23.8) v4(168.17,22.74) v4(168.38,23.78) v4(169.04,22.68) v4(178.46,33.35) v4(178.79,31.27) v4(178.82,32.21) v4(179.33,33.35) v4(179.68,32.21) v4(179.71,31.27) v4(180.21,33.33) v4(180.59,32.13) v4(180.65,31.24) v4(181.51,43.46) v4(181.53,45.21) v4(181.53,44.35) v4(181.56,31.22) v4(182.04,31.97) v4(182.4,46.26) v4(182.4,45.37) v4(182.4,44.48) v4(182.52,31.22) v4(185.75,48.82) v4(186.08,60.51) v4(186.13,59.59) v4(186.64,48.82) v4(186.77,58.98) v4(186.82,47.86) v4(187.43,60.51) v4(187.45,59.54) v4(187.45,20.07) v4(187.55,48.82) v4(188.27,59.01) v4(188.44,48.82) v4(188.85,58.27) v4(189.31,59.01) v4(189.33,48.82) v4(189.46,25.35) v4(189.48,24.13) v4(189.48,22.28) v4(189.69,55.96) v4(189.79,58.24) v4(190.03,46.79) v4(190.25,59.06) v4(190.25,48.82) v4(190.7,58.24) v4(190.89,46.79) v4(191.16,48.82) v4(191.47,58.78) v4(191.76,46.79) v4(192.08,48.82) v4(192.48,58.8) v4(192.62,46.79) v4(194.41,65.36) v4(195.28,65.36) v4(196.34,65.38) v4(196.65,64.52) v4(197.21,65.38) v4(200.79,14.12) v4(201.65,15.01)
