# Allegro board 5n-armani13.a00.0828.brd (continued)
## Nets (continued)
+VCORE: C0700.1 C0701.1 C0702.1 C0703.1 C0704.1 C0705.1 C0706.1 C0707.1 C0708.1 C0709.1 C0710.1 C0711.1 C0712.1 C0713.1 C0714.1 C0715.1 C0716.1 C0717.1 C0718.1 C0719.1 C0734.1 C0735.1 C0736.1 C0737.1 C0738.1 C0739.1 C0740.1 C0741.1 C0742.1 C0743.1 C0744.1 PC8100.1 PC8101.1 PC8102.1 PC8103.1 PC8104.1 PC8105.1 PC8106.1 PC8107.1 PC8108.1 PC8109.1 PC8110.1 PC8118.1 PC8119.1 PC8120.1 PC8121.1 PC8122.1 PC8123.1 PC8124.1 PC8125.1 PC8126.1 PC8127.1 PC8128.1 PC8129.1 PC8130.1 PC8131.1 PC8132.1 PC8133.1 PC8134.1 PC8135.1 PC8136.1 PC8178.1 PC8179.1 PC8180.1 PC8181.1 PC8182.1 PCE8100.1 PJP7902.2 PJP7904.2 PL7900.2 PL7901.2 R0606.2 R0700.1 U0400.A30(VCC_1) U0400.A34(VCC_2) U0400.A39(VCC_3) U0400.A44(VCC_4) U0400.AK33(VCC_5) U0400.AK35(VCC_6) U0400.AK37(VCC_7) U0400.AK38(VCC_8) U0400.AK40(VCC_9) U0400.AL33(VCC_10) U0400.AL37(VCC_11) U0400.AL40(VCC_12) U0400.AM32(VCC_13) U0400.AM33(VCC_14) U0400.AM35(VCC_15) U0400.AM37(VCC_16) U0400.AM38(VCC_17) U0400.G30(VCC_18) U0400.G32(VCC_19) U0400.G33(VCC_20) U0400.G35(VCC_21) U0400.G37(VCC_22) U0400.G38(VCC_23) U0400.G40(VCC_24) U0400.G42(VCC_25) U0400.J30(VCC_26) U0400.J33(VCC_27) U0400.J37(VCC_28) U0400.J40(VCC_29) U0400.K33(VCC_30) U0400.K35(VCC_31) U0400.K37(VCC_32) U0400.K38(VCC_33) U0400.K40(VCC_34) U0400.K42(VCC_35) U0400.K43(VCC_36)
+VCORE1_BT_D: PR7902.1 PU7900.2(BOOT)
+VCORE1_FCCM: PR7917.2 PU7900.7(FCCM)
+VCORE1_HG_D: PR7900.1 PU7900.1(UGATE)
+VCORE1_LG_D: PR7914.1 PU7900.5(LGATE)
+VCORE1_PHASE_D: PC7903.2 PC7904.2 PQ7900.2(GR) PR7913.2 PU7900.8(PHASE)
+VCORE1_PWM: PR7918.2 PU7900.3(PWM)
+VCORE1_R_BT_D: PC7904.1 PR7902.2
+VCORE1_R_HG_D: PC7903.1 PQ7900.1(HSG) PR7900.2 PR7913.1
+VCORE1_R_LG_D: PC7914.1 PQ7900.8(LSG) PR7914.2
+VCORE2_BT_D: PR7908.1 PU7901.2(BOOT)
+VCORE2_FCCM: PR7919.2 PU7901.7(FCCM)
+VCORE2_HG_D: PR7907.1 PU7901.1(UGATE)
+VCORE2_LG_D: PR7916.1 PU7901.5(LGATE)
+VCORE2_PHASE_D: PC7910.2 PC7911.2 PQ7901.2(GR) PR7915.2 PU7901.8(PHASE)
+VCORE2_PWM: PR7920.2 PU7901.3(PWM)
+VCORE2_R_BT_D: PC7911.1 PR7908.2
+VCORE2_R_HG_D: PC7910.1 PQ7901.1(HSG) PR7907.2 PR7915.1
+VCORE2_R_LG_D: PC7915.1 PQ7901.8(LSG) PR7916.2
+VCORE2_SN_C: PC7912.1 PR7909.2
+VCORE/GT: C0745.1 C0746.1 C0747.1 C0748.1 C0749.1 R0700.2 R0701.2 U0400.A48(VCCGT_1) U0400.A53(VCCGT_2) U0400.AK42(VCCGTX_1) U0400.AK43(VCCGTX_2) U0400.AK45(VCCGTX_3) U0400.AK46(VCCGTX_4) U0400.AK48(VCCGTX_5) U0400.AK50(VCCGTX_6) U0400.AL43(VCCGTX_14) U0400.AL46(VCCGTX_15) U0400.AL50(VCCGTX_16) U0400.AM48(VCCGTX_20) U0400.AM50(VCCGTX_21) U0400.AM52(VCCGTX_22) U0400.J43(VCCGT_21) U0400.J45(VCCGT_22) U0400.J46(VCCGT_23) U0400.J48(VCCGT_24) U0400.J50(VCCGT_25) U0400.J52(VCCGT_26) U0400.K48(VCCGT_32) U0400.K50(VCCGT_33)
+VCORE_CSN1_A: PC7800.1 PC7803.2 PC7806.1 PC7807.2 PC7808.2 PC7839.2 PC7840.2 PR7803.2 PR7804.1 PR7806.1 PR7853.1 PR7905.2 PR7912.2 PRT7800.2
+VCORE_CSP1_A: PC7800.2 PC7803.1 PC7839.1 PC7840.1 PR7800.1 PR7803.1 PR7904.2 PR7910.2 PU7800.7(ISUMP_B)
+VCORE_ISEN1_A: PC7807.1 PR7808.2 PR7906.2 PR7922.2 PU7800.9(ISEN1_B)
+VCORE_ISEN2_A: PC7808.1 PR7811.2 PR7911.2 PR7921.2 PU7800.10(ISEN2_B)
+VCORE_SN_C: PC7905.1 PR7903.2
+VDC_IN: PC7600.1 PC7602.1 PC7606.1 PD7600.2(CATHODE) PL7600.2 PL7601.2 PL7602.2 PQ7607.1(SOURCE1) PQ7607.2(SOURCE2) PQ7607.3(SOURCE3) PQ7609.4(EMITTER2) PR7600.1 PR7602.1 PR7603.1 PR7604.1 PR7611.1 PR7615.1 PR7625.1 R2406.1 R2407.1
+VREF_PINSET: PR9434.1 PR9439.1 PR9446.1 PR9448.1 PRT9401.1 PU9400.15(VREF_PINSET)
+VRTC_BATT: CON3602.2 Q3601.1(GATE) R3609.1 R3612.1
+VSUS_ROM: C1900.1 R1901.2 R1902.1 R1903.1 R1904.1 U1900.8(VCC)
+VTT_A_DDR_VTTSNS: PR8612.1 PU8600.2(VTTSNS)
+VTT_A_REF: PC8616.1 PU8600.4(VTTREF)
+VTT_DDR: C2000.1 C2100.1 C2208.1 C2209.1 C2220.1 C2221.1 C2222.1 C2223.1 CON2000.258(VTT) CON2100.258(VTT) PJP8602.2
AC_DIS: PR7627.1 Q2401.5(GATE) R2423.1 U2300.69(GPIO103/SPI_IO0)
AC_IN#_G: PR7611.2 PR7612.1 PU7600.1(SENSE)
AC_PRESENT: D2400.1(ANODE) R1203.2 R1207.1 U0400.AY15(GPD1/ACPRESENT)
ACAV_IN_ERP: Q2400.2(GATE) R2402.1 R2404.2 R2405.1
ACAV_IN_R: D2400.2(CATHODE) R2307.2 R2401.1 R2402.2
AD_OFF_R: PC7602.2 PQ7607.4(GATE) PR7625.2 PR7626.1 PR7643.1
ADAP_ID_VOL_G: PQ7602.1(BASE) PR7608.2 PR7610.1
ADBIA0: U6000.L18(ADBIA0) U6800.J4(ABI#) U6801.J4(ABI#)
ADBIA1: U6000.K16(ADBIA1) U6802.J4(ABI#) U6803.J4(ABI#)
ALL_SUS_PWRGD: R1218.1 R1221.1 U1201.4(OUT_Y) U1202.1(INB)
ALL_SYS_PWRGD: PR7837.2 R1223.1 U1203.2(INA) U1800.4(OUT_Y)
ALL_SYS_PWRGD_R: R1223.2 U1204.2(A)
ALL_SYS_PWRGD_VR: PR7837.1 PU7800.40(VR_ENABLE)
ALWON: PR8701.1 R2411.1 U2300.121(VCI_OUT/GPIO036)
AMBER_LED_ON#_R: Q5000.3(DRAIN) R5001.2
AMD_CLKTESTA: C6304.1 T6301.1 U6000.K8(CLKTESTA)
AMD_CLKTESTB: C6303.1 T6300.1 U6000.L7(CLKTESTB)
AU1_CBN: C3818.1 U3800.24(CBN)
AU1_CBP: C3818.2 U3800.23(CBP)
AU1_CPVEE: C3821.2 U3800.25(CPVEE)
AU1_HPOUT1_JD#: C3840.1 R3809.2 R3810.2 U3800.48(JD1)
AU1_HPOUT2_JD#: R3824.2 U3800.47(JD2)
AU1_LD1_CAP: C3824.1 R3814.2 U3800.39(LDO1_CAP)
AU1_LD2_CAP: C3823.2 U3800.21(LDO2_CAP)
AU1_LD3_CAP: C3817.2 U3800.19(LDO3_CAP)
AU1_VREF: C3822.1 U3800.38(VREF)
AUX: R3804.2 R3827.2 U3800.33(5VSTB/AUX_MODE)
AUX_EN_WOWL: T1205.1 U0400.BB17(GPD9/SLP_WLAN#)
AUX_ON: PR9106.1 U2300.3(GPIO001/SPI_CS#/32KHZ_OUT)
AZ_BITCLK_1: C1004.1 C3814.1 R1014.2 U3800.14(BCLK)
AZ_SDATA_IN0: R3805.1 U0400.BA21(HDA_SDI0/I2S0_RXD)
AZ_SDATA_OUT_1: R1015.2 U3800.17(SDATA_OUT)
AZ_SYNC_1: R1013.2 U3800.15(SYNC)
BAT1_LED#: Q5000.4(SOURCE) R2342.2 U2300.106(GPIO156/LED1)
BAT2_LED#: Q5000.1(SOURCE) R2343.2 U2300.1(GPIO157/LED0/TST_CLK_OUT)
BB_AMON_BMON: PR7724.2 R2305.2 R2311.2
BEEP: D3805.1(ANODE1) U2300.45(GPIO054/PWM1)
BKLT_IN_EC: R2344.1 U0400.R12(EDP_BKLTEN) U2300.67(GPIO101/SPI_CLK)
BLUETOOTH_EN: CON5103.37 U0400.AB2(GPP_C9/UART0_TXD)
BOARD_ID: C2314.1 R2314.2 R2315.1 U2300.111(GPIO155/ADC2)
BOARD_ID1: R1509.2 R1511.1 U0400.AC1(GPP_C12/UART1_RXD/ISH_UART1_RXD)
BOARD_ID2: R1510.2 R1512.1 U0400.AB3(GPP_C11/UART0_CTS#)
BPM0: T0405.1 U0400.C55(BPM#[0])
BPM1: T0406.1 U0400.D55(BPM#[1])
BPM2: T0411.1 U0400.B54(BPM#[2])
BPM3: T0412.1 U0400.C56(BPM#[3])
BREATH_LED#: CON5103.39 R2349.2 U2300.70(GPIO104/LED2)
C0_VDDI: C2503.1 U2500.C2(VDDI)
CAM_EN#: T0407.1 U0400.A6(GPP_E3/CPU_GP0)
CAP_LED#: U2300.93(GPIO140/KSO17) U5100.4
CASA0#: U6000.G19(CASA0B) U6800.L3(CAS#/RAS#) U6801.G3(RAS#/CAS#)
CASA1#: U6000.G16(CASA1B) U6802.G3(RAS#/CAS#) U6803.L3(CAS#/RAS#)
CCG4_CC1_P1: C5806.1 CON5700.A5(CC1) D5706.1(ANODE) U5800.9(CC1_P1)
CCG4_CC2_P1: C5805.1 CON5700.B5(CC2) D5707.1(ANODE) U5800.7(CC2_P1)
CCG4_I2C_INT#: R5812.2 U2300.32(GPIO126/SHD_SCLK) U5800.15(I2C_INT_EC)
CCG4_I2C_SCL: C1904.1 Q1901.1(SOURCE) R1916.1 R5721.1 R5724.1 R5810.2 U5800.17(I2C_SCL_SCB1_EC)
CCG4_I2C_SCL_MUX: R5818.2 U5703.21(FLIP/SCL) U5800.29(SCL_4/MUX_CTRL_1_P1)
CCG4_I2C_SDA: C1903.1 Q1901.4(SOURCE) R1914.1 R5722.1 R5723.1 R5811.2 U5800.16(I2C_SDA_SCB1_EC)
CCG4_I2C_SDA_MUX: R5817.2 U5703.22(CTL0/SDA) U5800.28(SDA_4/MUX_CTRL_2_P1)
CCG4_ID1: R5821.2 U5800.25(SCL_3)
CCG4_ID2: R5822.1 R5823.2 U5800.27(GPIO_3)
CCG4_SWD_CLK: T5804.1 U5800.2(SWD_CLK/I2C_CFG_EC)
CCG4_SWD_IO: T5803.1 U5800.1(SWD_IO/AR_RST#)
CFAN_PWM_R: C3603.1 CON3600.4 Q3602.3(DRAIN) R3610.1 R3611.2
CFG0: T0903.1 U0400.E68(CFG[0])
CFG1: T0906.1 U0400.B67(CFG[1])
CFG2: T0907.1 U0400.D65(CFG[2])
CFG3: T0900.1 U0400.D67(CFG[3])
CFG4: R0901.1 U0400.E70(CFG[4])
CFG5: T0908.1 U0400.C68(CFG[5])
CFG6: T0909.1 U0400.D68(CFG[6])
CFG7: T0904.1 U0400.C67(CFG[7])
CFG8: T0910.1 U0400.F71(CFG[8])
CFG9: T0911.1 U0400.G69(CFG[9])
CFG10: T0912.1 U0400.F70(CFG[10])
CFG11: T0913.1 U0400.G68(CFG[11])
CFG12: T0914.1 U0400.H70(CFG[12])
CFG13: T0915.1 U0400.G71(CFG[13])
CFG14: T0916.1 U0400.H69(CFG[14])
CFG15: T0917.1 U0400.G70(CFG[15])
CFG16: T0918.1 U0400.E63(CFG[16])
CFG17: T0919.1 U0400.F63(CFG[17])
CFG18: T0920.1 U0400.E66(CFG[18])
CFG19: T0921.1 U0400.F66(CFG[19])
CFG_RCOMP: R0900.1 U0400.E60(CFG_RCOMP)
CHA_DIMM0_EVENT#: CON2000.134(EVENT_N/NF) R2002.2
CHB_DIMM0_EVENT#: CON2100.134(EVENT_N/NF) R2100.2
CHG_ACIN: PC7716.1 PR7707.2 PR7710.1 PU7700.19(ACIN) Q2401.3(DRAIN)
CHG_ACOK: PR7702.2 PR7706.2 PR7709.1 PR7721.2 R2401.2
CHG_ACOK_R: PR7721.1 PU7700.24(ACOK)
CHG_AMON_R: PR7724.1 PU7700.29(AMON/BMON)
CHG_BATGONE_R: PC7721.1 PR7726.2 PU7700.25(BATGONE)
CHG_BGATE_C: PR7719.1 PU7700.32(BGATE)
CHG_BGATE_R_C: PC7722.1 PQ7701.4(GATE) PR7719.2
CHG_BOOT1_D: PC7711.2 PU7700.12(BOOT1)
CHG_BOOT2_D: PC7715.2 PU7700.4(BOOT2)
CHG_COMP: PR7717.1 PU7700.28(COMP)
CHG_COMP_R: PC7723.1 PR7717.2
CHG_CSIN: PC7708.1 PC7710.1 PR7704.2 PU7700.14(CSIN)
CHG_CSIP: PC7708.2 PC7709.1 PR7703.2 PU7700.15(CSIP)
CHG_CSON: PC7718.2 PC7719.1 PR7714.1 PU7700.1(CSON)
CHG_CSON_R: PJP7703.1 PR7714.2
CHG_CSOP: PC7717.1 PC7718.1 PR7713.1 PU7700.2(CSOP)
CHG_CSOP_R: PJP7702.1 PR7713.2
CHG_DCIN_B: PC7712.1 PR7708.1 PU7700.17(DCIN)
CHG_DCIN_R: PD7700.2(CATHODE) PD7701.2(CATHODE) PR7708.2
CHG_LG1_D: PQ7702.4(G) PU7700.9(LGATE1)
CHG_LG2_D: PQ7704.4(G) PU7700.7(LGATE2)
CHG_OTGEN_R: PT7701.1 PU7700.20(OTGEN/CMIN)
CHG_OTGPG_R: PT7702.1 PU7700.26(OTGPG/CMOUT)
CHG_PH1_D: PC7711.1 PL7700.1 PQ7700.1(S_1) PQ7700.2(S_2) PQ7700.3(S_3) PQ7702.5(D) PU7700.10(PHASE1)
CHG_PH2_D: PC7715.1 PL7700.2 PQ7703.1(S_1) PQ7703.2(S_2) PQ7703.3(S_3) PQ7704.5(D) PU7700.6(PHASE2)
CHG_PROCHOT#: PR7723.1 PU7700.23(PROCHOT#)
CHG_PROG: PR7716.1 PU7700.27(PROG)
CHG_PSYS: PR7725.2 PT7700.1
CHG_PSYS_R: PR7725.1 PU7700.30(PSYS)
CHG_SCL_R: PR7722.1 PU7700.22(SCL)
CHG_SDA_R: PR7720.1 PU7700.21(SDA)
CHG_SMBCLK: PR7722.2 R2317.2 R2318.2 U2300.9(GPIO010/SMB01_CLK/SMB01_CLK18)
CHG_SMBDAT: PR7720.2 R2316.2 R2319.2 U2300.8(GPIO007/SMB01_DATA/SMB01_DATA18)
CHG_UG1_D: PR7718.1 PU7700.11(UGATE1)
CHG_UG1_R_D: PQ7700.4(G) PR7718.2
CHG_UG2_D: PR7701.1 PU7700.5(UGATE2)
CHG_UG2_R_D: PQ7703.4(G) PR7701.2
CHG_VBAT: PR7715.1 PU7700.31(VBAT)
CKEA0: U6000.K20(CKEA0) U6800.J3(CKE#) U6801.J3(CKE#)
CKEA1: U6000.J17(CKEA1) U6802.J3(CKE#) U6803.J3(CKE#)
CLK_PCIE_LAN_REQ#: CON5104.2 R1010.2 U0400.AT8(GPP_B7/SRCCLKREQ2#)
CLK_PCIE_NVME_REQ#: R1002.2 R3104.1 U0400.AU8(GPP_B9/SRCCLKREQ4#)
CLK_PCIE_PEG_REQ#: R1004.2 R1030.1 R6908.1 U0400.AR10(GPP_B5/SRCCLKREQ0#)
CLK_PCIE_PEG_REQ#_R: R6908.2 U6000.N7(CLKREQB)
CLK_PCIE_SSD_REQ#_R: CON3100.52 R3104.2
CLK_PCIE_WLAN_REQ#: CON5103.34 R1003.2 U0400.AT7(GPP_B6/SRCCLKREQ1#)
CLK_TP_SIO: Q5104.3(DRAIN) R2338.2 U2300.78(GPIO114/PS2_CLK0)
CLK_TP_SIO_C: C5130.1 CON5100.1 D5103.1(ANODE) Q5104.4(SOURCE) R5106.2
CLKA0: R6812.2 U6000.H26(CLKA0) U6800.J12(CK) U6801.J12(CK)
CLKA0#: R6813.2 U6000.H25(CLKA0B) U6800.J11(CK#) U6801.J11(CK#)
CLKA1: R6814.2 U6000.G9(CLKA1) U6802.J12(CK) U6803.J12(CK)
CLKA1#: R6815.2 U6000.H9(CLKA1B) U6802.J11(CK#) U6803.J11(CK#)
CLKPCIE_GPU_N0: U0400.D42(CLKOUT_PCIE_N0) U6000.AK32(PCIE_REFCLKN)
CLKPCIE_GPU_P0: U0400.C42(CLKOUT_PCIE_P0) U6000.AK30(PCIE_REFCLKP)
CLKPCIE_LAN_N3: CON5104.10 U0400.D41(CLKOUT_PCIE_N2)
CLKPCIE_LAN_P3: CON5104.11 U0400.C41(CLKOUT_PCIE_P2)
CLKPCIE_SSD_N4: CON3100.53 U0400.B40(CLKOUT_PCIE_N4)
CLKPCIE_SSD_P4: CON3100.55 U0400.A40(CLKOUT_PCIE_P4)
CLKPCIE_WLAN_N1: CON5103.7 U0400.B42(CLKOUT_PCIE_N1)
CLKPCIE_WLAN_P1: CON5103.8 U0400.A42(CLKOUT_PCIE_P1)
CMP_VIN0: C3707.1 R3709.2 TR3700.1 U2300.20(GPIO020/CMP_VIN0)
CMP_VOUT0: R2333.2 R2400.1 U2300.85(GPIO124/CMP_VOUT0)
COMP_A_VCPU: PC7814.1 PR7813.1 PU7800.16(COMP_A)
COMP_A_VCPU_R: PC7816.2 PR7813.2
COMP_B_VCPU: PC7812.2 PR7812.2 PR7854.2 PU7800.4(COMP_B)
COMP_B_VCPU_R: PC7815.1 PR7812.1 PR7854.1
COMP_C_VCPU: PC7831.1 PR7842.2 PU7800.24(COMP_C)
COMP_C_VCPU_R: PC7832.1 PR7842.1
CPU_DP1_CTRL_CLK: Q2900.1(SOURCE) R2900.2 U0400.L13(GPP_E18/DDPB_CTRLCLK)
CPU_DP1_CTRL_DATA: Q2900.4(SOURCE) R2901.2 U0400.L12(GPP_E19/DDPB_CTRLDATA)
CPU_DP1_HPD: R0408.1 U0400.L9(GPP_E13/DDPB_HPD0)
CPU_DP2_HPD: Q5801.2(SOURCE) R0411.2 R5825.2 U0400.L7(GPP_E14/DDPC_HPD1)
CPU_THERM#: D3700.2(CATHODE) R3708.2 U3700.4(T_CRIT#)
CPUFAN_TACH_R: C3602.1 CON3600.3 D3600.2(CATHODE)
CSA0_0#: U6000.H22(CSA0B_0) U6800.G12(CS#/WE#) U6801.L12(WE#/CS#)
CSA0_1#: T6302.1 U6000.J22(CSA0B_1)
CSA1_0#: U6000.G13(CSA1B_0) U6802.L12(WE#/CS#) U6803.G12(CS#/WE#)
CSA1_1#: T6303.1 U6000.K13(CSA1B_1)
CSI2_COMP: R1300.2 U0400.E13(CSI2_COMP)
CSIN_R: PJP7700.2 PR7704.1
CSIP_R: PJP7701.2 PR7703.1
CSON_R: PC7720.1 PJP7703.2 PQ7701.1(SOURCE1) PQ7701.2(SOURCE2) PQ7701.3(SOURCE3) PR7712.2
CTAL_1: R1008.1 X1001.2
DAT_TP_SIO: Q5104.6(DRAIN) R2337.2 U2300.79(GPIO115/PS2_DAT0)
DAT_TP_SIO_C: C5129.1 CON5100.2 D5102.1(ANODE) Q5104.1(SOURCE) R5105.2
DBC_PANEL_EN: CON3000.16 T1501.1 U0400.AM5(GPP_B19/GSPI1_CS#)
DC_IN_ID_ADAP_Q: PC7608.1 PD7602.2(CATHODE) PL7605.2 PQ7601.3(DRAIN) PR7608.1
DC_IN_ID_ADAP_R: PQ7601.4(SOURCE) PR7607.1
DC_IN_OK: PR7613.2 PR7614.1 PR7644.1 PU7600.6(DOUT)
DCI_CLK: T5700.1 U5703.32(HPDIN/DCI_CLK)
DCI_DATA: T5701.1 U5703.29(CAD_SNK/DCI_DAT)
DCIN_R: PC7700.1 PC7701.1 PC7702.1 PC7703.1 PJP7700.1 PQ7700.5(D) PR7700.2
DCPDSW_1P0: C1611.2 U0400.AL1(DCPDSW_1P0)
DCPRTC: C1617.1 U0400.BB10(DCPRTC)
DDBIA0_0: U6000.H27(DDBIA0_0) U6801.P13(DBI2#/DBI1#)
DDBIA0_1: U6000.A27(DDBIA0_1) U6800.D2(DBI0#/DBI3#)
DDBIA0_2: U6000.C23(DDBIA0_2) U6800.P13(DBI2#/DBI1#)
DDBIA0_3: U6000.C19(DDBIA0_3) U6801.D2(DBI0#/DBI3#)
DDBIA1_0: U6000.C15(DDBIA1_0) U6803.D2(DBI0#/DBI3#)
DDBIA1_1: U6000.E9(DDBIA1_1) U6802.P13(DBI2#/DBI1#)
DDBIA1_2: U6000.C5(DDBIA1_2) U6802.D2(DBI0#/DBI3#)
DDBIA1_3: U6000.H4(DDBIA1_3) U6803.P13(DBI2#/DBI1#)
DDPC_AUXN: C5718.1 U0400.E48(DDI2_AUXN)
DDPC_AUXP: C5717.1 U0400.F48(DDI2_AUXP)
DDR0_A_ALERT_N: CON2000.116(ALERT_N) U0400.AW50(DDR0_ALERT#)
DDR0_A_PARITY: CON2000.143(PARITY) U0400.AT52(DDR0_PAR)
DDR1_B_ALERT_N: CON2100.116(ALERT_N) U0400.AN43(DDR1_ALERT#)
DDR1_B_PARITY: CON2100.143(PARITY) U0400.AP43(DDR1_PAR)
DDR_VTT_CNTL: PR8603.1 R0503.1 U0500.4(Y)
DDR_VTT_CNTL_R: R0504.1 U0400.AW67(DDR_VTT_CNTL) U0500.2(A)
DEVSLP0_HDD: CON3101.8 R1407.2
DEVSLP2_SSD: CON3100.38 R1408.2 R3102.1
DGPU_CS_CTR: T1107.1 U0400.V1(GPP_D21/SPI1_IO2)
DGPU_DMINUS: T6922.1 U6000.T2(DMINUS)
DGPU_DPLUS: T6923.1 U6000.T4(DPLUS)
DGPU_FANOUT: R6941.2 T6939.1 U6000.R5(GPIO28_FDO)
DGPU_HOLD_RST#: R1520.1 U0400.P3(GPP_D10) U6001.1(INB)
DGPU_PS0: C6200.1 R6200.2 R6201.1 U6000.AC19(PS_0)
DGPU_PS1: C6201.1 R6202.1 R6203.2 U6000.AD19(PS_1)
DGPU_PS2: C6202.1 R6204.1 R6205.2 U6000.AE17(PS_2)
DGPU_PS3: C6203.1 R6206.1 R6207.2 U6000.AE20(PS_3)
DGPU_PWR_EN: PR9426.1 PR9503.1 R7004.1 R7205.1 U0400.U1(GPP_D13/ISH_UART0_RXD/SML0BDATA)
DGPU_PWROK: PR9415.2 PU9400.3(PGOOD) U0400.C8(GPP_D18/DMIC_DATA1) U6903.1(INB) U6903.2(INA)
DGPU_TS_A: T6924.1 U6000.AE19(TS_A)
DMIC_CLK: C3816.1 CON3000.10 R3808.1
DMIC_CLK_R: R3808.2 U3800.5(GPIO1/DMIC_CLK)
DMIC_DATA: CON3000.9 R3820.1
DMIC_DATA_R: R3820.2 U3800.4(GPIO0/DMIC_DATA12)
DN1: CON5700.A7(DN1) D5700.1(ANODE) L5700.3 RN5700.4(Y)
DN1_MUX: L5700.4 RN5700.3(X) U5702.17(OUTA0-)
DN2: CON5700.B7(DN2) D5703.1(ANODE) L5701.2 RN5701.2(Y)
DN2_MUX: L5701.1 RN5701.1(X) U5702.9(OUTB0-)
DP1: CON5700.A6(DP1) D5701.1(ANODE) L5700.2 RN5700.2(Y)
DP1_MUX: L5700.1 RN5700.1(X) U5702.18(OUTA0+)
DP2: CON5700.B6(DP2) D5702.1(ANODE) L5701.3 RN5701.4(Y)
DP2_MUX: L5701.4 RN5701.3(X) U5702.8(OUTB0+)
DP_DDI2_DATA0: C5709.1 U0400.D50(DDI2_TXP[0])
DP_DDI2_DATA0#: C5710.1 U0400.C50(DDI2_TXN[0])
DP_DDI2_DATA1: C5711.1 U0400.D52(DDI2_TXP[1])
DP_DDI2_DATA1#: C5712.1 U0400.C52(DDI2_TXN[1])
DP_DDI2_DATA2: C5713.1 U0400.B50(DDI2_TXP[2])
DP_DDI2_DATA2#: C5714.1 U0400.A50(DDI2_TXN[2])
DP_DDI2_DATA3: C5715.1 U0400.C51(DDI2_TXP[3])
DP_DDI2_DATA3#: C5716.1 U0400.D51(DDI2_TXN[3])
EC_AGND: C2317.2 C2321.2 R2328.2 U2300.112(AVSS)
EC_MUTE#: D3807.1(CATHODE1) R2302.2
EC_MUTE#_R: C3833.1 D3807.3(ANODE) R3811.2 U3800.2(PDB)
EDCA0_0: U6000.H28(EDCA0_0) U6801.R13(EDC2/EDC1)
EDCA0_1: U6000.C27(EDCA0_1) U6800.C2(EDC0/EDC3)
EDCA0_2: U6000.A23(EDCA0_2) U6800.R13(EDC2/EDC1)
EDCA0_3: U6000.E19(EDCA0_3) U6801.C2(EDC0/EDC3)
EDCA1_0: U6000.E15(EDCA1_0) U6803.C2(EDC0/EDC3)
EDCA1_1: U6000.D10(EDCA1_1) U6802.R13(EDC2/EDC1)
EDCA1_2: U6000.D6(EDCA1_2) U6802.C2(EDC0/EDC3)
EDCA1_3: U6000.G5(EDCA1_3) U6803.R13(EDC2/EDC1)
EDP_AUXN: C3009.1 U0400.E45(EDP_AUXN)
EDP_AUXN_CC: C3009.2 CON3000.19
EDP_AUXP: C3008.1 U0400.F45(EDP_AUXP)
EDP_AUXP_CC: C3008.2 CON3000.18
EDP_COMP: R0413.1 U0400.E52(EDP_RCOMP)
EDP_DISP_UTIL: T0408.1 U0400.B52(EDP_DISP_UTIL)
EDP_HPD: R0415.2 R3000.1 U0400.L10(GPP_E17/EDP_HPD)
EDP_HPD_R: CON3000.14 R3000.2
EDP_TXN0: C3006.1 U0400.C47(EDP_TXN[0])
EDP_TXN0_CC: C3006.2 CON3000.22
EDP_TXN1: C3004.1 U0400.D46(EDP_TXN[1])
EDP_TXN1_CC: C3004.2 CON3000.25
EDP_TXP0: C3007.1 U0400.C46(EDP_TXP[0])
EDP_TXP0_CC: C3007.2 CON3000.21
EDP_TXP1: C3005.1 U0400.C45(EDP_TXP[1])
EDP_TXP1_CC: C3005.2 CON3000.24
EDP_VDD_EN: D3000.2(ANODE2) U0400.U13(EDP_VDDEN)
EMMC_CCLK: R2500.1 U0400.AM3(GPP_F22/EMMC_CLK)
EMMC_CLK_R: R2500.2 R2509.1 U2500.M6(CLK)
EMMC_CMD: R2513.2 U0400.AP4(GPP_F12/EMMC_CMD) U2500.M5(CMD)
EMMC_DATA0: R2501.2 U0400.AP2(GPP_F13/EMMC_DATA0) U2500.A3(DAT0)
EMMC_DATA1: R2502.2 U0400.AP1(GPP_F14/EMMC_DATA1) U2500.A4(DAT1)
EMMC_DATA2: R2503.2 U0400.AP3(GPP_F15/EMMC_DATA2) U2500.A5(DAT2)
EMMC_DATA3: R2504.2 U0400.AN3(GPP_F16/EMMC_DATA3) U2500.B2(DAT3)
EMMC_DATA4: R2505.2 U0400.AN1(GPP_F17/EMMC_DATA4) U2500.B3(DAT4)
EMMC_DATA5: R2506.2 U0400.AN2(GPP_F18/EMMC_DATA5) U2500.B4(DAT5)
EMMC_DATA6: R2507.2 U0400.AM4(GPP_F19/EMMC_DATA6) U2500.B5(DAT6)
EMMC_DATA7: R2508.2 U0400.AM1(GPP_F20/EMMC_DATA7) U2500.B6(DAT7)
EMMC_RCLK: R2512.2 U0400.AM2(GPP_F21/EMMC_RCLK) U2500.H5(DS)
EMMC_RCOMP_R: R1301.1 U0400.AT1(EMMC_RCOMP)
ENA: R5807.2 U5702.16(ENA) U5800.26(SDA_3/MUX_CTRL_3_P1/VSEL_2_P1)
ENB: R5808.2 U5702.10(ENB) U5800.36(GPIO_7)
ESPI_ALERT#: R1107.2 U0400.AY11(GPP_A6/SERIRQ) U2300.55(GPIO063/SER_IRQ/ESPI_ALERT#)
ESPI_CLK: C1104.1 J5300.7 R1108.2 U2300.57(GPIO034/PCI_CLK/ESPI_CLK)
ESPI_CS#: J5300.4 R1115.2 U2300.58(GPIO044/LFRAME#/ESPI_CS#)
ESPI_IO0: C1103.1 J5300.12 R1110.2 U2300.59(GPIO040/LAD0/ESPI_IO0)
ESPI_IO1: C1102.1 J5300.11 R1111.2 U2300.60(GPIO041/LAD1/ESPI_IO1)
ESPI_IO2: C1101.1 J5300.10 R1112.2 U2300.61(GPIO042/LAD2/ESPI_IO2)
ESPI_IO3: C1100.1 J5300.9 R1113.2 U2300.62(GPIO043/LAD3/ESPI_IO3)
ESPI_RESET#: J5300.5 R2331.2 U0400.BA11(GPP_A14/SUS_STAT#/ESPI_RESET#) U2300.53(GPIO061/LPCPD#/ESPI_RESET#)
FAN1_PWM: Q3602.2(SOURCE) R3601.2 R3610.2 U2300.47(GPIO056/PWM3)
FAN1_TACH: D3600.1(ANODE) R3602.2 U2300.40(GPIO050/TACH0)
FB_A_VCPU: PC7818.2 PR7816.1 PR7822.1 PU7800.17(FB_A)
FB_B_VCPU: PR7814.2 PR7815.1 PR7820.2 PR7855.2 PU7800.5(FB_B)
FB_B_VCPU_R: PC7820.1 PC7841.1 PR7815.2
FB_C_VCPU: PC7834.1 PR7845.2 PR7851.2 PU7800.25(FB_C)
FBA_SEN0: R6801.2 U6800.J10(SEN)
FBA_SEN1: R6802.2 U6801.J10(SEN)
FBA_SEN2: R6817.2 U6802.J10(SEN)
FBA_SEN3: R6819.2 U6803.J10(SEN)
FBA_VREFC_0: C6801.1 R6806.2 R6807.1 U6800.J14(VREFC)
FBA_VREFC_1: C6802.1 R6808.2 R6809.1 U6801.J14(VREFC)
FBA_VREFC_2: C6803.1 R6810.2 R6811.1 U6802.J14(VREFC)
FBA_VREFC_3: C6800.1 R6804.2 R6805.1 U6803.J14(VREFC)
FBA_ZQ0: R6800.2 U6800.J13(ZQ)
FBA_ZQ1: R6803.2 U6801.J13(ZQ)
FBA_ZQ2: R6816.2 U6802.J13(ZQ)
FBA_ZQ3: R6818.2 U6803.J13(ZQ)
FCCM_A: PR8015.1 PU7800.21(FCCM_A)
FCCM_B: PR7917.1 PR7919.1 PU7800.11(FCCM_B)
FCCM_C: PR8013.1 PU7800.29(FCCM_C)
FFS_I2C_SCL: C3703.1 Q3701.1(SOURCE) R1907.1 R3710.2 U3701.1(SCL/SPC)
FFS_I2C_SDA: C3702.1 Q3701.4(SOURCE) R1908.1 R3712.2 U3701.4(SDA/SDI/SDO)
FFS_INT1: R3705.1 U0400.M3(GPP_D2/SPI1_MISO)
FFS_INT2: Q3101.2(GATE) R3115.1 R3704.1 U0400.AC2(GPP_C13/UART1_TXD/ISH_UART1_TXD)
FFS_INT2_HDD: CON3101.9 Q3101.3(DRAIN) R3110.2 R3115.2
FLIP#: R5809.2 U5702.12(SBI) U5702.14(SAI) U5800.5(I2C_INT_AR_P1)
FPR_SCAN#: CON5103.40 U2300.42(GPIO052/SPI_IO2)
GC6_FB_EN_MCP: T1511.1 U0400.AP7(GPP_B16/GSPI0_CLK)
GC6_THM_DIS#: R2348.2 U2300.23(GPIO160/DAC_0)
GPIO162: R2339.2 U2300.126(VCI_IN1#/GPIO162)
GPU MAINPOWER_DISCH_G: Q7200.1(GATE) Q7201.1(GATE) Q7202.1(GATE) Q7203.1(GATE) Q7204.3(DRAIN) R7204.2
GPU_BP0: R6910.2 T6919.1 U6000.U1(BP_0)
GPU_BP1: R6911.2 T6918.1 U6000.U3(BP_1)
GPU_CS: T6946.1 U6000.N8(GPIO_22_ROMCSB)
GPU_DBG_DATA0: T6917.1 U6000.Y7(DBG_DATA0)
GPU_DBG_DATA1: T6916.1 U6000.Y8(DBG_DATA1)
GPU_DBG_DATA2: T6915.1 U6000.AB2(DBG_DATA2)
GPU_DBG_DATA3: T6914.1 U6000.AB4(DBG_DATA3)
GPU_DBG_DATA4: T6913.1 U6000.AB7(DBG_DATA4)
GPU_DBG_DATA5: T6912.1 U6000.AB8(DBG_DATA5)
GPU_DBG_DATA6: T6911.1 U6000.AB9(DBG_DATA6)
GPU_DBG_DATA7: T6910.1 U6000.AC7(DBG_DATA7)
GPU_DBG_DATA8: T6909.1 U6000.AC8(DBG_DATA8)
GPU_DBG_DATA9: T6908.1 U6000.AD7(DBG_DATA9)
GPU_DBG_DATA10: T6907.1 U6000.AC10(DBG_DATA10)
GPU_DBG_DATA11: T6906.1 U6000.AD9(DBG_DATA11)
GPU_DBG_DATA12: T6929.1 U6000.AE8(NC_DBG_DATA12)
GPU_DBG_DATA13: T6928.1 U6000.Y11(NC_DBG_DATA13)
GPU_DBG_DATA14: T6927.1 U6000.AE9(NC_DBG_DATA14)
GPU_DBG_DATA15: T6926.1 U6000.L9(NC_DBG_DATA15)
GPU_DBG_DATA16: T6925.1 U6000.N9(NC_DBG_DATA16)
GPU_DIECRACKMON: T6940.1 U6000.AM26(DIECRACKMON)
GPU_DISCHARGE: Q7204.1(GATE) R7205.2
GPU_EVENT_MCP#: T1510.1 U0400.AN8(GPP_B15/GSPI0_CS#)
GPU_GPIO6: T6941.1 U6000.T8(GPIO_6)
GPU_GPIO11: T6931.1 U6000.N6(GPIO_11)
GPU_GPIO12: T6930.1 U6000.N5(GPIO_12)
GPU_GPIO13: T6932.1 U6000.N3(GPIO_13)
GPU_GPIO15: T6933.1 U6000.N1(GPIO_15_PWRCNTL_0)
GPU_GPIO16: T6934.1 U6000.M4(GPIO_16)
GPU_GPIO20: T6935.1 U6000.P8(GPIO_20_PWRCNTL_1)
GPU_GPIO21: T6936.1 U6000.P7(GPIO_21)
GPU_GPIO29: T6937.1 U6000.AK10(GPIO_29)
GPU_GPIO30: T6938.1 U6000.AM10(GPIO_30)
GPU_I2C_SCL: R6912.2 T6921.1 U6000.R1(SCL)
GPU_I2C_SDA: R6913.2 T6920.1 U6000.R3(SDA)
GPU_OVERT: Q6901.1(GATE) R6914.1 U6000.M2(GPIO_19_CTF)
GPU_OVERT_R: Q6901.3(DRAIN) R2403.1
GPU_PWR_LEVEL: R6938.2 U2300.10(GPIO011/NSMI/NEMI_INT) U6000.T9(GPIO_5_AC_BATT)
GPU_SCLK: T6945.1 U6000.P2(GPIO_10_ROMSCK)
GPU_SI: T6943.1 U6000.P4(GPIO_9_ROMSI)
GPU_SO: T6944.1 U6000.P10(GPIO_8_ROMSO)
GPU_TCK: T6902.1 U6000.L3(JTAG_TCK)
GPU_TDI: T6901.1 U6000.L5(JTAG_TDI)
GPU_TDO: T6904.1 U6000.K4(JTAG_TDO)
GPU_TESTEN: R6936.2 R6943.2 U6000.K7(TESTEN)
GPU_THERMAL_INT#: T6948.1 U6000.R6(GPIO_17_THERMAL_INT)
GPU_THM_SMBCLK: Q1900.6(DRAIN) Q6900.6(DRAIN) R1910.2 U2300.12(GPIO013/SMB02_CLK/SMB02_CLK18)
GPU_THM_SMBCLK_R: Q6900.1(SOURCE) R6934.2 U6000.U7(SMBCLK)
GPU_THM_SMBDAT: Q1900.3(DRAIN) Q6900.3(DRAIN) R1909.2 U2300.11(GPIO012/SMB02_DATA/SMB02_DATA18)
GPU_THM_SMBDAT_R: Q6900.4(SOURCE) R6935.2 U6000.U8(SMBDAT)
GPU_TMS: T6903.1 U6000.L1(JTAG_TMS)
GPU_TREST#: T6900.1 U6000.L6(JTAG_TRSTB)
GPU_WAKE#_R: R6937.2 U6000.AJ27(WAKEB)
H_CPU_SVIDALERT#: R0603.1 U0400.B63(VIDALERT#)
H_CPU_SVIDCLK: R0604.2 U0400.A63(VIDSCK)
H_CPU_SVIDDAT: R0605.2 U0400.D64(VIDSOUT)
H_PECI: R2300.1 U2300.94(GPIO033/PECI_DAT/SB_TSI_DAT)
HDA_BCLK_R: R1014.1 U0400.AY22(HDA_BLK/I2S0_SCLK)
HDA_RST#: D3807.2(CATHODE2) R1016.2
HDA_RST#_R: R1016.1 U0400.AW22(HDA_RST#/I2S1_SCLK)
HDA_SDI1_DSP: T1002.1 U0400.AY21(HDA_SDI1/I2S1_RXD)
HDA_SDO_R: R1012.2 R1015.1 U0400.BB22(HDA_SDO/I2S0_TXD)
HDA_SYNC_R: R1013.1 U0400.BA22(HDA_SYNC/I2S0_SFRM)
HDD_DET#: T1100.1 U0400.M1(GPP_D0/SPI1_CS#)
HDD_DEVSLP: R1407.1 U0400.J1(GPP_E4/DEVSLP0)
HDD_EN_PCH: U0400.J4(GPP_D3/SPI1_MOSI) U3100.4(EN/EN#)
HDMI_CLKN_SNK: C2901.1 L2603.3 R2610.1 R2909.2 RN2606.1(X)
HDMI_CLKP_SNK: C2905.1 L2603.2 R2610.2 R2910.2 RN2606.3(X)
HDMI_DATA0: C2903.2 U0400.F55(DDI1_TXP[0])
HDMI_DATA0#: C2902.2 U0400.E55(DDI1_TXN[0])
HDMI_DATA1: C2906.2 U0400.F58(DDI1_TXP[1])
HDMI_DATA1#: C2900.2 U0400.E58(DDI1_TXN[1])
HDMI_DATA2: C2907.2 U0400.G53(DDI1_TXP[2])
HDMI_DATA2#: C2904.2 U0400.F53(DDI1_TXN[2])
HDMI_DATA3: C2905.2 U0400.G56(DDI1_TXP[3])
HDMI_DATA3#: C2901.2 U0400.F56(DDI1_TXN[3])
HDMI_HPD: Q2901.4(SOURCE) R0408.2 R2913.1
HDMI_HPD_SNK: CON2600.19(HOT_PLUG_DETECT/HEAC-) D2600.1(ANODE) Q2901.3(DRAIN) R2602.2
HDMI_POWER: C2600.1 C2601.1 CON2600.18(+5VPOWER) F2600.1
HDMI_SCLK_SNK: C2908.1 CON2600.15(SCL) D2900.1(ANODE) Q2900.6(DRAIN) R2912.2
HDMI_SDATA_SNK: C2909.1 CON2600.16(SDA) D2901.1(ANODE) Q2900.3(DRAIN) R2911.2
HDMI_TMDS_CLK_N: CON2600.12(TMDS_CLOCK-) L2603.4 RN2606.2(Y) U2600.1(CH1) U2600.10(N.C.4)
HDMI_TMDS_CLK_P: CON2600.10(TMDS_CLOCK+) L2603.1 RN2606.4(Y) U2600.2(CH2) U2600.9(N.C.3)
HDMI_TMDS_DATA0_N: CON2600.9(TMDS_DATA0-) L2600.4 RN2603.2(Y) U2600.4(CH3) U2600.7(N.C.2)
HDMI_TMDS_DATA0_P: CON2600.7(TMDS_DATA0+) L2600.1 RN2603.4(Y) U2600.5(CH4) U2600.6(N.C.1)
HDMI_TMDS_DATA1_N: CON2600.6(TMDS_DATA1-) L2601.4 RN2604.2(Y) U2601.5(CH4) U2601.6(N.C.1)
HDMI_TMDS_DATA1_P: CON2600.4(TMDS_DATA1+) L2601.1 RN2604.4(Y) U2601.4(CH3) U2601.7(N.C.2)
HDMI_TMDS_DATA2_N: CON2600.3(TMDS_DATA2-) L2602.4 RN2605.2(Y) U2601.2(CH2) U2601.9(N.C.3)
HDMI_TMDS_DATA2_P: CON2600.1(TMDS_DATA2+) L2602.1 RN2605.4(Y) U2601.1(CH1) U2601.10(N.C.4)
HDMI_TXN0_SNK: C2904.1 L2600.3 R2607.1 R2903.2 RN2603.1(X)
HDMI_TXN1_SNK: C2900.1 L2601.3 R2608.1 R2905.2 RN2604.1(X)
HDMI_TXN2_SNK: C2902.1 L2602.3 R2609.1 R2907.2 RN2605.1(X)
HDMI_TXP0_SNK: C2907.1 L2600.2 R2607.2 R2904.2 RN2603.3(X)
HDMI_TXP1_SNK: C2906.1 L2601.2 R2608.2 R2906.2 RN2604.3(X)
HDMI_TXP2_SNK: C2903.1 L2602.2 R2609.2 R2908.2 RN2605.3(X)
HOST_DEBUG_TX: T2304.1 U2300.81(GPIO117/TFDP_CLK/UART_TX)
HPOUT1_JD#: D3806.1(ANODE) J3800.6 R3810.1
HPOUT_L: C3830.1 R3802.1 R3829.2 U3800.27(HPOUT_L)
HPOUT_R: C3831.1 R3803.1 R3828.2 U3800.26(HPOUT_R)
HW_ACAV_IN: R2307.1 U2300.128(VCI_OVRD_IN/GPIO164)
HW_ACAVIN_NB: PR7614.2 U2300.24(GPIO161/DAC_1)
I2C0_SCL_TCH_PAD: Q5103.3(DRAIN) R1515.2 U0400.U6(GPP_C17/I2C0_SCL)
I2C0_SDA_TCH_PAD: Q5103.6(DRAIN) R1516.2 U0400.U7(GPP_C16/I2C0_SDA)
I2C_SCL_TP_MOS: C5128.1 CON5100.6 D5101.1(ANODE) Q5103.4(SOURCE) R5104.2
I2C_SDA_TP_MOS: C5127.1 CON5100.7 D5100.1(ANODE) Q5103.1(SOURCE) R5103.2
I2S1_SFRM: T1003.1 U0400.AY20(I2S1_SFRM)
I2S1_TXD: T1004.1 U0400.AW20(I2S1_TXD)
I_ADP: C2317.1 R2311.1 U2300.110(GPIO154/ADC3)
I_BATT: C2321.1 R2305.1 U2300.114(GPIO121/ADC0)
IC_DELAY: PC7603.1 PU7600.3(CD)
ICSP_CLK: T2306.1 U2300.101(GPIO145(ICSP_CLOCK))
ICSP_CLR: T2307.1 U2300.87(ICSP_MCLR)
ICSP_DAT: T2305.1 U2300.102(GPIO146(ICSP_DATA))
IMON_A_VCPU: PC7825.2 PR7825.1 PU7800.14(IMON_A)
IMON_B_VCPU: PC7824.2 PR7824.2 PR7856.2 PU7800.2(IMON_B)
IMON_C_VCPU: PC7835.2 PR7849.2 PU7800.23(IMON_C)
INT1: R3705.2 U3701.12(INT1)
INT2: R3704.2 U3701.11(INT2)
INTRUDER#: R1206.2 U0400.AP16(INTRUDER#)
IR_CAM_DET#: T1509.1 U0400.P4(GPP_D11)
ISH_I2C0_SCL: Q3701.6(DRAIN) R3711.2 U0400.N3(GPP_D6/ISH_I2C0_SCL)
ISH_I2C0_SDA: Q3701.3(DRAIN) R3713.2 U0400.M4(GPP_D5/ISH_I2C0_SDA)
ISUM_A_R: PR7805.2 PRT7801.1
ISUMN_A_R: PC7811.1 PR7809.2
ISUMN_A_VCPU: PR7809.1 PR7810.1 PU7800.20(ISUMN_A)
ISUMN_B_VCPU: PC7805.1 PR7806.2 PR7853.2 PU7800.8(ISUMN_B)
ISUMN_B_VCPU_R: PC7805.2 PR7804.2
ISUMN_C_R: PC7830.1 PR7835.2 PU7800.28(ISUMN_C)
ISUMN_C_RR: PC7830.2 PR7838.2
ITP_PMODE: T0901.1 U0400.E8(ITP_PMODE)
KB_DET#: CON5102.30 R1518.2 U0400.AD4(GPP_C23/UART2_CTS#)
KB_LED_BL_DET: R5101.1 R5110.1 U0400.W8(GPP_G6/SD_CLK)
KB_LED_BL_DET_R: CON5101.2 R5101.2
KB_LED_PWM: Q5100.1(GATE) R2347.2 U2300.44(GPIO053/PWM0)
KSI0: C5123.1 CON5102.22 RN5101.1(3) U2300.98(GPIO143/KSI0/DTR#)
KSI1: C5122.1 CON5102.24 RN5101.5(3) U2300.99(GPIO144/KSI1/DCD#)
KSI2: C5121.1 CON5102.26 RN5100.1(3) U2300.6(GPIO005/SMB00_DATA/SMB00_DATA18)
KSI3: C5117.1 CON5102.23 RN5101.3 U2300.7(GPIO006/SMB00_CLK/SMB00_CLK18/K)
KSI4: C5110.1 CON5102.27 RN5100.3 U2300.104(GPIO147/KSI4/DSR#)
KSI5: C5108.1 CON5102.25 RN5101.7(3) U2300.105(GPIO150/KSI5/RI#)
KSI6: C5107.1 CON5102.28 RN5100.5(3) U2300.107(GPIO151/KSI6/RTS#)
KSI7: C5105.1 CON5102.29 RN5100.7(3) U2300.108(GPIO152/KSI7/CTS#)
KSO0: C5120.1 CON5102.13 U2300.2(GPIO027/KSO00/PVT_IO1)
KSO1: C5119.1 CON5102.15 U2300.14(GPIO015/KSO01/PVT_CS#)
KSO2: C5118.1 CON5102.14 U2300.15(GPIO016/KSO02/PVT_SCLK)
KSO3: C5116.1 CON5102.16 U2300.16(GPIO017/KSO03/PVT_IO0)
KSO4: C5115.1 CON5102.20 U2300.37(GPIO045/BCM_INT1#/KSO04)
KSO5: C5114.1 CON5102.21 U2300.38(GPIO046/BCM_DAT1/KSO05)
KSO6: C5113.1 CON5102.18 U2300.39(GPIO047/BCM_CLK1/KSO06)
KSO7: C5112.1 CON5102.19 U2300.50(GPIO025/KSO07/PVT_IO2)
KSO8: C5111.1 CON5102.17 U2300.46(GPIO055/PWM2/KSO08/PVT_IO3)
KSO9: C5109.1 CON5102.7 R2320.2 U2300.68(GPIO102/KSO09[CR_STRAP])
KSO10: C5106.1 CON5102.5 U2300.72(GPIO106/KSO10)
KSO11: C5104.1 CON5102.6 U2300.74(GPIO110/KSO11)
KSO12: C5103.1 CON5102.12 U2300.75(GPIO111/KSO12)
KSO13: C5102.1 CON5102.9 U2300.76(GPIO112/PS2_CLK1A/KSO13)
KSO14: C5101.1 CON5102.8 U2300.77(GPIO113/PS2_DAT1A/KSO14)
KSO15: C5100.1 CON5102.10 U2300.86(GPIO125/KSO15)
KSO16: C5132.1 CON5102.11 U2300.92(GPIO132/KSO16)
L: C3808.1 R3829.1
L_BKLT_CTRL: D3003.1(ANODE) R3002.1 U0400.R11(EDP_BKLTCTL)
L_BKLT_CTRL_R: C3011.1 CON3000.12 D3003.2(CATHODE) D3004.2(CATHODE) R3002.2 R3009.1
LAN_WAKE#: C1204.1 R1209.2 R2345.2 U0400.AM15(GPD2/LAN_WAKE#)
LANWAKE#: R2345.1 U2300.35(GPIO031/BCM_DAT0/PWM5)
LCD_CBL_DET#: CON3000.4 R1519.2 T1504.1 U0400.W4(GPP_C10/UART0_RTS#)
LCD_TST: CON3000.15 U2300.26(GPIO166/CMP_VREF1/UART_CLK)
LCD_VCC_TEST_EN: D3000.1(ANODE1) D3004.1(ANODE) U2300.113(GPIO122/ADC1)
LID_CL_SIO#: R3707.2 U2300.66(GPIO100/NEC_SCI) U3702.1(OUT)
LINE2_L: C3808.2 U3800.36(LINE2_L)
LINE2_R: C3809.2 U3800.35(LINE2_R)
M2_LED#_R: CON3100.10 R3116.2
M2_SSD_PEDET: R1406.1 U0400.G4(GPP_E2/SATAXPCIE2/SATAGP2)
M2_SSD_PEDET_N: Q3100.3(DRAIN) R1406.2 R3105.2 R3106.2
M_A_A0: CON2000.144(A0) U0400.AY50(DDR0_MA[0]/DDR0_CAB[9]/DDR0_MA[)
M_A_A1: CON2000.133(A1) U0400.BB50(DDR0_MA[1]/DDR0_CAB[8]/DDR0_MA[)
M_A_A2: CON2000.132(A2) U0400.AY51(DDR0_MA[2]/DDR0_CAB[5]/DDR0_MA[)
M_A_A3: CON2000.131(A3) U0400.BA50(DDR0_MA[3])
M_A_A4: CON2000.128(A4) U0400.BB52(DDR0_MA[4])
M_A_A5: CON2000.126(A5) U0400.BA51(DDR0_MA[5]/DDR0_CAA[0]/DDR0_MA[)
M_A_A6: CON2000.127(A6) U0400.BA52(DDR0_MA[6]/DDR0_CAA[2]/DDR0_MA[)
M_A_A7: CON2000.122(A7) U0400.AW52(DDR0_MA[7]/DDR0_CAA[4]/DDR0_MA[)
M_A_A8: CON2000.125(A8) U0400.AY52(DDR0_MA[8]/DDR0_CAA[3]/DDR0_MA[)
M_A_A9: CON2000.121(A9) U0400.BB54(DDR0_MA[9]/DDR0_CAA[1]/DDR0_MA[)
M_A_A10: CON2000.146(A10/AP) U0400.AT50(DDR0_MA[10]/DDR0_CAB[7]/DDR0_MA)
M_A_A11: CON2000.120(A11) U0400.BA54(DDR0_MA[11]/DDR0_CAA[7]/DDR0_MA)
M_A_A12: CON2000.119(A12) U0400.AW54(DDR0_MA[12]/DDR0_CAA[6]/DDR0_MA)
M_A_A13: CON2000.158(A13) U0400.AU46(DDR0_MA[13]/DDR0_CAB[0]/DDR0_MA)
M_A_A14: CON2000.151(WE_N/A14) U0400.AT46(DDR0_WE#/DDR0_CAB[2]/DDR0_MA[14)
M_A_A15: CON2000.156(CAS_N/A15) U0400.AU48(DDR0_CAS#/DDR0_CAB[1]/DDR0_MA[1)
M_A_A16: CON2000.152(RAS_N/A16) U0400.AU50(DDR0_RAS#/DDR0_CAB[3]/DDR0_MA[1)
M_A_ACT_N: CON2000.114(ACT_N) U0400.BA55(DDR0_MA[15]/DDR0_CAA[8]/DDR0_AC)
M_A_BA0: CON2000.150(BA0) U0400.AU52(DDR0_BA[0]/DDR0_CAB[4]/DDR0_BA[)
M_A_BA1: CON2000.145(BA1) U0400.AT48(DDR0_BA[1]/DDR0_CAB[6]/DDR0_BA[)
M_A_BG0: CON2000.115(BG0) U0400.AY55(DDR0_BA[2]/DDR0_CAA[5]/DDR0_BG[)
M_A_BG1: CON2000.113(BG1) U0400.AY54(DDR0_MA[14]/DDR0_CAA[9]/DDR0_BG)
M_A_D0: CON2000.8(DQ0) U0400.AL71(DDR0_DQ[0])
M_A_D1: CON2000.3(DQ5) U0400.AL68(DDR0_DQ[1])
M_A_D2: CON2000.21(DQ3) U0400.AN68(DDR0_DQ[2])
M_A_D3: CON2000.20(DQ2) U0400.AN69(DDR0_DQ[3])
M_A_D4: CON2000.4(DQ4) U0400.AL70(DDR0_DQ[4])
M_A_D5: CON2000.7(DQ1) U0400.AL69(DDR0_DQ[5])
M_A_D6: CON2000.17(DQ7) U0400.AN70(DDR0_DQ[6])
M_A_D7: CON2000.16(DQ6) U0400.AN71(DDR0_DQ[7])
M_A_D8: CON2000.29(DQ9) U0400.AR70(DDR0_DQ[8])
M_A_D9: CON2000.28(DQ8) U0400.AR68(DDR0_DQ[9])
M_A_D10: CON2000.42(DQ11) U0400.AU71(DDR0_DQ[10])
M_A_D11: CON2000.41(DQ10) U0400.AU68(DDR0_DQ[11])
M_A_D12: CON2000.25(DQ13) U0400.AR71(DDR0_DQ[12])
M_A_D13: CON2000.24(DQ12) U0400.AR69(DDR0_DQ[13])
M_A_D14: CON2000.38(DQ14) U0400.AU70(DDR0_DQ[14])
M_A_D15: CON2000.37(DQ15) U0400.AU69(DDR0_DQ[15])
M_A_D16: CON2000.50(DQ16) U0400.BB65(DDR0_DQ[16]/DDR0_DQ[32])
M_A_D17: CON2000.45(DQ21) U0400.AW65(DDR0_DQ[17]/DDR0_DQ[33])
M_A_D18: CON2000.58(DQ22) U0400.AW63(DDR0_DQ[18]/DDR0_DQ[34])
M_A_D19: CON2000.62(DQ18) U0400.AY63(DDR0_DQ[19]/DDR0_DQ[35])
M_A_D20: CON2000.46(DQ20) U0400.BA65(DDR0_DQ[20]/DDR0_DQ[36])
M_A_D21: CON2000.49(DQ17) U0400.AY65(DDR0_DQ[21]/DDR0_DQ[37])
M_A_D22: CON2000.63(DQ19) U0400.BA63(DDR0_DQ[22]/DDR0_DQ[38])
M_A_D23: CON2000.59(DQ23) U0400.BB63(DDR0_DQ[23]/DDR0_DQ[39])
M_A_D24: CON2000.79(DQ30) U0400.BA61(DDR0_DQ[24]/DDR0_DQ[40])
M_A_D25: CON2000.67(DQ29) U0400.AW61(DDR0_DQ[25]/DDR0_DQ[41])
M_A_D26: CON2000.83(DQ26) U0400.BB59(DDR0_DQ[26]/DDR0_DQ[42])
M_A_D27: CON2000.70(DQ24) U0400.AW59(DDR0_DQ[27]/DDR0_DQ[43])
M_A_D28: CON2000.66(DQ28) U0400.BB61(DDR0_DQ[28]/DDR0_DQ[44])
M_A_D29: CON2000.71(DQ25) U0400.AY61(DDR0_DQ[29]/DDR0_DQ[45])
M_A_D30: CON2000.84(DQ27) U0400.BA59(DDR0_DQ[30]/DDR0_DQ[46])
M_A_D31: CON2000.80(DQ31) U0400.AY59(DDR0_DQ[31]/DDR0_DQ[47])
M_A_D32: CON2000.170(DQ36) U0400.AY39(DDR0_DQ[32]/DDR1_DQ[0])
M_A_D33: CON2000.169(DQ37) U0400.AW39(DDR0_DQ[33]/DDR1_DQ[1])
M_A_D34: CON2000.186(DQ35) U0400.AY37(DDR0_DQ[34]/DDR1_DQ[2])
M_A_D35: CON2000.187(DQ34) U0400.AW37(DDR0_DQ[35]/DDR1_DQ[3])
M_A_D36: CON2000.173(DQ33) U0400.BB39(DDR0_DQ[36]/DDR1_DQ[4])
M_A_D37: CON2000.174(DQ32) U0400.BA39(DDR0_DQ[37]/DDR1_DQ[5])
M_A_D38: CON2000.183(DQ38) U0400.BA37(DDR0_DQ[38]/DDR1_DQ[6])
M_A_D39: CON2000.182(DQ39) U0400.BB37(DDR0_DQ[39]/DDR1_DQ[7])
M_A_D40: CON2000.195(DQ40) U0400.AY35(DDR0_DQ[40]/DDR1_DQ[8])
M_A_D41: CON2000.190(DQ45) U0400.AW35(DDR0_DQ[41]/DDR1_DQ[9])
M_A_D42: CON2000.204(DQ47) U0400.AY33(DDR0_DQ[42]/DDR1_DQ[10])
M_A_D43: CON2000.207(DQ42) U0400.AW33(DDR0_DQ[43]/DDR1_DQ[11])
M_A_D44: CON2000.191(DQ44) U0400.BB35(DDR0_DQ[44]/DDR1_DQ[12])
M_A_D45: CON2000.194(DQ41) U0400.BA35(DDR0_DQ[45]/DDR1_DQ[13])
M_A_D46: CON2000.208(DQ43) U0400.BA33(DDR0_DQ[46]/DDR1_DQ[14])
M_A_D47: CON2000.203(DQ46) U0400.BB33(DDR0_DQ[47]/DDR1_DQ[15])
M_A_D48: CON2000.216(DQ48) U0400.AY31(DDR0_DQ[48]/DDR1_DQ[32])
M_A_D49: CON2000.212(DQ53) U0400.AW31(DDR0_DQ[49]/DDR1_DQ[33])
M_A_D50: CON2000.224(DQ54) U0400.AY29(DDR0_DQ[50]/DDR1_DQ[34])
M_A_D51: CON2000.228(DQ50) U0400.AW29(DDR0_DQ[51]/DDR1_DQ[35])
M_A_D52: CON2000.215(DQ49) U0400.BB31(DDR0_DQ[52]/DDR1_DQ[36])
M_A_D53: CON2000.211(DQ52) U0400.BA31(DDR0_DQ[53]/DDR1_DQ[37])
M_A_D54: CON2000.229(DQ51) U0400.BA29(DDR0_DQ[54]/DDR1_DQ[38])
M_A_D55: CON2000.225(DQ55) U0400.BB29(DDR0_DQ[55]/DDR1_DQ[39])
M_A_D56: CON2000.233(DQ61) U0400.AY27(DDR0_DQ[56]/DDR1_DQ[40])
M_A_D57: CON2000.237(DQ56) U0400.AW27(DDR0_DQ[57]/DDR1_DQ[41])
M_A_D58: CON2000.249(DQ58) U0400.AY25(DDR0_DQ[58]/DDR1_DQ[42])
M_A_D59: CON2000.250(DQ59) U0400.AW25(DDR0_DQ[59]/DDR1_DQ[43])
M_A_D60: CON2000.232(DQ60) U0400.BB27(DDR0_DQ[60]/DDR1_DQ[44])
M_A_D61: CON2000.236(DQ57) U0400.BA27(DDR0_DQ[61]/DDR1_DQ[45])
M_A_D62: CON2000.246(DQ63) U0400.BA25(DDR0_DQ[62]/DDR1_DQ[46])
M_A_D63: CON2000.245(DQ62) U0400.BB25(DDR0_DQ[63]/DDR1_DQ[47])
M_A_DIM0_CKE0: CON2000.109(CKE0) U0400.BA56(DDR0_CKE[0])
M_A_DIM0_CKE1: CON2000.110(CKE1) U0400.BB56(DDR0_CKE[1])
M_A_DIM0_CLK0: CON2000.137(CK0_T) U0400.AT53(DDR0_CKP[0])
M_A_DIM0_CLK1: CON2000.138(CK1_T/NF) U0400.AT55(DDR0_CKP[1])
M_A_DIM0_CLK#0: CON2000.139(CK0_C) U0400.AU53(DDR0_CKN[0])
M_A_DIM0_CLK#1: CON2000.140(CK1_C/NF) U0400.AU55(DDR0_CKN[1])
M_A_DIM0_CS#0: CON2000.149(CS0_N) U0400.AU45(DDR0_CS#[0])
M_A_DIM0_CS#1: CON2000.157(CS1_N) U0400.AU43(DDR0_CS#[1])
M_A_DIM0_ODT0: CON2000.155(ODT0) U0400.AT45(DDR0_ODT[0])
M_A_DIM0_ODT1: CON2000.161(ODT1) U0400.AT43(DDR0_ODT[1])
M_A_DQS0: CON2000.13(DQS0_T) U0400.AM69(DDR0_DQSP[0])
M_A_DQS1: CON2000.34(DQS1_T) U0400.AT70(DDR0_DQSP[1])
M_A_DQS2: CON2000.55(DQS2_T) U0400.AY64(DDR0_DQSP[2]/DDR0_DQSP[4])
M_A_DQS3: CON2000.76(DQS3_T) U0400.BA60(DDR0_DQSP[3]/DDR0_DQSP[5])
M_A_DQS4: CON2000.179(DQS4_T) U0400.AY38(DDR0_DQSP[4]/DDR1_DQSP[0])
M_A_DQS5: CON2000.200(DQS5_T) U0400.BA34(DDR0_DQSP[5]/DDR1_DQSP[1])
M_A_DQS6: CON2000.221(DQS6_T) U0400.AY30(DDR0_DQSP[6]/DDR1_DQSP[4])
M_A_DQS7: CON2000.242(DQS7_T) U0400.BA26(DDR0_DQSP[7]/DDR1_DQSP[5])
M_A_DQS#0: CON2000.11(DQS0_C) U0400.AM70(DDR0_DQSN[0])
M_A_DQS#1: CON2000.32(DQS1_C) U0400.AT69(DDR0_DQSN[1])
M_A_DQS#2: CON2000.53(DQS2_C) U0400.BA64(DDR0_DQSN[2]/DDR0_DQSN[4])
M_A_DQS#3: CON2000.74(DQS3_C) U0400.AY60(DDR0_DQSN[3]/DDR0_DQSN[5])
M_A_DQS#4: CON2000.177(DQS4_C) U0400.BA38(DDR0_DQSN[4]/DDR1_DQSN[0])
M_A_DQS#5: CON2000.198(DQS5_C) U0400.AY34(DDR0_DQSN[5]/DDR1_DQSN[1])
M_A_DQS#6: CON2000.219(DQS6_C) U0400.BA30(DDR0_DQSN[6]/DDR1_DQSN[4])
M_A_DQS#7: CON2000.240(DQS7_C) U0400.AY26(DDR0_DQSN[7]/DDR1_DQSN[5])
M_B_A0: CON2100.144(A0) U0400.BA46(DDR1_MA[0]/DDR1_CAB[9]/DDR1_MA[)
M_B_A1: CON2100.133(A1) U0400.AY46(DDR1_MA[1]/DDR1_CAB[8]/DDR1_MA[)
M_B_A2: CON2100.132(A2) U0400.AY47(DDR1_MA[2]/DDR1_CAB[5]/DDR1_MA[)
M_B_A3: CON2100.131(A3) U0400.BB46(DDR1_MA[3])
M_B_A4: CON2100.128(A4) U0400.BA47(DDR1_MA[4])
M_B_A5: CON2100.126(A5) U0400.AY48(DDR1_MA[5]/DDR1_CAA[0]/DDR1_MA[)
M_B_A6: CON2100.127(A6) U0400.BA48(DDR1_MA[6]/DDR1_CAA[2]/DDR1_MA[)
M_B_A7: CON2100.122(A7) U0400.AP48(DDR1_MA[7]/DDR1_CAA[4]/DDR1_MA[)
M_B_A8: CON2100.125(A8) U0400.BB48(DDR1_MA[8]/DDR1_CAA[3]/DDR1_MA[)
M_B_A9: CON2100.121(A9) U0400.AP50(DDR1_MA[9]/DDR1_CAA[1]/DDR1_MA[)
M_B_A10: CON2100.146(A10/AP) U0400.AW46(DDR1_MA[10]/DDR1_CAB[7]/DDR1_MA)
M_B_A11: CON2100.120(A11) U0400.AN48(DDR1_MA[11]/DDR1_CAA[7]/DDR1_MA)
M_B_A12: CON2100.119(A12) U0400.AN50(DDR1_MA[12]/DDR1_CAA[6]/DDR1_MA)
M_B_A13: CON2100.158(A13) U0400.BA43(DDR1_MA[13]/DDR1_CAB[0]/DDR1_MA)
M_B_A14: CON2100.151(WE_N/A14) U0400.AY44(DDR1_WE#/DDR1_CAB[2]/DDR1_MA[14)
M_B_A15: CON2100.156(CAS_N/A15) U0400.AY43(DDR1_CAS#/DDR1_CAB[1]/DDR1_MA[1)
M_B_A16: CON2100.152(RAS_N/A16) U0400.AW44(DDR1_RAS#/DDR1_CAB[3]/DDR1_MA[1)
M_B_ACT_N: CON2100.114(ACT_N) U0400.AN53(DDR1_MA[15]/DDR1_CAA[8]/DDR1_AC)
M_B_BA0: CON2100.150(BA0) U0400.BB44(DDR1_BA[0]/DDR1_CAB[4]/DDR1_BA[)
M_B_BA1: CON2100.145(BA1) U0400.BA44(DDR1_BA[1]/DDR1_CAB[6]/DDR1_BA[)
M_B_BG0: CON2100.115(BG0) U0400.AP52(DDR1_BA[2]/DDR1_CAA[5]/DDR1_BG[)
M_B_BG1: CON2100.113(BG1) U0400.AN52(DDR1_MA[14]/DDR1_CAA[9]/DDR1_BG)
M_B_D0: CON2100.24(DQ12) U0400.AF65(DDR1_DQ[0]/DDR0_DQ[16])
M_B_D1: CON2100.25(DQ13) U0400.AF64(DDR1_DQ[1]/DDR0_DQ[17])
M_B_D2: CON2100.37(DQ15) U0400.AK65(DDR1_DQ[2]/DDR0_DQ[18])
M_B_D3: CON2100.38(DQ14) U0400.AK64(DDR1_DQ[3]/DDR0_DQ[19])
M_B_D4: CON2100.29(DQ9) U0400.AF66(DDR1_DQ[4]/DDR0_DQ[20])
M_B_D5: CON2100.28(DQ8) U0400.AF67(DDR1_DQ[5]/DDR0_DQ[21])
M_B_D6: CON2100.42(DQ11) U0400.AK67(DDR1_DQ[6]/DDR0_DQ[22])
M_B_D7: CON2100.41(DQ10) U0400.AK66(DDR1_DQ[7]/DDR0_DQ[23])
M_B_D8: CON2100.8(DQ0) U0400.AF70(DDR1_DQ[8]/DDR0_DQ[24])
M_B_D9: CON2100.3(DQ5) U0400.AF68(DDR1_DQ[9]/DDR0_DQ[25])
M_B_D10: CON2100.17(DQ7) U0400.AH71(DDR1_DQ[10]/DDR0_DQ[26])
M_B_D11: CON2100.20(DQ2) U0400.AH68(DDR1_DQ[11]/DDR0_DQ[27])
M_B_D12: CON2100.4(DQ4) U0400.AF71(DDR1_DQ[12]/DDR0_DQ[28])
M_B_D13: CON2100.7(DQ1) U0400.AF69(DDR1_DQ[13]/DDR0_DQ[29])
M_B_D14: CON2100.21(DQ3) U0400.AH70(DDR1_DQ[14]/DDR0_DQ[30])
M_B_D15: CON2100.16(DQ6) U0400.AH69(DDR1_DQ[15]/DDR0_DQ[31])
M_B_D16: CON2100.59(DQ23) U0400.AT66(DDR1_DQ[16]/DDR0_DQ[48])
M_B_D17: CON2100.63(DQ19) U0400.AU66(DDR1_DQ[17]/DDR0_DQ[49])
M_B_D18: CON2100.46(DQ20) U0400.AP65(DDR1_DQ[18]/DDR0_DQ[50])
M_B_D19: CON2100.45(DQ21) U0400.AN65(DDR1_DQ[19]/DDR0_DQ[51])
M_B_D20: CON2100.49(DQ17) U0400.AN66(DDR1_DQ[20]/DDR0_DQ[52])
M_B_D21: CON2100.50(DQ16) U0400.AP66(DDR1_DQ[21]/DDR0_DQ[53])
M_B_D22: CON2100.62(DQ18) U0400.AT65(DDR1_DQ[22]/DDR0_DQ[54])
M_B_D23: CON2100.58(DQ22) U0400.AU65(DDR1_DQ[23]/DDR0_DQ[55])
M_B_D24: CON2100.70(DQ24) U0400.AT61(DDR1_DQ[24]/DDR0_DQ[56])
M_B_D25: CON2100.66(DQ28) U0400.AU61(DDR1_DQ[25]/DDR0_DQ[57])
M_B_D26: CON2100.84(DQ27) U0400.AP60(DDR1_DQ[26]/DDR0_DQ[58])
M_B_D27: CON2100.80(DQ31) U0400.AN60(DDR1_DQ[27]/DDR0_DQ[59])
M_B_D28: CON2100.67(DQ29) U0400.AN61(DDR1_DQ[28]/DDR0_DQ[60])
M_B_D29: CON2100.71(DQ25) U0400.AP61(DDR1_DQ[29]/DDR0_DQ[61])
M_B_D30: CON2100.83(DQ26) U0400.AT60(DDR1_DQ[30]/DDR0_DQ[62])
M_B_D31: CON2100.79(DQ30) U0400.AU60(DDR1_DQ[31]/DDR0_DQ[63])
M_B_D32: CON2100.169(DQ37) U0400.AU40(DDR1_DQ[32]/DDR1_DQ[16])
M_B_D33: CON2100.173(DQ33) U0400.AT40(DDR1_DQ[33]/DDR1_DQ[17])
M_B_D34: CON2100.182(DQ39) U0400.AT37(DDR1_DQ[34]/DDR1_DQ[18])
M_B_D35: CON2100.183(DQ38) U0400.AU37(DDR1_DQ[35]/DDR1_DQ[19])
M_B_D36: CON2100.170(DQ36) U0400.AR40(DDR1_DQ[36]/DDR1_DQ[20])
M_B_D37: CON2100.174(DQ32) U0400.AP40(DDR1_DQ[37]/DDR1_DQ[21])
M_B_D38: CON2100.186(DQ35) U0400.AP37(DDR1_DQ[38]/DDR1_DQ[22])
M_B_D39: CON2100.187(DQ34) U0400.AR37(DDR1_DQ[39]/DDR1_DQ[23])
M_B_D40: CON2100.195(DQ40) U0400.AT33(DDR1_DQ[40]/DDR1_DQ[24])
M_B_D41: CON2100.191(DQ44) U0400.AU33(DDR1_DQ[41]/DDR1_DQ[25])
M_B_D42: CON2100.207(DQ42) U0400.AU30(DDR1_DQ[42]/DDR1_DQ[26])
M_B_D43: CON2100.203(DQ46) U0400.AT30(DDR1_DQ[43]/DDR1_DQ[27])
M_B_D44: CON2100.194(DQ41) U0400.AR33(DDR1_DQ[44]/DDR1_DQ[28])
M_B_D45: CON2100.190(DQ45) U0400.AP33(DDR1_DQ[45]/DDR1_DQ[29])
M_B_D46: CON2100.204(DQ47) U0400.AR30(DDR1_DQ[46]/DDR1_DQ[30])
M_B_D47: CON2100.208(DQ43) U0400.AP30(DDR1_DQ[47]/DDR1_DQ[31])
M_B_D48: CON2100.216(DQ48) U0400.AU27(DDR1_DQ[48])
M_B_D49: CON2100.212(DQ53) U0400.AT27(DDR1_DQ[49])
M_B_D50: CON2100.225(DQ55) U0400.AT25(DDR1_DQ[50])
M_B_D51: CON2100.229(DQ51) U0400.AU25(DDR1_DQ[51])
M_B_D52: CON2100.211(DQ52) U0400.AP27(DDR1_DQ[52])
M_B_D53: CON2100.215(DQ49) U0400.AN27(DDR1_DQ[53])
M_B_D54: CON2100.228(DQ50) U0400.AN25(DDR1_DQ[54])
M_B_D55: CON2100.224(DQ54) U0400.AP25(DDR1_DQ[55])
M_B_D56: CON2100.232(DQ60) U0400.AT22(DDR1_DQ[56])
M_B_D57: CON2100.236(DQ57) U0400.AU22(DDR1_DQ[57])
M_B_D58: CON2100.249(DQ58) U0400.AU21(DDR1_DQ[58])
M_B_D59: CON2100.245(DQ62) U0400.AT21(DDR1_DQ[59])
M_B_D60: CON2100.237(DQ56) U0400.AN22(DDR1_DQ[60])
M_B_D61: CON2100.233(DQ61) U0400.AP22(DDR1_DQ[61])
M_B_D62: CON2100.246(DQ63) U0400.AP21(DDR1_DQ[62])
M_B_D63: CON2100.250(DQ59) U0400.AN21(DDR1_DQ[63])
M_B_DIM0_CKE0: CON2100.109(CKE0) U0400.AN56(DDR1_CKE[0])
M_B_DIM0_CKE1: CON2100.110(CKE1) U0400.AP55(DDR1_CKE[1])
M_B_DIM0_CLK0: CON2100.137(CK0_T) U0400.AP45(DDR1_CKP[0])
M_B_DIM0_CLK1: CON2100.138(CK1_T/NF) U0400.AP46(DDR1_CKP[1])
M_B_DIM0_CLK#0: CON2100.139(CK0_C) U0400.AN45(DDR1_CKN[0])
M_B_DIM0_CLK#1: CON2100.140(CK1_C/NF) U0400.AN46(DDR1_CKN[1])
M_B_DIM0_CS#0: CON2100.149(CS0_N) U0400.BB42(DDR1_CS#[0])
M_B_DIM0_CS#1: CON2100.157(CS1_N) U0400.AY42(DDR1_CS#[1])
M_B_DIM0_ODT0: CON2100.155(ODT0) U0400.BA42(DDR1_ODT[0])
M_B_DIM0_ODT1: CON2100.161(ODT1) U0400.AW42(DDR1_ODT[1])
M_B_DQS0: CON2100.34(DQS1_T) U0400.AH65(DDR1_DQSP[0]/DDR0_DQSP[2])
M_B_DQS1: CON2100.13(DQS0_T) U0400.AG70(DDR1_DQSP[1]/DDR0_DQSP[3])
M_B_DQS2: CON2100.55(DQS2_T) U0400.AR65(DDR1_DQSP[2]/DDR0_DQSP[6])
M_B_DQS3: CON2100.76(DQS3_T) U0400.AR60(DDR1_DQSP[3]/DDR0_DQSP[7])
M_B_DQS4: CON2100.179(DQS4_T) U0400.AR38(DDR1_DQSP[4]/DDR1_DQSP[2])
M_B_DQS5: CON2100.200(DQS5_T) U0400.AR32(DDR1_DQSP[5]/DDR1_DQSP[3])
M_B_DQS6: CON2100.221(DQS6_T) U0400.AR27(DDR1_DQSP[6])
M_B_DQS7: CON2100.242(DQS7_T) U0400.AR21(DDR1_DQSP[7])
M_B_DQS#0: CON2100.32(DQS1_C) U0400.AH66(DDR1_DQSN[0]/DDR0_DQSN[2])
M_B_DQS#1: CON2100.11(DQS0_C) U0400.AG69(DDR1_DQSN[1]/DDR0_DQSN[3])
M_B_DQS#2: CON2100.53(DQS2_C) U0400.AR66(DDR1_DQSN[2]/DDR0_DQSN[6])
M_B_DQS#3: CON2100.74(DQS3_C) U0400.AR61(DDR1_DQSN[3]/DDR0_DQSN[7])
M_B_DQS#4: CON2100.177(DQS4_C) U0400.AT38(DDR1_DQSN[4]/DDR1_DQSN[2])
M_B_DQS#5: CON2100.198(DQS5_C) U0400.AT32(DDR1_DQSN[5]/DDR1_DQSN[3])
M_B_DQS#6: CON2100.219(DQS6_C) U0400.AR25(DDR1_DQSN[6])
M_B_DQS#7: CON2100.240(DQS7_C) U0400.AR22(DDR1_DQSN[7])
M_CH_DRAM_RESET#: R2000.2 R2001.1 U0400.AT13(DRAM_RESET#)
M_CH_DRAM_RESET#_R: C2002.1 C2011.1 C2102.1 CON2000.108(RESET_N) CON2100.108(RESET_N) R2001.2
M_CHA_VREF_CA: C2007.1 C2008.1 R2004.1 U0400.AY67(DDR_VREF_CA)
M_CHA_VREF_CA_D: C2009.1 C2010.1 CON2000.164(VREFCA) R2003.2 R2004.2 R2005.1
M_CHB_VREF_CA: C2108.1 C2109.1 R2102.1 U0400.BA67(DDR1_VREF_DQ)
M_CHB_VREF_CA_D: C2110.1 C2111.1 CON2100.164(VREFCA) R2101.2 R2102.2 R2103.1
MAA0_0: U6000.K17(MAA0_0) U6800.H4(A10/A0/A8/A7) U6801.K4(A8/A7/A10/A0)
MAA0_1: U6000.J20(MAA0_1) U6800.H5(A9/A1/A11/A6) U6801.K5(A11/A6/A9/A1)
MAA0_2: U6000.H23(MAA0_2) U6800.H11(BA0/A2/BA2/A4) U6801.K11(BA2/A4/BA0/A2)
MAA0_3: U6000.G23(MAA0_3) U6800.H10(BA3/A3/BA1/A5) U6801.K10(BA1/A5/BA3/A3)
MAA0_4: U6000.G24(MAA0_4) U6800.K11(BA2/A4/BA0/A2) U6801.H11(BA0/A2/BA2/A4)
MAA0_5: U6000.H24(MAA0_5) U6800.K10(BA1/A5/BA3/A3) U6801.H10(BA3/A3/BA1/A5)
MAA0_6: U6000.J19(MAA0_6) U6800.K5(A11/A6/A9/A1) U6801.H5(A9/A1/A11/A6)
MAA0_7: U6000.K19(MAA0_7) U6800.K4(A8/A7/A10/A0) U6801.H4(A10/A0/A8/A7)
MAA0_8: U6000.G20(MAA0_8) U6800.J5(A12/A13) U6801.J5(A12/A13)
MAA1_0: U6000.J14(MAA1_0) U6802.K4(A8/A7/A10/A0) U6803.H4(A10/A0/A8/A7)
MAA1_1: U6000.K14(MAA1_1) U6802.K5(A11/A6/A9/A1) U6803.H5(A9/A1/A11/A6)
MAA1_2: U6000.J11(MAA1_2) U6802.K11(BA2/A4/BA0/A2) U6803.H11(BA0/A2/BA2/A4)
MAA1_3: U6000.J13(MAA1_3) U6802.K10(BA1/A5/BA3/A3) U6803.H10(BA3/A3/BA1/A5)
MAA1_4: U6000.H11(MAA1_4) U6802.H11(BA0/A2/BA2/A4) U6803.K11(BA2/A4/BA0/A2)
MAA1_5: U6000.G11(MAA1_5) U6802.H10(BA3/A3/BA1/A5) U6803.K10(BA1/A5/BA3/A3)
MAA1_6: U6000.J16(MAA1_6) U6802.H5(A9/A1/A11/A6) U6803.K5(A11/A6/A9/A1)
MAA1_7: U6000.L15(MAA1_7) U6802.H4(A10/A0/A8/A7) U6803.K4(A8/A7/A10/A0)
MAA1_8: U6000.G14(MAA1_8) U6802.J5(A12/A13) U6803.J5(A12/A13)
MASK_SATA_LED#: R2341.2 R5002.1 U2300.56(GPIO064/LRESET#)
MDA0_0: U6000.K27(DQA0_0) U6801.T11(DQ18/DQ10)
MDA0_1: U6000.J29(DQA0_1) U6801.U11(DQ16/DQ8)
MDA0_2: U6000.H30(DQA0_2) U6801.T13(DQ19/DQ11)
MDA0_3: U6000.H32(DQA0_3) U6801.U13(DQ17/DQ9)
MDA0_4: U6000.G29(DQA0_4) U6801.N11(DQ20/DQ12)
MDA0_5: U6000.F28(DQA0_5) U6801.M13(DQ23/DQ15)
MDA0_6: U6000.F32(DQA0_6) U6801.M11(DQ22/DQ14)
MDA0_7: U6000.F30(DQA0_7) U6801.N13(DQ21/DQ13)
MDA0_8: U6000.C30(DQA0_8) U6800.A2(DQ1/DQ25)
MDA0_9: U6000.F27(DQA0_9) U6800.B2(DQ3/DQ27)
MDA0_10: U6000.A28(DQA0_10) U6800.B4(DQ2/DQ26)
MDA0_11: U6000.C28(DQA0_11) U6800.A4(DQ0/DQ24)
MDA0_12: U6000.E27(DQA0_12) U6800.E4(DQ4/DQ28)
MDA0_13: U6000.G26(DQA0_13) U6800.E2(DQ5/DQ29)
MDA0_14: U6000.D26(DQA0_14) U6800.F2(DQ7/DQ31)
MDA0_15: U6000.F25(DQA0_15) U6800.F4(DQ6/DQ30)
MDA0_16: U6000.A25(DQA0_16) U6800.M11(DQ22/DQ14)
MDA0_17: U6000.C25(DQA0_17) U6800.M13(DQ23/DQ15)
MDA0_18: U6000.E25(DQA0_18) U6800.N13(DQ21/DQ13)
MDA0_19: U6000.D24(DQA0_19) U6800.N11(DQ20/DQ12)
MDA0_20: U6000.E23(DQA0_20) U6800.T13(DQ19/DQ11)
MDA0_21: U6000.F23(DQA0_21) U6800.U13(DQ17/DQ9)
MDA0_22: U6000.D22(DQA0_22) U6800.U11(DQ16/DQ8)
MDA0_23: U6000.F21(DQA0_23) U6800.T11(DQ18/DQ10)
MDA0_24: U6000.E21(DQA0_24) U6801.F2(DQ7/DQ31)
MDA0_25: U6000.D20(DQA0_25) U6801.E4(DQ4/DQ28)
MDA0_26: U6000.F19(DQA0_26) U6801.E2(DQ5/DQ29)
MDA0_27: U6000.A19(DQA0_27) U6801.F4(DQ6/DQ30)
MDA0_28: U6000.D18(DQA0_28) U6801.B4(DQ2/DQ26)
MDA0_29: U6000.F17(DQA0_29) U6801.A4(DQ0/DQ24)
MDA0_30: U6000.A17(DQA0_30) U6801.B2(DQ3/DQ27)
MDA0_31: U6000.C17(DQA0_31) U6801.A2(DQ1/DQ25)
MDA1_0: U6000.E17(DQA1_0) U6803.A2(DQ1/DQ25)
MDA1_1: U6000.D16(DQA1_1) U6803.B2(DQ3/DQ27)
MDA1_2: U6000.F15(DQA1_2) U6803.B4(DQ2/DQ26)
MDA1_3: U6000.A15(DQA1_3) U6803.A4(DQ0/DQ24)
MDA1_4: U6000.D14(DQA1_4) U6803.F4(DQ6/DQ30)
MDA1_5: U6000.F13(DQA1_5) U6803.E2(DQ5/DQ29)
MDA1_6: U6000.A13(DQA1_6) U6803.E4(DQ4/DQ28)
MDA1_7: U6000.C13(DQA1_7) U6803.F2(DQ7/DQ31)
MDA1_8: U6000.E11(DQA1_8) U6802.U11(DQ16/DQ8)
MDA1_9: U6000.A11(DQA1_9) U6802.T11(DQ18/DQ10)
MDA1_10: U6000.C11(DQA1_10) U6802.U13(DQ17/DQ9)
MDA1_11: U6000.F11(DQA1_11) U6802.T13(DQ19/DQ11)
MDA1_12: U6000.A9(DQA1_12) U6802.N13(DQ21/DQ13)
MDA1_13: U6000.C9(DQA1_13) U6802.M11(DQ22/DQ14)
MDA1_14: U6000.F9(DQA1_14) U6802.N11(DQ20/DQ12)
MDA1_15: U6000.D8(DQA1_15) U6802.M13(DQ23/DQ15)
MDA1_16: U6000.E7(DQA1_16) U6802.E2(DQ5/DQ29)
MDA1_17: U6000.A7(DQA1_17) U6802.F2(DQ7/DQ31)
MDA1_18: U6000.C7(DQA1_18) U6802.E4(DQ4/DQ28)
MDA1_19: U6000.F7(DQA1_19) U6802.F4(DQ6/DQ30)
MDA1_20: U6000.A5(DQA1_20) U6802.B4(DQ2/DQ26)
MDA1_21: U6000.E5(DQA1_21) U6802.B2(DQ3/DQ27)
MDA1_22: U6000.C3(DQA1_22) U6802.A2(DQ1/DQ25)
MDA1_23: U6000.E1(DQA1_23) U6802.A4(DQ0/DQ24)
MDA1_24: U6000.G7(DQA1_24) U6803.M11(DQ22/DQ14)
MDA1_25: U6000.G6(DQA1_25) U6803.N11(DQ20/DQ12)
MDA1_26: U6000.G1(DQA1_26) U6803.M13(DQ23/DQ15)
MDA1_27: U6000.G3(DQA1_27) U6803.N13(DQ21/DQ13)
MDA1_28: U6000.J6(DQA1_28) U6803.T11(DQ18/DQ10)
MDA1_29: U6000.J1(DQA1_29) U6803.U13(DQ17/DQ9)
MDA1_30: U6000.J3(DQA1_30) U6803.T13(DQ19/DQ11)
MDA1_31: U6000.J5(DQA1_31) U6803.U11(DQ16/DQ8)
ME_FWP: R1012.1 U2300.80(GPIO116/TFDP_DATA/UART_RX)
ME_SUS_PWR_ACK: R1208.2 R1229.2 U0400.AR13(GPP_A13/SUSWARN#/SUSPWRDNACK)
MEC_XTAL1_R: C2319.1 U2300.123(XTAL1) X2300.2
MEC_XTAL2: C2312.2 R2329.1 R2330.2 U2300.125(XTAL2)
MEC_XTAL2_R: C2318.1 R2330.1 X2300.1
MEM_SMBCLK: Q1902.6(DRAIN) R1100.2 U0400.R7(GPP_C0/SMBCLK)
MEM_SMBCLK_D: C2005.1 C2106.1 CON2000.253(SCL) CON2100.253(SCL) Q1902.1(SOURCE) R1907.2 R1919.2
MEM_SMBDATA: Q1902.3(DRAIN) R1101.2 U0400.R8(GPP_C1/SMBDATA)
MEM_SMBDATA_D: C2006.1 C2107.1 CON2000.254(SDA) CON2100.254(SDA) Q1902.4(SOURCE) R1908.2 R1921.2
MIC2_CAP: C3815.1 U3800.32(MIC2_CAP)
MIC2_L: C3813.1 D3803.2(CATHODE) J3800.4 L3803.2
MIC2_R: C3811.1 D3801.2(CATHODE) J3800.1 L3802.2
MIC2_VREFO_L: R3801.1 U3800.28(MIC2_VREFO_L)
MIC2_VREFO_R: R3800.1 U3800.29(MIC2_VREFO_R)
MISO_TPM: R3910.1 U3901.24(LAD0/MISO)
MODEL_ID: C2313.1 R2312.1 R2313.1 R2351.1 U2300.109(GPIO153/ADC4)
MOSI_TPM: R3909.1 U3901.21(LAD1/MOSI)
MQ1500_G: Q2600.1(GATE) Q2601.3(DRAIN) R2601.2
MSM#: T0902.1 U0400.AP56(MSM#)
MVREFDA: C6302.1 R6306.2 R6307.1 U6000.K26(MVREFDA)
MVREFSA: C6301.1 R6304.2 R6305.1 U6000.J26(MVREFSA)
NB_MUTE#: R2302.1 U2300.119(BGPO/GPIO004)
NRB_BIT: R1500.2 U0400.AR7(GPP_B18/GSPI0_MOSI)
NTC_A_VCPU: PR7826.1 PU7800.15(NTC_A)
NTC_A_VCPU_R: PR7826.2 PR7829.1
NTC_B_VCPU: PR7828.2 PU7800.3(NTC_B)
OPC_RCOMP: R0407.2 U0400.H65(OPC_RCOMP)
OPCE_RCOMP: R0406.2 U0400.H66(OPCE_RCOMP)
OUT1_DP_AUXN_C: C5718.2 R5711.2 R5725.2 U5703.25(AUXN)
OUT1_DP_AUXP_C: C5717.2 R5710.1 U5703.24(AUXP)
OUT1_DP_D0N_C: C5710.2 U5703.10(DP0N)
OUT1_DP_D0P_C: C5709.2 U5703.9(DP0P)
OUT1_DP_D1N_C: C5712.2 U5703.13(DP1N)
OUT1_DP_D1P_C: C5711.2 U5703.12(DP1P)
OUT1_DP_D2N_C: C5714.2 U5703.16(DP2N)
OUT1_DP_D2P_C: C5713.2 U5703.15(DP2P)
OUT1_DP_D3N_C: C5716.2 U5703.19(DP3N)
OUT1_DP_D3P_C: C5715.2 U5703.18(DP3P)
PANEL_BKEN_EC: R3001.1 U2300.117(GPIO023/ADC6/A20M)
PANEL_BKEN_EC_R: CON3000.13 R3001.2
PBAT_PRES#: C3604.1 D3603.1(ANODE) PR7726.1 R3607.1 R3608.2 U2300.29(GPIO134/SHD_IO1)
PBAT_SMBCLK: CON3601.4 D3601.1(ANODE) R2317.1
PBAT_SMBDAT: CON3601.5 D3602.1(ANODE) R2316.1
PC_BEEP: D3805.3(CATHODE) R3823.2
PCBEEP: C3834.2 U3800.34(PCBEEP)
PCBEEP_R: C3834.1 C3843.1 R3822.1 R3823.1
PCH_BATLOW#: R1204.2 T1204.1 U0400.AU13(GPD0/BATLOW#)
PCH_DPWROK_R: R1216.2 T1200.1 U0400.BB20(DSW_PWROK)
PCH_ESPI_CLK: R1108.1 U0400.AW9(GPP_A9/CLKOUT_LPC0/ESPI_CLK)
PCH_ESPI_CS#: C1105.1 R1115.1 U0400.BA12(GPP_A5/LFRAME#/ESPI_CS#)
PCH_ESPI_IO0: R1110.1 U0400.AY13(GPP_A1/LAD0/ESPI_IO0)
PCH_ESPI_IO1: R1111.1 U0400.BA13(GPP_A2/LAD1/ESPI_IO1)
PCH_ESPI_IO2: R1112.1 U0400.BB13(GPP_A3/LAD2/ESPI_IO2)
PCH_ESPI_IO3: R1113.1 U0400.AY12(GPP_A4/LAD3/ESPI_IO3)
PCH_JTAG_TCK: T0404.1 U0400.B56(PCH_JTAG_TCK)
PCH_JTAG_TDI: R0401.1 T0400.1 U0400.D59(PCH_JTAG_TDI) U0400.D60(PROC_TDI)
PCH_JTAG_TDO: R0403.1 T0401.1 U0400.A56(PCH_JTAG_TDO) U0400.A61(PROC_TDO)
