# Allegro board 5n-armani13.a00.0828.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ACAV_IN_ERP: length 10.1
  TOP w0.102: 17.91,52.3 R2405.1 18.47,52.3 18.67,52.5 18.67,53.71 18.73,53.77 18.73,53.8 18.88,53.95 19.58,53.95 19.71,53.82 Q2400.2 ; 17.91,52.3 17.91,51.87 17.93,51.84 R2402.1 ; 17.91,52.3 17.17,52.3 16.84,52.63 16.84,53.83 17.09,54.08 R2404.2 15.67,54.97 v2(15.49,54.79)
ACAV_IN_R: length 37.7
  TOP w0.102: D2400.2 15.98,52.53 17.15,51.37 17.15,50.8 17.45,50.5 R2402.2 17.93,50.14 17.91,50.12 R2401.1 18.34,49.61 18.94,49.01 19.11,49.01 19.66,48.47 20.7,48.47 21.01,48.77 24,48.77 24.87,49.63 25.98,49.63 26.78,50.43 30.02,50.43 30.71,51.12 32.29,51.12 32.5,50.9 33.93,50.9 34.41,51.39 35.22,51.39 v1(35.96,52.12) ; R2307.2 45.06,48.62 44.58,49.1 40.71,49.1 v1(40.48,49.32)
  IN2 w0.102: v1(35.96,52.12) 37.38,50.7 39.83,50.7 40.48,50.04 v1(40.48,49.32)
  BOTTOM w0.102: v1(35.96,52.12) 36.52,51.56 v2(36.65,51.56)
AD_OFF_R: length 16.5
  TOP w0.254: PQ7607.4 55.17,109.76 55.37,109.55 PC7602.2 PR7625.2 56.4,110.06 56.39,110.07 PR7626.1 56.9,110.42 v1(57.02,110.54) ; PR7643.1 66.47,109.91 v1(66.95,110.39)
  IN1 w0.254: v1(66.95,110.39) 65.91,109.35 57.53,109.35 57.02,109.86 v1(57.02,110.54)
ADAP_ID_VOL_G: length 7.5
  BOTTOM w0.102: PQ7602.1 16.15,55.1 14.88,56.37 v2(14.88,56.62) 14.88,57.1 15.37,57.58 16.57,57.58 16.64,57.66 PR7608.2 16.64,58.68 16.76,58.8 17.27,58.8 17.4,58.68 PR7610.1
ADBIA0: length 38.8
  TOP w0.127: v1(195.78,98.17) 195.76,98.17 U6801.J4
  IN1 w0.122: v1(195.78,98.17) 195.78,96.38 195.37,95.96 195.37,95.11 195.37,95.11 195.37,94.77 195.37,94.76 195.37,94.61 194.5,93.74 194.5,91.37 193.76,90.63 188.25,90.63 187.88,90.99 178.54,90.99 177.27,89.72 176.15,89.72 175.94,89.5 174.84,89.5 174.6,89.26 173.73,89.26 173.61,89.38 173.61,89.95 173.48,90.07 173.24,90.07 173.12,89.95 173.12,89.38 173,89.26 172.75,89.26 172.5,89.51 168.28,89.51 167.87,89.91 v1(167.87,89.99)
  BOTTOM w0.102: U6000.L18 167.64,90.22 v1(167.87,89.99)
  BOTTOM w0.127: U6801.J4 195.76,98.17 v1(195.78,98.17)
ADBIA1: length 45.4
  TOP w0.127: U6803.J4 189.98,79.39 190.3,79.39 190.43,79.26 190.71,79.26 190.84,79.39 v1(191.42,79.39)
  IN3 w0.102: v1(168.61,87.63) 168.15,87.18 167.56,87.18 167.06,86.67 167.06,83.34
  IN3 w0.122: 167.06,83.34 167.06,82.12 167.18,81.99 167.18,78.51 167.54,78.16 167.99,78.16 168.11,78.28 168.11,78.63 168.23,78.75 168.48,78.75 168.6,78.63 168.6,78.2 168.72,78.08 168.97,78.08 169.09,78.2 169.09,78.63 169.21,78.75 169.45,78.75 169.58,78.63 169.58,78.2 169.7,78.08 169.94,78.08 170.06,78.2 170.06,78.63 170.19,78.75 170.43,78.75 170.55,78.63 170.55,78.2 170.67,78.08 171.1,78.08 171.22,78.2 171.22,78.62 171.35,78.74 171.58,78.74 171.71,78.62 171.71,78.2 171.83,78.08 172.11,78.08 172.24,78.21 172.24,78.6 172.36,78.73 173.77,78.73 174.37,79.33 174.98,79.33 176.19,78.13 180.7,78.13 181.24,77.59 184.57,77.59 185.38,78.4 189.66,78.4 190.65,79.39 v1(191.42,79.39)
  BOTTOM w0.102: U6000.K16 168.31,87.94 168.31,87.93 v1(168.61,87.63)
  BOTTOM w0.127: U6803.J4 189.98,79.39 190.3,79.39 190.43,79.26 190.71,79.26 190.84,79.39 v1(191.42,79.39)
ALL_SUS_PWRGD: length 20.7
  TOP w0.102: R1221.1 61.7,11.84 62.29,11.25 v2(62.76,11.25) 64.11,11.25 64.67,11.81 65.33,11.81 65.76,12.25 R1218.1 66.22,12.91 66.5,13.19 v1(66.5,13.62)
  IN3 w0.102: v1(72.45,14) 71.63,13.19 69.88,13.19 69.44,13.62 v1(66.5,13.62)
  BOTTOM w0.102: U1201.4 74.91,18.53 74.79,18.41 74.79,17.44 73.74,16.39 73.74,15.09 73.32,14.67 U1202.1 73.05,14.18 72.87,14 v1(72.45,14)
ALL_SYS_PWRGD: length 142
  TOP w0.102: v2(77.72,20.02) 77.88,19.87 v1(77.88,18.95) ; v1(105.56,22.1) 105.56,22.36 104.83,23.09 104.83,26.31 104.14,26.99 102.81,26.99 v1(102.18,26.37)
  IN2 w0.102: v1(169.44,51.62) 169.01,51.18 167.01,51.18 164.39,53.8 160.53,53.8 159.33,52.61 155.37,52.61 153.47,50.71 153.47,44.83 157.58,40.72 157.58,38.46 156.23,37.11 153.45,37.11 149.62,33.28 141.58,33.28 137.9,29.59 135.76,29.59 134.93,28.76 133.66,28.76 133.12,29.29 131.65,29.29 131.32,29.62 130.84,29.62 129.44,28.22 128.21,28.22 122.7,22.71 119.64,22.71 118.12,21.19 118.12,20.34 117.29,19.51 115.47,19.51 114.55,20.42 113.23,20.42 112.07,21.59 110.57,21.59 110.21,21.24 106.43,21.24 v1(105.56,22.1) 104.45,20.98 97.69,20.98 97.08,20.37 91.17,20.37 90.51,19.71 86.6,19.71 84.95,21.36 82.96,21.36 81.96,20.37 79.78,20.37 78.94,19.54 78,19.54 77.88,19.41 v1(77.88,18.95)
  BOTTOM w0.102: v1(77.88,18.95) 77.58,18.66 U1800.4 ; U1203.2 100.86,25.05 100.74,25.17 100.74,25.94 100.91,26.11 101.93,26.11 v1(102.18,26.37) 102.51,26.7 102.51,27.15 102.26,27.4 102.26,28.3 102.39,28.43 R1223.1 ; PR7837.2 169.6,51.46 v1(169.44,51.62)
ALL_SYS_PWRGD_R: length 23.2
  IN3 w0.102: v1(92.2,19.06) 92.2,20.38 92.42,20.6 93.52,20.6 94.84,21.92 95.5,21.92 96.81,23.23 101.24,23.23 101.51,23.5 101.51,25.53 101.94,25.96 102.39,25.96 v1(102.79,26.37)
  BOTTOM w0.102: v1(102.79,26.37) 102.84,26.42 R1223.2 ; U1204.2 95.23,14.46 94.51,15.18 94.51,16.42 v2(94.24,16.7) 92.81,18.13 92.81,18.45 92.74,18.52 92.74,18.54 92.42,18.85 92.41,18.85 v1(92.2,19.06)
ALL_SYS_PWRGD_VR: length 3.1
  BOTTOM w0.102: PU7800.40 172.16,50.85 171.55,51.46 PR7837.1 170.94,51.51 171.53,52.1 v2(171.53,52.43)
ALWON: length 221.9
  TOP w0.102: v1(149.99,30.23) 149.99,29.4 145.77,25.19 145.77,21.06 146.61,20.22 146.61,18.29 148.31,16.59 148.31,13.87 144.73,10.29 v1(144.73,9.98) ; U2300.121 41.04,39.5 40.17,38.62 38.73,38.62 38.38,38.27 38.38,34.51 37.83,33.96 36.89,33.96 36.37,34.47 33.08,34.47 28.17,29.57 27.08,29.57 26.49,28.98 26.49,27.87 25.58,26.95 25.58,26.47 25.22,26.11 25.22,25.82 25.06,25.66 v2(25.06,25.22) 25.06,24.91 v1(24.59,24.44) 24.69,24.34 R2411.1
  IN1 w0.102: v1(161.9,36.5) 156.72,31.32 151.08,31.32 v1(149.99,30.23)
  IN3 w0.102: v1(161.9,36.5) 161.93,36.48 164.24,36.48 165.71,37.95 168.66,37.95 171.4,40.69 171.4,41.07 172.57,42.24 v1(172.64,42.24) ; v1(24.59,24.44) 24.23,24.08 24.23,20.5 25.59,19.14 30.51,19.14 37.9,11.75 37.9,8.47 42.96,3.41 100.36,3.41 102.72,5.77 102.72,7.39 105.68,10.36 107.57,10.36 108.24,11.03 109.58,11.03 110.21,10.39 118.13,10.39 118.96,9.55 144.3,9.55 v1(144.73,9.98)
  BOTTOM w0.102: PR8701.1 174.15,42.11 174.02,42.24 v1(172.64,42.24)
AMBER_LED_ON#_R: length 16.5
  TOP w0.102: R5001.2 16,92.99 16.36,93.35 19.71,93.35 v2(20.96,92.1) 21.11,91.95 21.11,86.9 20.12,85.91 v1(19.89,85.91)
  BOTTOM w0.102: v1(19.89,85.91) 19.66,85.91 19.49,86.07 Q5000.3
AMD_CLKTESTA: length 5.3
  TOP w0.102: v1(168.45,81.62) 168.45,81.56 T6301.1 169.52,80.5 169.52,79.02 168.99,78.49 C6304.1
  BOTTOM w0.102: v1(168.45,81.62) 168.42,81.62 U6000.K8
AMD_CLKTESTB: length 6
  TOP w0.102: v1(166.32,80.94) 166.32,80.55 167.16,79.71 C6303.1 166.71,79.47 166.5,79.25 166.09,79.25 165.2,78.36 165.2,78.03 T6300.1
  BOTTOM w0.102: U6000.L7 166.75,80.94 v1(166.32,80.94)
AU1_CBN: length 2.6
  TOP w0.432: v1(13.72,25.72) 13.72,25.23 C3818.1
  BOTTOM w0.229: U3800.24 14.84,26.28 14.72,26.15 14.15,26.15 v1(13.72,25.72)
AU1_CBP: length 2.3
  TOP w0.432: v1(14.44,25.68) 14.44,24.99 C3818.2
  BOTTOM w0.229: U3800.23 15.24,26.06 14.99,25.81 14.58,25.81 v1(14.44,25.68)
AU1_CPVEE: length 2.1
  TOP w0.508: C3821.2 13.16,26.44 v1(13.74,26.44)
  BOTTOM w0.229: U3800.25 14.01,27.04 13.74,26.77 v1(13.74,26.44)
AU1_HPOUT1_JD#: length 12.4
  BOTTOM w0.152: U3800.48 19.24,32.25 19.43,32.44 20.09,32.44 20.24,32.59 20.24,33.28 20.69,33.73 20.86,33.73 C3840.1 R3809.2 21.03,35.52 21.03,36.25 19.94,37.34 19.4,37.34 18.76,37.99 18.76,38.55 18.15,39.15 v2(17.75,39.15) 17.15,39.15 16.47,38.47 R3810.2
AU1_HPOUT2_JD#: length 3.2
  BOTTOM w0.102: U3800.47 18.84,32.42 19.24,32.82 19.56,32.82 v2(19.79,33.05) 19.79,33.37 20.39,33.97 R3824.2
AU1_LD1_CAP: length 3.8
  TOP w0.254: R3814.2 C3824.1 14.86,33.35 v1(15.04,33.17) 15.47,33.61 v2(15.47,33.81)
  BOTTOM w0.229: U3800.39 15.64,32.48 15.04,33.08 v1(15.04,33.17)
AU1_LD2_CAP: length 1.8
  TOP w0.432: v1(15.93,25.45) 16,25.53 C3823.2
  BOTTOM w0.229: v1(15.93,25.45) 16.04,25.57 U3800.21
AU1_LD3_CAP: length 4.3
  TOP w0.254: v2(17.2,22.91) 17.2,23.32 17.88,24.01 C3817.2 17.37,25.22 v1(17.27,25.22)
  BOTTOM w0.254: v1(17.27,25.22) 16.84,25.65 U3800.19
AU1_VREF: length 1.7
  BOTTOM w0.229: 14.86,32.64 15.01,32.64 15.24,32.41 U3800.38
  BOTTOM w0.254: 14.86,32.64 14.46,33.04 C3822.1
AUX: length 10.3
  TOP w0.432: R3827.2 15.11,36.84 R3804.2 14.55,35.89
  TOP w0.508: 14.55,35.89 13.71,35.89 v2(13.59,35.77) 12.98,35.16 v1(12.98,34.95)
  BOTTOM w0.229: U3800.33 13.69,30.24 13.27,30.66 12.57,30.66 12.34,30.89
  BOTTOM w0.508: v1(12.98,34.95) 12.09,34.06 12.09,31.14 12.34,30.89
AUX_EN_WOWL: length 23.7
  TOP w0.102: v1(89.8,29.38) 89.8,28.46 T1205.1
  BOTTOM w0.076: U0400.BB17 104.57,42.34 103.62,42.34 103.34,42.07 102.77,42.07
  BOTTOM w0.102: 102.77,42.07 101.53,42.07 100.08,40.62 98.32,40.62 97.46,39.75 95.99,39.75 89.8,33.56 v1(89.8,29.38)
AUX_ON: length 273.3
  TOP w0.102: U2300.3 40.1,41.7 v1(39.55,41.15) ; v1(206.17,19.18) 206.17,18.29 200.89,13.01 190.07,13.01 188.19,11.13 182.11,11.13 181.47,11.76 176.77,11.76 176.06,12.47 172.51,12.47 171.74,11.71 165.07,11.71 164.41,12.37 161.82,12.37 161.04,13.16 158.73,13.16 158.12,12.54 158.12,11.43 157.84,11.15 154.41,11.15 v1(153.34,10.09)
  IN1 w0.102: v1(28.25,31.19) 28.7,30.73 28.7,28.11 31.24,25.57 31.29,25.57 32.88,23.98 32.88,15.89 v1(37.44,11.33) ; v1(153.34,10.09) 152.37,10.09 151.19,8.9 116.5,8.9 v1(116.08,9.32) ; v1(203.64,40.64) 203.64,44.19 199.96,47.88 198.25,47.88 196.14,50 196.14,53.42 v1(195.5,54.05)
  IN2 w0.102: v1(203.64,40.64) 204.5,41.49 205.34,41.49 207.62,39.21 207.62,20.63 v1(206.17,19.18)
  IN3 w0.102: v1(37.44,11.33) 37.44,8.64 42.88,3.2 100.44,3.2 102.92,5.68 102.92,7.25 105.21,9.54 111.85,9.54 112.5,8.89 115.65,8.89 v1(116.08,9.32)
  BOTTOM w0.102: PR9106.1 195.61,54.05 v1(195.5,54.05) ; v1(28.25,31.19) 28.25,32.03 v2(30.99,34.77) 33.3,37.09 33.3,38.19 35.85,40.74 39.14,40.74 v1(39.55,41.15)
AZ_BITCLK_1: length 128.5
  TOP w0.102: v1(64.7,5.75) 64.94,5.98 66.69,5.98 67.16,5.51 71.97,5.51 73.33,6.87 73.33,10.02 73.65,10.34 73.65,11.15 75.26,12.75 78.94,12.75 79.2,13.01 79.2,15.85 79.81,16.46 79.81,21.06 79.48,21.39 79.48,23.85 84.07,28.45 v2(85.27,28.45) 85.34,28.45 86.41,29.52 v1(86.41,31.09)
  IN1 w0.097: v1(19.48,17.5) 22.85,17.5 37.13,3.22 62.17,3.22 v1(64.7,5.75)
  BOTTOM w0.102: R1014.2 C1004.1 95.64,43.82 95.61,43.79 95.61,43.79 86.41,34.6 v1(86.41,31.09) ; U3800.14 18.84,26.06 18.97,25.94 19.46,25.94 19.84,26.32 C3814.1 21.51,25.78 22.04,25.78 23.22,24.61 23.22,24.21 23.22,19.64 21.08,17.5 v1(19.48,17.5)
AZ_SDATA_IN0: length 125.3
  TOP w0.102: v1(84.99,29.75) 84.58,29.34 83.15,29.34 v2(82.13,28.32) 78.64,24.83 78.64,20.22 79.1,19.76 79.1,16.77 78.54,16.21 77.77,16.21 77.24,15.68 77.24,15.53 75.17,13.46 74.96,13.46 72.94,11.44 72.94,10.64 72.62,10.32 72.62,7.16 71.68,6.23 67.46,6.23 66.99,6.7 64.36,6.7 v1(63.41,5.75)
  IN1 w0.097: v1(63.41,5.75) 61.58,3.92 37.43,3.92 22.56,18.8 v1(20.88,18.8)
  BOTTOM w0.076: 102.86,43.66 102.88,43.68 103.52,43.68 104.11,44.27 105.62,44.27 U0400.BA21
  BOTTOM w0.102: v1(20.88,18.8) 22.5,20.42 22.5,23.9 R3805.1 ; 102.86,43.66 102.41,43.21 100.28,43.21 100.15,43.33 95.84,43.33 86.89,34.39 86.89,30.53 86.11,29.75 v1(84.99,29.75)
AZ_SDATA_OUT_1: length 119.6
  TOP w0.102: v1(62.8,5.75) 63.98,6.92 67.12,6.92 67.59,6.45 71.59,6.45 72.39,7.26 72.39,10.41 72.71,10.73 72.71,11.54 74.87,13.69 75.08,13.69 77.01,15.63 77.01,15.78 77.67,16.44 78.44,16.44 78.87,16.86 78.87,19.66 78.41,20.12 78.41,25.21 82.98,29.78 v2(84.02,29.78) 84.26,29.78 84.73,30.25 v1(85.4,30.25)
  IN1 w0.097: v1(62.8,5.75) 61.2,4.15 37.54,4.15 21.95,19.74 v1(20.47,19.74)
  BOTTOM w0.102: U3800.17 17.64,26.06 18.46,25.25 19.45,25.25 19.79,24.91 19.79,23.93 20.24,23.47 20.24,19.97 v1(20.47,19.74) ; R1015.2 96.14,45.7 95.38,44.94 95.38,44.58 85.4,34.6 v1(85.4,30.25)
AZ_SYNC_1: length 127.1
  TOP w0.102: v1(85.9,30.69) 85.9,29.7 85.14,28.93 83.35,28.93 v2(79.69,25.27) 78.99,24.57 78.99,20.68 79.32,20.35 79.32,16.67 78.58,15.93 77.81,15.93 77.47,15.59 77.47,15.44 75.27,13.24 75.06,13.24 73.17,11.35 73.17,10.54 72.85,10.22 72.85,7.07 71.77,6 67.36,6 66.89,6.47 64.74,6.47 v1(64.02,5.75)
  IN1 w0.097: v1(19.41,18.14) 22.89,18.14 37.33,3.7 61.97,3.7 v1(64.02,5.75)
  BOTTOM w0.102: v1(19.41,18.14) 21.01,18.14 22.73,19.87 22.73,24.41 21.84,25.3 20.78,25.3 20.24,25.83 19.74,25.83 19.61,25.71 18.64,25.71 18.44,25.91 U3800.15 ; v1(85.9,30.69) 85.9,34.78 95.43,44.3 95.44,44.3 95.63,44.49 95.63,44.81 96.04,45.21 97.54,45.21 97.89,44.86 R1013.2
BAT1_LED#: length 96.2
  TOP w0.102: v2(43.04,50.13) 43.04,50.13 43.04,50.13 v1(43.49,49.68) ; v1(42.71,47.05) 42.7,47.06 42.7,47.42 R2342.2 ; v1(40.72,33) 41.21,33.5 U2300.106
  IN3 w0.102: v1(21.41,83.7) 21.54,83.57 23.83,83.57 25.65,85.4 27.56,85.4 29.82,87.66 31.01,87.66 32.46,89.1 v1(32.46,90.53) ; v1(42.71,47.05) 43.87,45.9 43.87,43.65 42.54,42.32 41.17,42.32 40.84,41.99 40.84,40.41 41.86,39.4 41.86,34.14 41.68,33.96 v1(40.72,33) ; v1(43.49,49.68) 43.49,51.82 44.63,52.96 44.63,60.35 v1(45.26,60.99)
  BOTTOM w0.102: Q5000.4 21.25,86.07 21.78,85.54 21.78,84.06 v1(21.41,83.7) ; v1(32.46,90.53) 33.3,90.53 33.88,89.94 33.88,89.72 34.67,88.93 38.95,88.93 40.95,86.94 40.95,86.03 42.65,84.33 44.85,84.33 45.69,83.49 45.69,82.88 47.85,80.72 47.85,71.86 47.22,71.22 46.71,71.22 44.65,69.17 44.65,63.76 45.26,63.15 v1(45.26,60.99) ; v1(43.49,49.68) 43.41,49.76 43.26,49.76 42.71,49.21 v1(42.71,47.05)
BAT2_LED#: length 97.2
  TOP w0.102: U2300.1 40.9,45.67 41.43,46.21 42.29,46.21 42.47,46.03 42.93,46.03 v1(43.66,46.76) ; R2343.2 44.23,31.96 v1(44.07,32.12)
  IN3 w0.102: v1(19.38,84.31) 19.81,84.74 22.03,84.74 25.23,87.94 29.34,87.94 29.67,88.27 30,88.27 30.45,88.72 30.45,89.05 30.79,89.39 31.67,89.39 32.05,89.76 32.05,90.73 v1(32.46,91.14) ; v1(44.07,32.12) 43.26,32.93 43.26,42.6 44.09,43.44 44.09,46.33 v1(43.66,46.76) ; v1(44.35,49.56) 44.35,52.28 44.86,52.78 44.86,59.87 v1(45.21,60.23)
  BOTTOM w0.102: v1(43.66,46.76) 44.58,47.68 44.58,49.33 v1(44.35,49.56) ; Q5000.1 19.25,84.77 19.38,84.65 v1(19.38,84.31) ; v1(45.21,60.23) 45.67,60.68 45.67,63.05 44.86,63.86 44.86,69.08 46.8,71.02 47.32,71.02 48.06,71.76 48.06,80.85 45.9,83.01 45.9,83.57 44.71,84.76 v2(43.41,84.76) 42.5,84.76 41.15,86.12 41.15,87.1 39.12,89.13 34.76,89.13 34.09,89.8 34.09,90.03 33.38,90.73 32.87,90.73 v1(32.46,91.14)
BB_AMON_BMON: length 206.3
  TOP w0.102: R2305.2 48.31,36.47 v1(48.1,36.68) ; R2311.2 47.19,33.1 48.49,31.8 48.49,30.51 48.08,30.1 v1(48.08,29.85) 48.08,29.11 48.49,28.7 48.49,25.3 47.47,24.28 46.33,24.28 45.82,23.78 45.82,21.87 48.06,19.64 50.62,19.64 51.49,18.77 51.49,15.6 v2(50.95,15.06) v1(49.61,13.72)
  IN2 w0.102: v1(49.61,13.72) 49.61,12.51 51.79,10.33 60.02,10.33 61.64,8.7 70.35,8.7 71.27,9.63 90.31,9.63 91.6,10.92 96.89,10.92 97.47,11.51 101.92,11.51 102.92,12.51 102.92,13 103.23,13.31 105.16,13.31 105.79,13.95 108.78,13.95 109.72,13.01 110.26,13.01 110.77,13.52 111.66,13.52 112.27,12.91 114.33,12.91 115.15,13.72 124.47,13.72 124.6,13.85 126.47,13.85 126.95,13.36 132.12,13.36 135,16.25 142.87,16.25 143.77,17.14 155.35,17.14 156.28,16.21 198.8,16.21 203.68,21.09 203.68,22.33 202.67,23.35 202.67,23.78 201.42,25.02 v1(201.42,25.68) ; v1(48.1,36.68) 48.46,36.32 48.46,30.23 v1(48.08,29.85)
  BOTTOM w0.102: PR7724.2 201.17,25.94 201.42,25.68 v1(201.42,25.68)
BEEP: length 53.1
  TOP w0.102: v1(43.1,10.7) 43.61,10.7 v2(43.74,10.82)
  TOP w0.229: U2300.45 25.42,37.5 v1(25.37,37.54)
  IN2 w0.254: v1(43.1,10.7) 43.03,10.62 34.61,10.62 34.43,10.62 23.65,21.4 23.65,32.06 23.98,32.39 23.98,36.3 25.22,37.54 v1(25.37,37.54)
  BOTTOM w0.254: v1(43.1,10.7) 43.92,10.7 44.2,10.98 44.2,12.07 45.1,12.97 46.95,12.97 47.43,12.49 49.08,12.49 D3805.1
BKLT_IN_EC: length 148.1
  TOP w0.102: U2300.67 29.3,27.19 29.26,27.16 29.26,26.57 28.83,26.14 28.73,26.14 28.6,26.01 R2344.1 29.13,25.99 v1(29.69,26.55)
  IN2 w0.102: v1(37.97,37.42) 37.97,35.44 39.22,34.19 39.22,26.87 42.32,23.77 42.32,23.58 44.02,21.88 44.02,20.6 44.32,20.3 48.67,20.3 49.56,21.19 50.9,21.19 51.79,20.3 54.16,20.3 55.81,18.65 61.94,18.65 62.24,18.34 63.54,18.34 64.02,18.82 65.74,18.82 66.55,18.01 68.84,18.01 69.6,17.25 70.51,17.25 70.64,17.12 74.88,17.12 77.52,19.76 78.79,19.76 81.07,22.05 83.97,22.05 84.33,22.41 84.9,22.41 86.9,20.4 89.26,20.4 90.34,21.47 94.99,21.47 95.28,21.19 97.24,21.19 97.82,21.76 97.82,22 98.76,22.94 102.57,22.94 102.77,22.74 105.86,22.74 106.1,22.49 111.93,22.49 113.01,21.41 114.35,21.41 114.55,21.61 116.99,21.61 117.81,22.44 118.72,22.44 119.45,23.17 122.51,23.17 124.14,24.8 124.14,28.4 124,28.54 124,32 122.18,33.82 121.63,33.82 120.45,35 120.45,39.03 v3(119.83,39.65)
  BOTTOM w0.102: v1(29.69,26.55) 29.69,29.75 v2(29.39,30.05) 29.24,30.2 29.24,32.41 33.84,37.01 34.71,37.01 35.08,37.38 35.08,37.66 35.53,38.11 36.08,38.11 36.42,38.46 37.31,38.46 37.97,37.8 v1(37.97,37.42)
  BOTTOM w0.108: U0400.R12 119.63,39.65 v3(119.83,39.65)
BLUETOOTH_EN: length 130.7
  TOP w0.102: v1(204.04,17.55) 203.72,17.55 202.16,19.11 v1(202.16,21.11) ; v1(153.77,18.85) 153.77,18.72 v2(154.23,18.26)
  IN1 w0.102: v1(117.06,29.82) 118.54,29.82 119.46,28.91 125.68,28.91 126.29,28.3 127.64,28.3 128.09,27.84 133.71,27.84 136,25.54 136,22.01 137.11,20.91 147.56,20.91 148.12,21.47 148.67,21.47 149.17,20.96 150.27,20.96 152.17,19.05 153.57,19.05 v1(153.77,18.85)
  IN2 w0.102: v1(202.16,21.11) 199.54,21.11 195.58,17.15 158.33,17.15 157.41,18.06 154.56,18.06 v1(153.77,18.85) ; v1(205.08,40.86) 207.16,38.77 207.16,21.07 205.54,19.44 205.54,18.65 204.44,17.55 v1(204.04,17.55)
  BOTTOM w0.076: U0400.AB2 115.99,33.36 116.06,33.29 116.06,32.94 116.11,32.7 116.11,32.2
  BOTTOM w0.102: v1(117.06,29.82) 116.56,30.32 116.56,31.75 116.11,32.2 ; CON5103.37 205.48,41.26 v1(205.08,40.86)
BOARD_ID: length 6.7
  TOP w0.102: v2(48.01,35.03) 46.91,33.94 R2314.2 R2315.1 C2314.1 44.89,33.94 44.18,34.65 44.03,34.65 43.59,35.09 43.59,35.33 43.42,35.5 U2300.111
BOARD_ID1: length 12.5
  BOTTOM w0.076: U0400.AC1 115.17,31.93
  BOTTOM w0.102: 115.17,31.93 115.52,31.57 115.52,29.88 116.15,29.24 116.15,28.81 116.36,28.6 116.36,27.92 116.78,27.5 117.58,27.5 118.22,26.85 118.22,26.23 118.57,25.88 R1511.1 118.17,25.03 118.17,24.09 118.29,23.98 R1509.2 118.29,22.89 v2(118.07,22.67)
BOARD_ID2: length 15.3
  BOTTOM w0.076: U0400.AB3 116.15,33.68 116.15,33.43 116.23,33.35 116.23,32.96 116.28,32.72 116.28,32.39 116.75,31.92 116.75,30.89
  BOTTOM w0.102: 116.75,30.89 116.75,30.7 117.55,29.9 117.55,28.1 118.63,27.02 118.63,26.41 119.14,25.9 119.14,24.87 119.25,24.76 R1512.1 R1510.2 120.19,22.91 120.07,22.79 119.84,22.79 119.71,22.66 119.71,21.85 v2(119.41,21.54)
BPM0: length 3.6
  TOP w0.076: T0405.1 128.76,64.32
  TOP w0.102: 128.76,64.32 128.99,64.09 v3(128.99,63.65)
  BOTTOM w0.076: U0400.C55 126.32,64.05 128.59,64.05 128.99,63.65 v3(128.99,63.65)
BPM1: length 5.1
  TOP w0.102: T0406.1 126.44,63.88 128.15,63.88 v3(128.38,63.65)
  BOTTOM w0.076: v3(128.38,63.66) 128.27,63.76 126.16,63.76 125.87,64.05 U0400.D55
BPM2: length 3.7
  TOP w0.102: T0411.1 127.41,62.28 127.79,62.28 v3(128.36,62.84)
  BOTTOM w0.102: v3(128.36,62.84) 128.14,63.06 128.14,63.06 127.95,63.25 127.51,63.25 127.47,63.21 126.92,63.21 U0400.B54
BPM3: length 4.3
  TOP w0.102: v3(128.6,64.98) 128.17,64.54 T0412.1
  BOTTOM w0.076: U0400.C56 126.22,64.61 126.63,65.02 127.08,65.02 127.1,65.03 127.21,65.05 127.52,65.05 127.86,64.71 128.33,64.71 v3(128.6,64.98)
BREATH_LED#: length 240.5
  TOP w0.102: U2300.70 30.5,27.36 30.63,27.23 30.75,27.23 30.99,26.99 30.99,26.82 31.78,26.04 R2349.2 32.18,26.42 v1(31.9,26.7) ; v1(42.88,10.01) 41.99,10.91 v2(41.99,11.15)
  IN1 w0.102: v1(31.9,26.7) 33.08,25.52 33.08,16 36.63,12.45 40.45,12.45 v1(42.88,10.01)
  IN2 w0.102: v1(42.88,10.01) 43,10.01 43.43,10.44 47.95,10.44 50.21,8.18 53.7,8.18 55.66,6.23 58.75,6.23 59.43,6.91 60.7,6.91 61.26,6.35 71.95,6.35 72.76,7.17 93.7,7.17 96.08,9.55 97.46,9.55 97.91,10.01 103.15,10.01 104.49,11.36 105.51,11.36 106.15,11.99 108.75,11.99 109.33,11.41 116.08,11.41 116.99,12.32 123.57,12.32 124.18,11.71 137.03,11.71 138.28,12.96 143.7,12.96 143.98,13.24 147.22,13.24 147.68,12.78 150.58,12.78 151.01,13.21 151.39,13.21 153.5,15.31 154.59,15.31 155.68,14.23 164.92,14.23 165.99,13.15 172.31,13.15 173.35,14.2 179.1,14.2 179.81,13.49 182.35,13.49 182.63,13.77 197.21,13.77 197.84,13.13 201.35,13.13 210.16,21.95 210.16,33.78 213.64,37.26 213.64,38.85 210,42.5 206.76,42.5 206.17,43.08 204.95,43.08 204.52,42.65 v1(204.5,42.65)
  BOTTOM w0.102: CON5103.39 204.89,42.26 v1(204.5,42.65)
C0_VDDI: length 5.4
  TOP w0.076: 97.29,24.03 97.78,24.03 U2500.C2
  TOP w0.102: 97.29,24.03 96.7,24.03 96.63,23.96 95.57,23.96 v1(94.95,23.35) 94.33,23.96 C2503.1
  BOTTOM w0.102: v2(94.21,23.19) 94.79,23.19 v1(94.95,23.35)
CAM_EN#: length 9.8
  BOTTOM w0.076: 129.31,34.57 128.55,34.57 127.69,35.43 127.09,35.43 U0400.A6
  BOTTOM w0.102: 129.31,34.57 129.8,34.57 130.01,34.37 130.53,34.37 130.66,34.5 135.08,34.5 T0407.1
CAP_LED#: length 63.7
  TOP w0.102: v2(41.67,23.64) 41.5,23.47 v1(40.26,23.47) 39.78,23.47 39.27,23.98 39.27,26.98 39.7,27.41 U2300.93
  IN2 w0.102: v1(84.3,20.2) 83.03,20.2 82.98,20.14 79.87,20.14 79.17,19.44 79.17,17.43 78.38,16.64 76.84,16.64 76.38,17.1 75.54,17.1 75.34,16.89 70.55,16.89 70.42,17.02 69.44,17.02 68.68,17.78 66.46,17.78 65.64,18.6 64.12,18.6 63.61,18.09 62.17,18.09 61.84,18.42 55.72,18.42 54.07,20.07 46.3,20.07 46.08,19.84 44.18,19.84 42.09,21.93 42.09,23.68 41.3,24.46 39.77,24.46 39.48,24.17 39.48,23.84 39.84,23.47 v1(40.26,23.47)
  BOTTOM w0.102: v1(84.3,20.2) 84.56,20.2 85.62,19.13 U5100.4
CASA0#: length 43.2
  TOP w0.127: U6801.G3 196.54,97.36 ; 196.54,97.36 v1(196.54,97.37) ; 196.54,97.36 196.54,96.88 196.3,96.64 193.61,96.64 192.79,95.81 192.79,91.87 190.77,89.86 v2(187.1,89.86) 182.73,89.86 180.33,92.27 180.33,93.5 180.08,93.74 179.9,93.74 179.84,93.81 174.35,93.81 174.11,93.56 174.11,92.46 174.41,92.15 174.8,92.15 175.06,91.9 175.06,91.16 174.83,90.93 173.85,90.93 173.73,91.06 173.73,91.54 173.6,91.66 173.23,91.66 173.08,91.51 173.08,90.96 172.97,90.86 172.59,90.86 172.47,90.99 172.47,92.03 172.21,92.28 171.66,92.28 171.04,91.67 170.66,91.67 v1(170.23,91.24)
  BOTTOM w0.127: v1(170.23,91.24) 170.43,91.04 U6000.G19 ; v1(196.54,97.37) 196.54,97.36 U6801.G3
CASA1#: length 50.3
  TOP w0.127: U6803.L3 188.93,78 v1(188.56,77.64) 188.56,78.09 188.31,78.34 187.17,78.34 185.78,79.74 185.77,79.74 v2(184.99,80.52) 184.99,80.52 184.61,80.9 184.61,81.08 184.68,81.15 184.68,81.33 184.5,81.51 184.32,81.51 184.25,81.44 184.07,81.44 183.48,82.03 182.31,82.03 182.18,82.16 182.18,83.3 182.04,83.44 181.81,83.44 181.67,83.3 181.67,82.78 181.55,82.65 179.86,82.65 178.08,80.88 175.18,80.88 175.06,80.75 175.06,79.78 175.23,79.61 176.31,79.61 176.48,79.44 176.48,79.19 176.31,79.02 175.44,79.02 175.31,78.89 175.31,78.11 175.11,77.91 173.89,77.91 173.7,78.1 173.7,78.92 173.83,79.05 174.05,79.05 174.18,79.17 174.18,79.43 174.05,79.55 173.83,79.55 173.7,79.68 173.7,80.43 173.83,80.56 174.57,80.56 174.7,80.69 174.7,80.94 174.57,81.07 173.83,81.07 173.7,81.19 173.7,82.37 173.83,82.49 175.06,82.49 175.18,82.62 175.18,82.88 175.06,83 173.83,83 173.7,83.13 173.7,83.92 173.83,84.05 177.09,84.05 177.22,84.18 177.22,84.58 177.09,84.72 173.83,84.72 173.7,84.85 173.7,85.71 172.09,87.33 171.42,87.33 171.09,87.66 v1(170.66,87.66)
  BOTTOM w0.127: v1(188.56,77.64) 188.6,77.64 U6803.L3 ; U6000.G16 170.43,87.89 v1(170.66,87.66)
CCG4_CC1_P1: length 87.8
  TOP w0.254: U5800.9 44.17,78.49 44.5,78.82 C5806.1 45.59,79.45 46.63,79.45 46.99,79.81 46.99,81.23 46.61,81.61 v2(46.61,82.1) 46.84,82.32 v1(46.84,82.76) ; v1(29.59,76.91) 29.59,76.81 29.25,76.47 29.25,75.46 28.76,74.96 27.2,74.96 26.75,74.5 24.31,74.5 23.67,75.14 20.57,75.14 18.97,76.74 16.99,76.74 15.37,78.36 13.36,78.36 v1(13.21,78.51)
  IN1 w0.254: v1(34.05,75.8) 34.05,76.41 33.43,77.04 29.72,77.04 v1(29.59,76.91) 28.98,76.91 28.12,77.78 23.7,77.78 23.06,78.41 23.06,83.32 20.62,85.77 20.62,87.54 19.79,88.37 17.2,88.37 16.85,88.72 16.03,88.72 15.25,87.94 12.9,87.94 10.77,90.07 10.34,90.07 v1(9.93,90.48)
  IN3 w0.254: v1(8.35,86.62) 7.95,87.01 7.95,88.88 8.26,89.18 9.47,89.18 9.83,89.54 9.83,90.38 v1(9.93,90.48) ; v1(34.05,75.8) 34.09,75.8 34.62,75.26 35.23,75.26 35.59,75.62 35.59,78.81 37.94,81.16 44.52,81.16 46.12,82.76 v1(46.84,82.76)
  BOTTOM w0.203: CON5700.A5 7.94,86.25 8.31,86.62 v1(8.35,86.62)
  BOTTOM w0.254: v1(13.21,78.51) 13.48,78.79 D5706.1
CCG4_CC2_P1: length 72.7
  TOP w0.254: D5707.1 10.74,92.63 v1(10.03,91.93) ; v1(46.84,83.46) 47.35,82.95 47.35,78.31 v2(47.02,77.98) 47.02,77.47 47.12,77.37 47.12,76.88 46.83,76.6 45.49,76.6 C5805.1 44.59,76.43 44.12,76.43 43.82,76.74 43.82,77.33 43.66,77.49 U5800.7
  IN1 w0.254: v1(34.52,77) 34.2,77 33.81,77.4 29,77.4 28.27,78.13 23.9,78.13 23.42,78.62 23.42,83.47 20.97,85.92 20.97,87.69 19.94,88.72 17.37,88.72 17.02,89.08 15.88,89.08 15.1,88.29 13.06,88.29 11.23,90.12 11.23,90.78 10.77,91.24 10.31,91.24 10.03,91.52 v1(10.03,91.93)
  IN3 w0.102: 6.35,88.88 6.24,88.76 6.24,88.75 6.03,88.2 CON5700.B5
  IN3 w0.254: v1(34.52,77) 34.89,77 35.23,77.35 35.23,78.95 37.79,81.51 42.58,81.51 44.53,83.46 v1(46.84,83.46) ; 6.35,88.88 6.64,89.17 7.2,89.17 7.57,89.54 9.25,89.54 9.45,89.74 9.45,91.09 10.03,91.67 v1(10.03,91.93)
CCG4_I2C_INT#: length 50.5
  TOP w0.102: v1(27.46,48.26) 27.45,48.26 27.45,47.23 28.02,46.66 28.02,45.9 v2(28.49,45.43) 28.49,44.9 28.5,44.89 U2300.32 ; R5812.2 40.49,82.18 v1(40.68,81.99) 40.54,81.85 40.54,80.16 40.66,80.04 U5800.15
  IN3 w0.127: v1(40.68,81.99) 37.82,81.99 34.73,78.9 34.73,78.15 33.63,77.05 33.63,74.23 32.79,73.38 32.79,70.06 26.09,63.36 26.09,58.37 27.46,57 v1(27.46,48.26)
CCG4_I2C_SCL: length 197.9
  TOP w0.102: U5800.17 39.66,80.23 v1(39.52,80.37) 39.37,80.52 39.37,80.72 R5810.2 ; v1(28,55.32) 29.03,55.32 C1904.1 ; 44.6,21.36 v1(44.6,20.7)
  IN3 w0.127: v1(78.46,17.93) 79.09,17.3 79.09,15.38 78.73,15.01 78.19,15.01 77.39,14.22 76.44,14.22 73.68,11.46 69.32,11.46 68.82,11.95 63.94,11.95 63.6,12.3 60.4,12.3 59.27,11.17 55.56,11.17 55.44,11.29 53.42,11.29 50.29,14.42 50.29,15.83 45.66,20.47 44.84,20.47 v1(44.6,20.7) 44.09,20.7 43.73,20.34 43.73,19.41 43.64,19.32 43.36,19.32 43.22,19.46 43.22,20.34 43.09,20.47 42.84,20.47 42.71,20.34 42.71,19.71 42.58,19.59 42.33,19.59 42.2,19.71 42.2,20.34 42.07,20.47 41.82,20.47 41.69,20.34 41.69,19.71 41.57,19.59 41.31,19.59 41.19,19.71 41.19,20.34 41.06,20.47 40.8,20.47 40.68,20.34 40.68,19.36 40.56,19.24 40.33,19.24 40.17,19.41 40.17,20.34 40.04,20.47 39.5,20.47 39.37,20.6 39.37,21.02 39.5,21.15 42.8,21.15 42.93,21.28 42.93,21.53 42.8,21.66 39.5,21.66 39.37,21.78 39.37,22.29 39.5,22.42 41.88,22.42 42.01,22.55 42.01,22.8 41.88,22.93 39.24,22.93 39.12,23.05 39.12,23.89 35.22,27.79 33.29,27.79 32.09,28.98 32.09,29.5 32.22,29.63 32.99,29.63 33.12,29.76 33.12,30.01 32.99,30.14 32.22,30.14 32.09,30.27 32.09,30.52 32.22,30.65 32.99,30.65 33.12,30.77 33.12,31.03 32.99,31.15 32.22,31.15 32.09,31.28 32.09,32.25 30.15,34.2 30.15,39.73 29.24,40.64 29.24,44.88 28,46.12 28,47.28 28.13,47.41 28.94,47.41 29.07,47.54 29.07,47.79 28.94,47.92 28.13,47.92 28,48.05 28,48.3 28.13,48.43 28.94,48.43 29.07,48.55 29.07,48.81 28.94,48.94 28.13,48.94 28,49.06 28,49.32 28.13,49.44 28.94,49.44 29.07,49.57 29.07,49.82 28.94,49.95 28.13,49.95 28,50.08 28,50.33 28.13,50.46 28.94,50.46 29.07,50.59 29.07,50.84 28.94,50.97 28.13,50.97 28,51.09 28,51.35 28.13,51.48 28.94,51.48 29.07,51.6 29.07,51.86 28.94,51.98 28.13,51.98 28,52.11 28,53.03 28.13,53.16 28.42,53.16 28.55,53.29 28.55,53.54 28.42,53.67 28.13,53.67 28,53.8 28,54.05 28.13,54.18 29.16,54.18 29.26,54.28 29.26,54.58 29.16,54.68 28.13,54.68 28,54.81 v1(28,55.32) 28,57.88 27.99,57.89 28.83,58.73 28.83,59.01 28.52,59.31 28.12,59.31 27.16,58.35 26.88,58.35 26.59,58.64 26.59,59.77 26.72,59.9 29.16,59.9 29.26,60 29.26,60.35 29.21,60.4 26.72,60.4 26.59,60.53 26.59,60.78 26.72,60.91 29.16,60.91 29.26,61.01 29.26,61.29 29.13,61.42 26.72,61.42 26.59,61.55 26.59,62.05 27.43,62.89 27.43,63.99 30.82,67.38 32.15,67.38 33.76,68.98 33.76,72.62 39.52,78.38 v1(39.52,80.37)
  BOTTOM w0.102: v1(39.52,80.37) 39.52,79.02 38.68,78.18 31.17,78.18 v2(30.2,79.15) 26.9,79.15 24.51,81.54 24.51,82.44 24.15,82.81 23.6,82.81 23.44,82.65 23.44,81.92 R5721.1 R5724.1 ; v1(78.46,17.93) 78.77,17.93 79.06,17.65 Q1901.1
CCG4_I2C_SCL_MUX: length 33
  TOP w0.102: U5800.29 37.32,74.99 37.11,74.78 37.11,74.4 36.67,73.97 35.53,73.97 35.33,73.76 35.33,73.68 R5818.2 34.95,73.56 34.8,73.71 34.8,73.98 34.56,74.22 33.68,74.22 32.97,74.94 32.97,74.98 32.97,76.2 33.63,76.86 33.63,77.9 34.34,78.62 35.76,78.62 36.02,78.87 36.02,82.46 34.85,83.64 v2(34.85,84.61) 34.85,87.46 33.35,88.95 v1(31.7,88.95) 31.24,88.5 30.24,88.5 29.72,87.97 29.72,87.4 28.58,86.26 28.58,85.8 28.31,85.54 U5703.21
  BOTTOM w0.102: v1(31.7,88.95) 32.09,88.95 v2(33.45,87.6)
CCG4_I2C_SDA: length 148.6
  TOP w0.102: R1914.1 75.21,17.4 75.31,17.5 75.31,17.58 75.48,17.74 77.23,17.74 v1(77.9,17.07) ; v1(40.64,83.8) 40.46,83.97 C1903.1 ; U5800.16 40.16,80.41 v1(40.13,80.44) 39.9,80.67 R5811.2
  IN2 w0.109: v1(40.13,80.44) 41.09,81.4 41.09,83.35 v1(40.64,83.8)
  IN3 w0.127: v1(40.13,80.44) 40.13,78.27 34.26,72.4 34.26,68.77 31.69,66.2 31.09,66.2 29.05,64.15 29.05,62.22 29.77,61.5 29.77,60.58 30.73,59.62 30.73,57.35 29.77,56.38 29.77,53.24 30.01,53 30.01,47.79 30.12,47.68 30.12,40.59 31.22,39.5 31.22,35.54 32.73,34.02 32.73,32.39 33.67,31.45 33.67,29.54 34.08,29.13 34.6,29.13 39.14,24.59 41.25,24.59 44.37,21.48 45.6,21.48 48.47,18.61 50.1,18.61 51.19,17.52 51.19,14.24 53.25,12.19 58.37,12.19 58.98,12.8 63.86,12.8 64.2,12.46 69.08,12.46 69.57,11.97 72.57,11.97 75.07,14.46 75.07,15.61 75.34,15.88 76.71,15.88 v1(77.9,17.07)
  BOTTOM w0.102: v1(40.13,80.44) 39.8,80.77 39.35,80.77 39.04,80.46 39.04,80.22 37.49,78.67 31.47,78.67 30.5,79.64 v2(27.09,79.64) 24.99,81.74 24.99,82.64 24.35,83.29 23.37,83.29 23.24,83.16 R5722.1 R5723.1 ; Q1901.4 77.63,16.35 77.9,16.62 v1(77.9,17.07)
CCG4_I2C_SDA_MUX: length 32.3
  TOP w0.102: U5703.22 27.71,86.08 29.21,87.58 29.21,88.15 v2(30.36,89.3) 30.5,89.44 33.5,89.44 R5817.2 34.85,89.51 34.85,88.14 35.33,87.66 35.33,83.84 36.5,82.66 v2(36.5,79.61) 36.5,78.67 35.96,78.13 34.54,78.13 34.11,77.7 34.11,76.66 33.45,76 33.45,75.14 33.88,74.7 34.8,74.7 35.18,74.32 36.35,74.32 36.6,74.58 36.6,74.95 37.13,75.49 U5800.28
CCG4_ID1: length 1.5
  TOP w0.102: R5821.2 36.68,77.65 37.34,76.99 U5800.25
CCG4_ID2: length 3
  TOP w0.102: R5823.2 R5822.1 36.35,75.06 36.35,75.16 36.68,75.49 36.68,75.82 36.84,75.99 U5800.27
CCG4_SWD_CLK: length 2.1
  TOP w0.102: U5800.2 44,74.99 v1(44.09,75.08)
  BOTTOM w0.102: T5804.1 44.73,75.08 v1(44.09,75.08)
CCG4_SWD_IO: length 1.7
  TOP w0.102: U5800.1 v1(43.94,74.49)
  BOTTOM w0.102: T5803.1 43.64,74.18 v1(43.94,74.49)
CFAN_PWM_R: length 19.3
  TOP w0.102: v1(205.78,89.4) v2(204.95,89.4) ; v2(208.25,86.74) v1(210.29,86.74)
  BOTTOM w0.381: CON3600.4 208.33,82.75 208.66,82.43 209.91,82.43 210.29,82.81 v1(210.29,86.74) 210.29,87.3 210.06,87.53 R3611.2 C3603.1 209.3,89.05 209.17,89.18 Q3602.3 206,89.18 v1(205.78,89.4) 205.78,90.77 R3610.1
CFG0: length 17.7
  TOP w0.102: T0903.1 134.72,66.63 134.7,66.65 131.5,66.65 129.44,68.71 129.44,71.17 v3(128.91,71.71)
  BOTTOM w0.076: v3(128.91,71.71) 127.92,71.71 127.48,71.27 126.81,71.27 126.75,71.21 125.64,71.21 U0400.E68
CFG1: length 4.7
  BOTTOM w0.076: U0400.B67 126.85,70.72 127,70.72 127.16,70.65 127.91,70.65 127.96,70.7 129.18,70.7
  BOTTOM w0.102: 129.18,70.7 129.2,70.7 129.72,71.22 129.72,71.44 T0906.1
CFG2: length 5.5
  BOTTOM w0.076: U0400.D65 125.64,69.87 126.89,69.87 127.2,70.03 128.47,70.03 128.78,69.73 129.18,69.73
  BOTTOM w0.102: 129.18,69.73 130.31,69.73 T0907.1
CFG3: length 4.8
  BOTTOM w0.076: 129.18,70.49 129.08,70.49 129.03,70.54 128.04,70.54 127.99,70.49 127.12,70.49 126.97,70.55 126.77,70.55 126.58,70.64 126.23,70.8 126.12,70.8 U0400.D67
  BOTTOM w0.102: T0900.1 130.09,70.49 129.18,70.49
CFG4: length 7.5
  BOTTOM w0.102: v2(128.68,77.93) 128.22,77.47 127.08,77.47 126.57,76.96 R0901.1 126.49,74.73 125.23,73.46 125.23,72.92 U0400.E70
CFG5: length 9.1
  TOP w0.076: 128.5,75.26 v3(127.36,74.12)
  TOP w0.102: T0908.1 128.75,79.12 128.75,75.52 128.5,75.26
  BOTTOM w0.076: v3(127.36,74.12) 126.9,74.12 126.52,73.74 126.52,73.15 126.34,72.98 126.34,72.38 U0400.C68
CFG6: length 10.6
  TOP w0.076: 127.89,75.26 v3(127.36,74.73)
  TOP w0.102: T0909.1 128.27,79.52 128.27,78.82 128.55,78.54 128.55,75.92 127.89,75.26
  BOTTOM w0.076: U0400.D68 125.52,72.62 125.88,72.98 125.88,73.56 126.75,74.42 127.05,74.42 v3(127.36,74.73)
CFG7: length 6.7
  BOTTOM w0.076: U0400.C67 126.7,71.51 127.06,71.86 127.57,71.86 127.81,72.11 127.81,75.14 127.69,75.26
  BOTTOM w0.102: 127.69,75.26 127.51,75.44 127.51,76.91 T0904.1
CFG8: length 4.7
  TOP w0.076: 125.12,75.26 125.01,75.15 v3(125.01,74.94)
  TOP w0.102: 125.12,75.26 126.53,76.67 T0910.1
  BOTTOM w0.076: U0400.F71 124.45,72.97 124.45,74.38 v3(125.01,74.94)
CFG9: length 8.3
  TOP w0.076: 124.15,75.26 123.88,74.99 v3(123.88,74.93)
  TOP w0.102: 124.15,75.26 125.63,76.74 125.63,78.86 T0911.1
  BOTTOM w0.076: v3(123.88,74.93) 123.5,74.56 123.5,73.52 123.47,73.49 123.47,73.25 123.51,73.11 123.51,72.86 123.43,72.71 123.43,72.24 U0400.G69
CFG10: length 9.8
  TOP w0.076: v3(125.01,74.38) 125.15,74.38 125.6,74.83 125.6,75.26
  TOP w0.102: 125.6,75.26 125.6,75.39 126.01,75.8 126.31,75.8 127.01,76.49 127.01,76.96 126.82,77.15 126.82,80.28 T0912.1
  BOTTOM w0.076: v3(125.01,74.38) 124.62,73.98 124.62,73.09 124.63,73.08 124.63,72.67 124.3,72.34 U0400.F70
CFG11: length 13.8
  TOP w0.076: 126.31,75.26 126.19,75.14 126.19,74.17 125.3,73.28 124.87,73.28 123.84,72.25 123.84,71.98 v3(123.08,71.22)
  TOP w0.102: T0913.1 127.48,80.84 127.48,80.22 127.03,79.76 127.03,77.23 127.21,77.05 127.21,76.17 126.39,75.35 126.39,75.34 126.31,75.26
  BOTTOM w0.076: U0400.G68 123.25,71.38 v3(123.08,71.22)
CFG12: length 11.1
  TOP w0.076: v3(122.98,74.84) 122.98,75.08 123.16,75.26
  TOP w0.102: 123.16,75.26 123.65,75.75 124.06,75.75 125.22,76.91 125.22,80.89 125.81,81.49 T0914.1
  BOTTOM w0.076: v3(122.98,74.84) 123.34,74.48 123.34,73.59 123.31,73.56 123.31,73.23 123.34,73.09 123.34,72.9 123.24,72.69 123.24,72.52 U0400.H70
CFG13: length 5.8
  TOP w0.076: v3(123.87,73.82) 124.03,73.82 124.38,74.17 124.38,74.53 124.61,74.75 124.61,75.11 124.76,75.26
  TOP w0.102: 124.76,75.26 126.04,76.53 126.04,77.69 T0915.1
  BOTTOM w0.076: v3(123.87,73.82) 123.74,73.68 U0400.G71
CFG14: length 10.5
  TOP w0.076: 123.57,75.26 123.39,75.08 123.39,74.53 123.14,74.28 v3(122.96,74.28)
  TOP w0.102: T0916.1 125.43,80.18 125.43,76.83 124.14,75.54 123.97,75.54 123.97,75.54 123.85,75.54 123.57,75.26
  BOTTOM w0.076: U0400.H69 122.68,72.1 122.68,73.49 122.6,73.57 122.6,73.92 v3(122.96,74.28)
CFG15: length 10.8
  TOP w0.076: 124.44,75.26 124.36,75.18 124.36,74.78 123.95,74.38 v3(123.87,74.38)
  TOP w0.102: T0917.1 126.47,81.11 126.47,79 125.83,78.36 125.83,76.66 124.44,75.26
  BOTTOM w0.076: U0400.G70 124.27,73.21 124.27,73.98 v3(123.87,74.38)
CFG16: length 12.1
  TOP w0.076: 129.16,75.26 127.95,74.05 127.95,73.38 125.02,70.45 v3(125.02,68.89)
  TOP w0.102: T0918.1 129.16,77.72 129.16,75.26
  BOTTOM w0.076: U0400.E63 125.02,68.72 v3(125.02,68.89)
CFG17: length 13.9
  TOP w0.076: 128.83,75.26 127.74,74.17 127.74,73.42 124.84,70.52 124.84,69.85 123.83,68.84 v3(123.83,68.81)
  TOP w0.102: 128.83,75.26 128.96,75.39 128.96,78.48 T0919.1
  BOTTOM w0.076: v3(123.83,68.81) 123.99,68.65 U0400.F63
CFG18: length 12.4
  TOP w0.076: 126.95,75.26 126.67,74.98 126.67,74.07 125.45,72.85 125.1,72.85 124.19,71.95 124.19,71.83 124.01,71.65 v3(124.01,71.03)
  TOP w0.102: 126.95,75.26 127.62,75.93 127.62,77.27 127.43,77.46 127.43,78.36 128,78.93 128,80.14 T0920.1
  BOTTOM w0.076: U0400.E66 124.64,70.4 v3(124.01,71.03)
CFG19: length 11.1
  TOP w0.076: v3(123.49,70.84) 123.49,71.37 124.02,71.9 124.02,72.15 124.97,73.1 125.45,73.1 126.49,74.15 126.49,75.16 126.59,75.26
  TOP w0.102: 126.59,75.26 127.41,76.08 127.41,77.13 127.23,77.32 127.23,78.89 T0921.1
  BOTTOM w0.076: v3(123.49,70.84) 123.95,70.37 U0400.F66
CFG_RCOMP: length 1.9
  TOP w0.254: v3(124.93,66.78) 125.37,66.78 125.59,66.56 R0900.1
  BOTTOM w0.254: U0400.E60 124.7,66.59 124.74,66.59 v3(124.93,66.78)
CHA_DIMM0_EVENT#: length 6.1
  TOP w0.102: v2(66.17,57.38) 65.68,57.86 v1(65.68,58.02) 65.68,58.65 R2002.2
  BOTTOM w0.102: v1(65.68,58.02) 65.68,58.7 65.31,59.07 CON2000.134
CHB_DIMM0_EVENT#: length 9.6
  TOP w0.102: R2100.2 48.9,55.93 v1(48.44,56.39) v2(47.94,56.89)
  IN1 w0.102: v1(51.69,59.54) 51.16,59.01 50.29,59.01 48.44,57.15 v1(48.44,56.39)
  BOTTOM w0.102: CON2100.134 51.15,60.07 v1(51.69,59.54)
CHG_ACIN: length 205
  TOP w0.254: v1(26.87,20.58) 26.86,20.59 Q2401.3
  IN3 w0.254: v1(195.68,30.49) 195.68,30.08 195.56,29.95 187.49,29.95 178.9,21.36 169.93,21.36 v1(169.74,21.55) ; v1(26.87,20.58) 27.41,20.04 31.52,20.04 31.82,19.74 31.82,19.49 40.49,10.82 40.49,8.61 45.31,3.79 87.49,3.79 90.87,7.17 94.44,7.17 97.51,10.24 104.36,10.24 104.76,10.64 107.45,10.64 108.12,11.31 109.8,11.31 110.41,10.7 118.59,10.7 119.29,10 142.61,10 143.12,10.51 150.19,10.51 151.04,11.36 151.31,11.36 151.89,11.93 v1(151.89,11.94)
  BOTTOM w0.229: PU7700.19 195.39,28.39
  BOTTOM w0.254: PR7707.2 PR7710.1 195.94,30.75 v1(195.68,30.49) 195.88,30.3 195.88,29.59 PC7716.1 195.35,28.43 195.39,28.39 ; v2(29.85,23.14) 28.75,23.14 26.87,21.26 v1(26.87,20.58) ; v1(151.89,11.94) 151.89,12.96 151.03,13.82 151.03,17.86 152.84,19.66 155.5,19.66 156.26,20.42 164.92,20.42 166.55,22.05 169.24,22.05 v1(169.74,21.55)
CHG_ACOK: length 233.6
  TOP w0.102: R2401.2 17.91,48.26 18.14,48.03 20.65,48.03 21.02,48.4 25.21,48.4 v2(25.51,48.71) 27.03,50.22 30.1,50.22 30.67,50.79 32.04,50.79 v1(32.12,50.71) ; PR7706.2 198.48,29.01 v1(199.01,28.48)
  IN2 w0.102: v1(199.01,28.48) 199.01,22.76 193.62,17.38 158.42,17.38 157.51,18.29 157,18.29 155.68,19.61 151.46,19.61 150.36,18.52 138.2,18.52 137.31,17.63 134.39,17.63 133.35,16.59 120.47,16.59 119.33,15.45 110.4,15.45 110.1,15.75 94.75,15.75 94.18,15.18 94.18,13.7 93.56,13.08 91.67,13.08 91.35,13.4 82.27,13.4 81.3,12.42 68.91,12.42 66.62,14.72 64.28,14.72 63.78,15.22 54.42,15.22 52.31,17.33 46.82,17.33 46.31,17.83 40.78,17.83 37.64,20.97 37.64,28.17 36.88,28.93 36.88,30.68 35.44,32.12 35.44,34.06 34.66,34.84 34.66,36.5 33.3,37.86 33.3,44.66 33.6,44.96 33.6,49.23 v1(32.12,50.71)
  BOTTOM w0.102: PR7702.2 PR7709.1 200,31.22 199.72,31.5 199.31,31.5 199.06,31.25 199.06,30.66 199.16,30.56 PR7721.2 199.52,30.25 199.64,30.13 199.64,29.11 199.01,28.48 v1(199.01,28.48)
CHG_ACOK_R: length 5.9
  BOTTOM w0.102: PU7700.24 197.39,27.97 197.71,28.3 198.25,28.3 198.73,28.78 198.73,28.96 PR7721.1 198.83,29.39 198.7,29.52 198.7,30.69 197.89,31.5 v2(197.89,31.73)
CHG_AMON_R: length 2.9
  BOTTOM w0.102: PR7724.1 200.05,26.54 v2(199.12,25.62) 199,25.49 PU7700.29
CHG_BATGONE_R: length 5.6
  BOTTOM w0.102: v2(199.49,31.07) PR7726.2
  BOTTOM w0.229: PU7700.25 198.35,27.56
  BOTTOM w0.254: 198.35,27.56 198.35,27.66 198.58,27.89 199.11,27.89 199.49,28.28 199.49,28.53 200.28,29.31 PC7721.1 PR7726.2
CHG_BGATE_C: length 2
  BOTTOM w0.229: PU7700.32 198.39,24.29
  BOTTOM w0.254: 198.39,24.29 v2(198.9,23.79) PR7719.1
CHG_BGATE_R_C: length 66.1
  TOP w0.254: v1(160.12,21.82) 160.12,20.79 165.92,14.99 197.31,14.99 200.86,18.54 v2(200.86,20.3) 200.86,23.15 v1(201.24,23.52)
  IN3 w0.254: v1(149.2,23.7) 149.2,24.82 149.98,25.6 154.74,25.6 159.13,21.21 159.76,21.21 160.12,21.57 v1(160.12,21.82)
  BOTTOM w0.254: PR7719.2 200.97,23.79 v1(201.24,23.52)
CHG_BOOT1_D: length 2.9
  BOTTOM w0.229: 192.76,25.76 193,25.76 193,25.76 193.39,25.76 193.39,25.76 193.41,25.76 193.61,25.55 193.62,25.55 193.68,25.49 PU7700.12
  BOTTOM w0.432: 192.76,25.76 192.63,25.63 PC7711.2 192.12,25.63 191.92,25.43 v2(191.41,25.43)
CHG_BOOT2_D: length 6.7
  TOP w0.635: v1(194.59,21.61) v2(195.41,22.43)
  IN1 w0.508: v1(197.1,22.35) 195.35,22.35 194.6,21.61 v1(194.59,21.61)
  BOTTOM w0.229: PU7700.4 196.19,23.35 197.1,22.43 v1(197.1,22.35)
  BOTTOM w0.635: PC7715.2 194.57,21.61 v1(194.59,21.61)
CHG_COMP: length 3.1
  BOTTOM w0.229: PU7700.28 198.48,25.89
  BOTTOM w0.254: 198.48,25.89 198.91,26.32 199.19,26.32 199.78,26.91 199.78,26.99 PR7717.1
CHG_COMP_R: length 3.3
  BOTTOM w0.102: PC7723.1 201.93,26.27 202.54,25.66 v2(202.54,25.07)
  BOTTOM w0.254: PR7717.2 201.71,27.47 201.93,27.26 PC7723.1
CHG_CSIN: length 7.2
  BOTTOM w0.203: 189.28,28.73 189.28,27.1 v2(189.48,26.9) 189.48,26.8 190.25,26.04 PC7710.1 191.18,26.04 191.62,26.47 PC7708.1 192.91,26.47 193.09,26.29 PU7700.14
CHG_CSIP: length 8
  BOTTOM w0.203: PU7700.15 193.37,26.69 v2(193.23,26.84) 192.74,27.33 PC7708.2 191.64,27.33 191.25,26.94 PC7709.1 190.31,26.94 189.79,27.46 189.79,29.9 189.69,30 PR7703.2
CHG_CSON: length 68.2
  TOP w0.254: v1(199.44,22.79) 200.05,22.18 200.05,18.34 197.19,15.47 166.12,15.47 160.66,20.94 160.66,26.27 v2(160.08,26.84) 157.15,29.77 v1(152.37,29.77)
  BOTTOM w0.102: PR7714.1 152.27,29.77 v1(152.37,29.77)
  BOTTOM w0.229: PC7718.2 198.5,23 198.5,23.17 198.04,23.62 197.56,23.62 PU7700.1
  BOTTOM w0.254: PC7719.1 199.52,22.71 v1(199.44,22.79) PC7718.2
CHG_CSON_R: length 4
  BOTTOM w0.102: v2(149.81,27.36) PR7714.2 151.55,26.53 PJP7703.1
CHG_CSOP: length 65.4
  TOP w0.254: v1(153.09,30.25) 157.58,30.25 v2(158.96,28.88) 161.06,26.77 161.06,21.08 166.24,15.9 197.03,15.9 199.44,18.32 v1(199.44,21.9)
  BOTTOM w0.229: PC7718.1 198.65,21.92 198.15,22.43 198.15,23.01 197.88,23.28 197.22,23.28 196.99,23.51 PU7700.2
  BOTTOM w0.254: PC7717.1 199.65,21.9 v1(199.44,21.9) 199.42,21.92 PC7718.1 ; PR7713.1 v1(153.09,30.25)
CHG_CSOP_R: length 5.3
  BOTTOM w0.102: PR7713.2 152.2,28.81 v2(152.15,28.86) 152.1,28.91 151.79,28.91 151.46,28.58 151.46,27.19 151.71,26.94 PJP7702.1
CHG_DCIN_B: length 6
  BOTTOM w0.229: 193.93,28.53 194.59,27.87 PU7700.17
  BOTTOM w0.254: 193.93,28.53 193.69,28.53
  BOTTOM w0.508: v2(194.08,32.18) 193.65,32.18 193.17,31.7 PR7708.1 193.17,30.33 193.39,30.1 PC7712.1 193.39,28.82 193.69,28.53
CHG_DCIN_R: length 8.5
  TOP w0.432: v1(191.83,30.47) 191.83,30.62 192.33,31.12 v2(193.17,31.12) 196.53,31.12 197.06,31.65 PD7700.2 PD7701.2
  BOTTOM w0.508: PR7708.2 191.8,30.51 v1(191.83,30.47)
CHG_LG1_D: length 14.5
  TOP w0.635: v4(182.25,30.18) 182.25,29.29 183.21,28.32 v2(187.4,28.32) 188.53,28.32 192.8,24.06 193.45,24.06 v1(193.59,23.92)
CHG_LG2_D: length 34.9
  TOP w0.635: v1(194.77,23.14) 194.59,23.14 192.91,21.47 189.08,21.47 188.43,22.11 181.2,22.11 179.25,20.17 v2(168.83,20.17) 167.05,20.17 165.63,21.58 165.63,23.8 v4(165.33,24.11)
  BOTTOM w0.229: v1(194.77,23.14) 194.99,23.36 PU7700.7
CHG_OTGEN_R: length 2.1
  TOP w0.102: PT7701.1 196.47,27.74 v1(195.99,28.22)
  BOTTOM w0.229: v1(195.99,28.22) 195.79,28.02 PU7700.20
CHG_OTGPG_R: length 1.2
  BOTTOM w0.229: PU7700.26 198.26,26.69
  BOTTOM w0.254: 198.26,26.69 PT7702.1
CHG_PH1_D: length 19.1
  TOP w0.635: v4(177.47,26.8) v2(179.68,26.8) 185.6,26.8 189.29,23.1 191.56,23.1 v4(191.94,23.48)
  BOTTOM w0.229: PU7700.10 193.3,24.69 192.99,24.39
  BOTTOM w0.508: v4(191.94,23.48) 191.94,23.95 192.25,24.26 PC7711.1 192.86,24.26 192.99,24.39
CHG_PH2_D: length 44.7
  TOP w0.635: v4(165.38,26.37) 164.49,25.48 164.49,21.11 v2(165.29,20.31) 166.58,19.02 179.73,19.02 181.57,20.87 187.92,20.87 189.54,19.26 195.8,19.26 196.61,20.07 196.61,20.64 v1(195.76,21.49)
  BOTTOM w0.229: 195.33,22.84 195.39,22.9 PU7700.6
  BOTTOM w0.508: 195.33,22.84 195.29,22.8 PC7715.1 195.29,21.96 v1(195.76,21.49)
CHG_PROCHOT#: length 2.1
  BOTTOM w0.102: PR7723.1 198.2,29.03 197.69,28.53 197.54,28.53 196.99,27.98 PU7700.23
CHG_PROG: length 4.2
  TOP w0.102: v2(198.9,27.55) v1(199.55,27.55)
  BOTTOM w0.229: PU7700.27 198.38,26.29
  BOTTOM w0.254: 198.38,26.29 198.81,26.72 199.08,26.72 199.43,27.07 199.43,27.42 v1(199.55,27.55) 199.55,27.72 199.88,28.04 199.89,28.04 PR7716.1
CHG_PSYS: length 3.7
  BOTTOM w0.254: PT7700.1 202.41,22.84 202.41,24.01 PR7725.2
CHG_PSYS_R: length 2.3
  BOTTOM w0.229: PU7700.30 199.39,25.09
  BOTTOM w0.254: 199.39,25.09 PR7725.1
CHG_SCL_R: length 1.8
  BOTTOM w0.102: PU7700.22 196.59,27.93 196.9,28.24 196.9,28.65 197.28,29.03 PR7722.1
CHG_SDA_R: length 1.5
  BOTTOM w0.102: PU7700.21 196.19,27.81 196.41,28.04 PR7720.1
CHG_SMBCLK: length 239.5
  TOP w0.102: v1(28.42,52.53) 28.69,52.8 29.32,52.8 29.67,53.14 34.31,53.14 34.44,53.01 v2(36.47,53.01) 37.82,53.01 37.95,52.89 R2318.2 37.87,52.56 37.8,52.56 37.26,52.02 37.26,49.48 38.02,48.72 38.02,46.79 R2317.2 37.47,45.8 37.7,45.57 U2300.9
  IN1 w0.097: v1(28.42,52.53) 28.42,51.35 30.11,49.67 30.11,44.9 32.59,42.42 32.59,40.82 33.29,40.12 33.29,29.25 34.83,27.71 35.75,27.71 39.44,24.02 39.44,23.58 43.85,19.18 45.44,19.18 48.92,15.71 56.02,15.71 57.3,14.43 57.89,14.43 59.26,13.05 59.62,13.05 60.38,12.3 67.97,12.3 70.43,9.83 74.64,9.83 76.14,11.33 80.42,11.33 82.57,13.47 91.7,13.47 92.61,14.38 93.11,14.38 94.51,15.78 104.9,15.78 105.4,15.28 114.22,15.28 117.15,12.36 117.15,11.49 117.72,10.92 122.26,10.92 125.11,13.78 126.35,13.78 130.74,9.38 150.99,9.38 152.2,10.59 161.65,10.59 v1(162.12,10.11)
  IN3 w0.127: v1(167.73,21.36) 167.73,20.88 168.07,20.54 179.43,20.54 188.02,29.12 196.13,29.12 196.95,29.94 v1(196.95,30.48)
  BOTTOM w0.102: v1(167.73,21.36) 167.73,20.81 166.16,19.24 166.16,14.47 162.12,10.44 v1(162.12,10.11) ; v1(196.95,30.48) 196.95,30.2 197.26,29.9 PR7722.2
CHG_SMBDAT: length 244.5
  TOP w0.102: v1(29.01,53.27) 29.36,53.62 38.25,53.62 39.42,52.45 v2(39.42,51.03) 40.03,50.42 40.03,49.97 39.94,49.88 39.52,49.46 39.05,49.46 R2319.2 38.73,48.65 38.99,48.39 38.99,47.2 R2316.2 38.51,45.14 38.1,44.73 U2300.8
  IN1 w0.097: v1(162.73,10.09) 162.73,10.42 162.09,11.06 152,11.06 150.79,9.86 147.14,9.86 146.09,10.91 141.61,10.91 140.83,10.14 130.99,10.14 126.64,14.48 124.82,14.48 122.02,11.69 118.82,11.69 114.51,15.99 107.3,15.99 104.79,18.5 102.48,18.5 102.21,18.23 102.21,17.05 101.7,16.54 92.68,16.54 92.05,15.9 92.05,14.82 91.55,14.32 89.28,14.32 88.56,15.04 88.21,15.04 87.13,13.95 82.37,13.95 80.22,11.81 75.94,11.81 74.48,10.34 70.64,10.34 68.15,12.83 60.55,12.83 59.84,13.54 59.45,13.54 57.93,15.06 57.34,15.06 56.22,16.18 49.11,16.18 45.59,19.71 43.99,19.71 41.58,22.12 41.58,24.34 37.73,28.2 35.02,28.2 33.77,29.45 33.77,40.32 33.07,41.02 33.07,42.62 30.59,45.1 30.59,49.87 29.01,51.44 v1(29.01,53.27)
  IN3 w0.127: v1(196.34,30.47) 196.34,30.05 195.92,29.63 187.72,29.63 179.13,21.05 168.65,21.05 v1(168.33,21.36)
  BOTTOM w0.102: v1(168.33,21.36) 168.33,20.74 166.64,19.04 166.64,13.99 v1(162.73,10.09) ; PR7720.2 196.42,29.9 196.42,30.23 196.34,30.3 196.34,30.47 v1(196.34,30.47)
CHG_UG1_D: length 13.7
  TOP w0.635: v1(193.24,25.24) 188.99,29.49 v2(184.99,29.49) 183.92,29.49 v4(183.26,30.15)
  BOTTOM w0.559: v4(183.26,30.15) 183.03,29.92 PR7718.1
CHG_UG1_R_D:
  vias: v2(184.18,26.39)
CHG_UG2_D: length 2.5
  BOTTOM w0.229: PU7700.5 195.79,23.04 v2(196.22,22.61)
  BOTTOM w0.508: PR7701.1 196.42,22.4 v2(196.22,22.61)
CHG_UG2_R_D: length 43.8
  TOP w0.635: v1(198.02,20.58) 198.02,19.41 196.18,17.57 166.42,17.57 163.03,20.95 v2(163.03,23.09) 163.03,23.74 162.23,24.54 v4(162.23,25)
  BOTTOM w0.508: v1(198.02,20.58) 197.79,20.81 PR7701.2
CHG_VBAT: length 2.1
  BOTTOM w0.229: PU7700.31 198.75,24.69 198.86,24.59
  BOTTOM w0.508: PR7715.1 199.69,24.71 199.57,24.59 198.86,24.59
CKEA0: length 44.1
  TOP w0.127: U6801.J3 195.78,98.96 v1(195.78,98.99) 194.38,98.99 193.23,97.84 193.23,97.66 193.38,97.5 193.38,97.32 193.2,97.14 193.03,97.14 192.87,97.3 192.69,97.3 192.46,97.06 192.46,92.01 190.77,90.32 v2(185.19,90.32) 184.94,90.32 184.8,90.19 184.47,90.19 184.35,90.32 184.35,90.71 184.22,90.84 183.97,90.84 183.84,90.71 183.84,90.32 183.71,90.19 183.34,90.19 183.21,90.32 183.21,90.4 183.08,90.53 182.53,90.53 180.66,92.41 180.66,92.67 180.98,92.99 180.98,93.32 180.22,94.07 180.04,94.07 179.97,94.14 173.46,94.14 173.3,93.98 173.3,93.7 173.43,93.58 173.58,93.58 173.71,93.45 173.71,92.28 173.46,92.03 173.1,92.03 172.95,92.18 172.95,92.51 172.84,92.61 171.43,92.61 170.82,92 169.4,92 169.3,91.9 168.37,91.9 167.87,92.4 v1(167.87,92.41)
  BOTTOM w0.102: U6000.K20 168.03,92.25 v1(167.87,92.41)
  BOTTOM w0.127: U6801.J3 195.78,98.96 v1(195.78,98.99)
CKEA1: length 50.9
  TOP w0.127: v1(171.65,88.06) 172.06,87.66 172.36,87.66 174.29,85.73 174.78,85.73 174.9,85.85 174.9,86.05 175.03,86.17 175.29,86.17 175.41,86.05 175.41,85.85 175.54,85.73 175.79,85.73 175.92,85.85 175.92,86.05 176.05,86.17 176.3,86.17 176.43,86.05 176.43,85.85 176.56,85.73 176.81,85.73 176.94,85.85 176.94,86.05 177.06,86.17 177.32,86.17 177.44,86.05 177.44,85.75 178.07,85.13 178.07,84.1 178.19,83.97 178.98,83.97 179.15,83.81 179.15,83.14 178.89,82.88 175.69,82.88 175.51,82.7 175.51,82.48 175.51,82.48 175.67,82.32 177.67,82.32 177.8,82.2 177.8,81.94 177.67,81.82 175.13,81.82 175.01,81.69 175.01,81.38 175.13,81.26 177.98,81.26 179.59,82.87 179.59,84.48 179.72,84.61 180,84.61 180.12,84.48 180.12,83.13 180.25,83 180.52,83 180.65,83.13 v2(180.65,84.48) 180.65,84.53 180.77,84.66 181.01,84.66 181.14,84.53 181.14,83.87 181.32,83.69 181.57,83.69 181.7,83.82 181.7,84.84 181.83,84.97 182.08,84.97 182.21,84.84 182.21,83.82 182.33,83.69 183.68,83.69 184.14,83.22 184.14,82.77 186.19,80.72 186.57,80.72 186.63,80.79 188.26,80.79 188.57,80.49 v1(188.57,80.03) 188.57,80 U6803.J3
  BOTTOM w0.102: U6000.J17 169.45,88.8 170.36,88.8 170.36,88.78 170.6,88.55 170.63,88.55 171.12,88.06 v1(171.65,88.06)
  BOTTOM w0.127: v1(188.57,80.03) 188.97,79.62 U6803.J3
CLK_PCIE_LAN_REQ#: length 124.9
  TOP w0.102: v1(159.23,12.22) 159.97,11.48 164.04,11.48 164.7,10.82 172.11,10.82 172.88,11.58 174.6,11.58 175.31,10.87 181.1,10.87 181.74,10.24 188.72,10.24 v1(190.14,11.66) 190.55,12.07 v2(190.73,12.07) ; R1010.2 105.56,31.14 105.74,31.32 v3(105.74,31.65) 105.56,31.65 105.33,31.88 105.33,32.84 108.18,35.69 v3(108.18,35.79)
  IN1 w0.097: v1(159.23,12.22) 159.28,12.27 159.28,12.9 159.03,13.15 150.65,13.15 149.48,11.97 147.88,11.97 147.42,12.42 138.51,12.42 137.02,13.91 130.04,13.91 126.04,17.91 123.29,17.91 123.16,17.78 120.75,17.78 120.35,18.19 116.88,18.19 111.47,23.6 111.47,25.48 111.91,25.92 111.91,26.85 110.03,28.73 109.36,28.73 108.86,29.24 107.87,29.24 105.74,31.36 v3(105.74,31.65)
  BOTTOM w0.102: v1(190.14,11.66) 189.36,12.45 186.97,12.45 186.74,12.68 186.74,16.66 186.49,16.92 186.49,20.44 186.78,20.73 190.57,20.73 190.82,20.47 CON5104.2 ; U0400.AT8 108.13,36.89 108.13,35.84 v3(108.18,35.79)
