# Allegro board 5n-armani13.a00.0828.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_ZQ2: length 3.5
  BOTTOM w0.102: U6802.J13 196.97,79.73 197.18,79.94 199.47,79.94 199.52,79.99 R6816.2
FBA_ZQ3: length 7.8
  TOP w0.102: v2(201.85,74.75) 200.99,74.75 199.95,75.8 R6818.2 199.95,76.02 199.72,76.25 199.72,77.5 198.02,79.2 197.37,79.2 U6803.J13
FCCM_A: length 37.5
  IN2 w0.254: v1(160.99,60.91) 163.35,60.91 165.56,58.7 170.97,58.7 171.53,58.14 174.6,58.14 175.11,58.65 178.92,58.65 179.04,58.52 179.04,52.45 179.27,52.22 179.27,48.62 178.56,47.91 178.56,46.44 178.28,46.15 177.77,46.15 177.55,46.38 v1(177.44,46.38)
  BOTTOM w0.229: PU7800.21 176.7,46.44 176.94,46.21 177.27,46.21 v1(177.44,46.38)
  BOTTOM w0.254: PR8015.1 159.41,62.18 159.54,62.05 160.73,62.05 160.99,61.8 v1(160.99,60.91)
FCCM_B: length 34.3
  TOP w0.102: v1(157.99,51.39) 158.06,51.46 v2(158.8,51.46)
  IN1 w0.254: v1(157.99,51.39) 159.39,51.39 160.02,52.02 161.34,52.02 161.52,51.84 163.22,51.84 163.86,52.48 167.03,52.48 167.11,52.56 169.7,52.56 170.28,53.14 175.11,53.14 177.01,51.23 177.39,51.23 177.5,51.34 v1(177.6,51.34)
  IN3 w0.254: v1(157.99,51.39) 157.99,50.04 158.45,49.58 158.45,48.41 159.89,46.97 159.89,45.57 159.66,45.34 159.66,44.81 158.93,44.07 v1(158.72,44.07)
  BOTTOM w0.229: PU7800.11 177.25,51.04 177.55,51.34 v1(177.6,51.34)
  BOTTOM w0.254: PR7917.1 158.6,43.46 158.72,43.59 v1(158.72,44.07) ; PR7919.1 158.5,52.22 157.99,51.72 v1(157.99,51.39)
FCCM_C: length 43.5
  IN1 w0.102: v1(145.49,31.8) 149.33,31.8 154,36.48 158.42,36.48 159.81,37.87 168.58,37.87 169.78,39.07 169.78,43.22 169.51,43.49 169.41,43.49 169.06,43.84 169.06,44.18 169.72,44.83 171.41,44.83 v1(172.13,45.54)
  BOTTOM w0.102: v1(145.49,31.8) 144.48,30.79 142.8,30.79 142.55,30.53 PR8013.1 v2(141.78,29.72) ; PU7800.29 173.5,46.33 172.72,45.54 v1(172.13,45.54)
FFS_I2C_SCL: length 86.1
  TOP w0.102: C3703.1 151.16,22.91 150.7,22.46 150.01,22.46 149.28,21.72 149.28,19.92 149.33,19.87 v1(149.33,19.33)
  TOP w0.254: C3703.1 151.97,22.13 152.55,22.13 152.67,22.24 U3701.1
  IN2 w0.102: v1(92.81,15.52) 93.5,16.21 110.29,16.21 110.5,15.99 117.89,15.99 119.35,17.45 122.33,17.45 122.73,17.86 123.9,17.86 v1(124.31,17.45) 124.71,17.05 133.1,17.05 134.14,18.09 137.01,18.09 137.9,18.98 148.97,18.98 v1(149.33,19.33)
  IN3 w0.102: v1(80.24,19.73) 80.24,19.14 82.49,16.89 90.25,16.89 91.29,15.85 92.48,15.85 v1(92.81,15.52)
  BOTTOM w0.102: R1907.1 v2(80.61,17.73) 80.82,17.94 80.82,18.48 80.24,19.06 v1(80.24,19.73) ; Q3701.1 123.2,18.69 R3710.2 124.31,17.58 v1(124.31,17.45)
FFS_I2C_SDA: length 71
  TOP w0.102: v1(150.44,19.33) 150.19,19.08 v2(150.19,18.7)
  TOP w0.254: U3701.4 153.14,19.79 152.63,19.28 C3702.1 150.5,19.28 v1(150.44,19.33)
  IN2 w0.102: v1(92.66,13.5) 92.66,13.98 94.66,15.98 110.19,15.98 110.5,15.67 117.9,15.67 119.45,17.22 122.42,17.22 122.65,17.45 v1(123.7,17.45) 124.33,16.82 133.22,16.82 134.26,17.86 137.11,17.86 138,18.75 149.86,18.75 v1(150.44,19.33)
  BOTTOM w0.102: Q3701.4 120.92,17.39 121.62,16.69 R3712.2 v1(123.7,17.45) ; v1(92.66,13.5) 92.48,13.68 R1908.1
FFS_INT1: length 48.1
  TOP w0.102: v2(150.98,26.88) 150.29,26.19 R3705.1 149.23,24.31 148.77,23.84 148.77,23.53 148.21,22.97 148.21,22.2 149,21.41 149,20.47 148.79,20.27 v1(148.79,19.76)
  IN1 w0.102: v1(148.79,19.76) 148.42,19.39 147.39,19.39 146.81,19.97 144.45,19.97 143.89,19.41 138.1,19.41 137.31,20.2 133.38,20.2 132.03,21.54 132.03,22.14 130.6,23.56 130.6,23.56 128.5,25.66 128.36,25.81 124.39,25.81 123.95,26.25 123.95,26.94 v1(123.24,27.65)
  BOTTOM w0.076: U0400.M3 121.41,33.56 121.5,32.98 121.55,32.87 121.56,32.78 121.68,32.66 121.68,31.8 121.92,31.56 122.67,31.56 123.26,30.97 123.26,30.89
  BOTTOM w0.102: 123.26,30.89 123.26,29.36 123.16,29.27 123.16,29.27 122.88,28.99 122.67,28.99 122.5,28.82 122.5,28.11 122.97,27.65 v1(123.24,27.65)
FFS_INT2: length 75.9
  TOP w0.102: R3704.1 152.9,25.2 152.77,25.07 152.77,24.42 151.99,23.65 151.99,23.32 v1(152.24,23.08)
  IN1 w0.102: v1(120.02,20.55) 120.02,19.94 121.26,18.7 122.12,18.7 122.43,19 126.79,19 131.4,14.39 137.25,14.39 138.48,13.16 143.85,13.16 143.93,13.24 147.47,13.24 v1(148.34,12.37)
  BOTTOM w0.076: U0400.AC2 115.4,33.45 115.4,33.24 115.43,33.11 115.43,32.95 115.38,32.78 115.38,31.99
  BOTTOM w0.102: v1(120.02,20.55) 118.64,20.55 118.29,20.91 118.29,21.36 118.39,21.47 118.39,22.1 118.67,22.38 118.67,23.4 119.02,23.75 119.02,24.7 118.94,24.79 118.94,25.82 118.43,26.33 118.43,26.93 117.66,27.7 116.88,27.7 116.56,28.02 116.56,28.7 116.36,28.91 116.36,29.31 116.23,29.44 116.23,29.44 115.71,29.96 115.71,31.66 115.38,31.99 ; Q3101.2 153.7,16.66 153.57,16.54 R3115.1 153.04,14.56 152.27,13.79 152.27,13.06 152.55,12.78 152.55,12.02 152.06,11.53 v2(149.96,11.53) 149.18,11.53 v1(148.34,12.37) 149.33,13.36 149.83,13.36 150.44,13.98 150.44,18.37 150.98,18.9 150.98,21.82 v1(152.24,23.08)
FFS_INT2_HDD: length 49.5
  IN2 w0.102: v1(112.45,13.67) 113.25,14.47 117.75,14.47 118.27,13.95 124.38,13.95 124.51,14.07 126.57,14.07 127.05,13.59 132.02,13.59 134.9,16.47 142.76,16.47 143.66,17.37 152.21,17.37 152.63,17.8 v1(152.63,18.16)
  BOTTOM w0.102: R3115.2 153.04,17.76 v1(152.63,18.16) 152.83,18.37 153.39,18.37 153.52,18.24 R3110.2 ; R3115.2 v2(152.07,17.4) ; R3115.2 153.62,17.4 153.71,17.31 Q3101.3 ; CON3101.9 113.18,14.22 112.63,13.67 v1(112.45,13.67)
FLIP#: length 50.5
  TOP w0.102: U5800.5 43.53,76.49 44.04,75.97 v1(44.04,75.69) 44.22,75.52 45.49,75.52 45.9,75.11 R5809.2 45.9,74.98 45.24,74.32 v2(45.24,74.07)
  IN1 w0.102: v1(15.37,77.24) 15.52,77.09 15.52,75.82 16.13,75.21 23.52,75.21 25.45,73.28 31.7,73.28 34.67,70.31 36.91,70.31 37.95,71.35 40.1,71.35 43.33,74.59 43.33,74.98 v1(44.04,75.69)
  BOTTOM w0.102: U5702.12 18.08,78.04 18.65,77.47 18.65,76.99 18.55,76.9 17.84,76.9 17.63,76.69 17.63,76.2 16.93,75.5 v2(16.38,75.5) 16.02,75.5 15.55,75.97 15.55,77.07 v1(15.37,77.24) 15.6,77.47 15.6,77.88 15.77,78.06 16.82,78.06 17.28,78.52 U5702.14
FPR_SCAN#: length 245.2
  TOP w0.102: U2300.42 25.98,38.7 25.56,39.12 v1(25.35,39.12)
  IN2 w0.102: v1(25.35,39.12) 25.78,39.12 26.04,38.86 26.04,37.59 25.58,37.14 25.35,37.14 24.28,36.07 24.28,32.25 23.95,31.92 23.95,23.18 24.09,23.05 24.55,22.58 26.14,22.58 27.31,21.41 27.31,20.07 35.59,11.79 37.56,11.79 37.99,11.36 47.36,11.36 50.31,8.41 53.8,8.41 55.75,6.45 58.65,6.45 59.34,7.14 60.79,7.14 61.35,6.58 71.85,6.58 72.66,7.39 93.6,7.39 95.99,9.78 97.35,9.78 97.36,9.78 97.94,10.37 103.18,10.37 103.21,10.39 104.4,11.58 105.42,11.58 106.06,12.22 108.85,12.22 109.42,11.64 114.79,11.64 115.7,12.55 123.67,12.55 124.12,12.1 132.49,12.1 135.48,15.09 143.36,15.09 144.27,16 154.87,16 155.96,14.91 197.03,14.91 198.35,13.59 201.16,13.59 207.9,20.33 207.9,40.32 205.54,42.67 v1(205.13,42.67)
  BOTTOM w0.102: v1(25.35,39.12) 25.83,39.6 v2(25.91,39.6) ; v1(205.13,42.67) 205.21,42.76 CON5103.40
GC6_FB_EN_MCP: length 6.7
  TOP w0.076: v3(109.3,35.84) 109.3,35.51 107.47,33.68 T1511.1
  BOTTOM w0.076: U0400.AP7 v3(109.3,35.84)
GC6_THM_DIS#: length 20.5
  TOP w0.102: R2348.2 42.93,54.5 42.84,54.58 v2(42.25,54.58) v1(41.45,53.78) ; v1(33.2,48.87) 32.59,48.26 32.03,48.26 31.78,48.01 31.78,45.21 32.1,44.89 U2300.23
  IN3 w0.102: v1(41.45,53.78) 36.32,53.78 34.7,52.15 34.7,50.37 v1(33.2,48.87)
  BOTTOM w0.102: v2(33.91,48.36) 33.4,48.87 v1(33.2,48.87)
GPIO162: length 16.1
  TOP w0.102: R2339.2 v2(44.4,53.49) 44.4,53.32 v1(43.64,52.56) ; v1(43.69,41.89) 43.3,41.5 U2300.126
  IN2 w0.102: v1(43.64,52.56) 42.98,51.89 42.98,48.77 44.48,47.27 44.48,43.46 43.69,42.67 v1(43.69,41.89)
  BOTTOM w0.102: v1(43.69,41.89) v2(44.32,41.89)
GPU MAINPOWER_DISCH_G: length 81.1
  TOP w0.102: v1(206.4,101.75) 198.6,109.55 185.85,109.55 181.19,104.89 177.23,104.89 174.99,107.13 156.98,107.13 v2(156.63,106.77) 156.28,106.42 v1(156.28,106.02)
  BOTTOM w0.102: v1(206.4,101.75) 205.97,102.19 205.97,103.56 205.71,103.81 R7204.2 206.12,104.57 207.19,104.57 207.8,105.18 Q7204.3 207.8,106.23 207.92,106.35 208.61,106.35 208.73,106.48 Q7202.1 208.73,108.13 209.3,108.69 209.3,113.28 208.57,114.01 Q7200.1 Q7201.1 ; Q7203.1 158.52,108.07 158.14,107.7 158.14,106.91 157.25,106.02 v1(156.28,106.02)
GPU_BP0: length 5
  BOTTOM w0.102: U6000.U1 162.43,77.7 161.57,76.84 T6919.1 162.1,74.81 162.53,74.81 R6910.2
GPU_BP1: length 5.4
  BOTTOM w0.102: U6000.U3 162.43,78.48 162.97,77.95 T6918.1 163.53,74.65 163.88,74.65 164.02,74.51 R6911.2
GPU_CS: length 28.9
  TOP w0.102: T6946.1 176.81,68.68 v1(174.88,68.68)
  IN1 w0.102: v1(174.88,68.68) 174.35,68.68 172.67,70.36 172.67,72.61 171.36,73.92 169.77,73.92 169.27,74.42 162.96,74.42 161.21,76.17 161.21,77.5 v1(165.3,81.59)
  BOTTOM w0.102: U6000.N8 165.4,81.59 v1(165.3,81.59)
GPU_DBG_DATA0: length 12.6
  TOP w0.102: T6917.1 157.23,70.48 158.09,71.34 158.09,79.23 159.28,80.42 v1(159.28,81)
  BOTTOM w0.102: U6000.Y7 159.5,81.22 v1(159.28,81)
GPU_DBG_DATA1: length 15.4
  TOP w0.102: T6916.1 156.39,68.91 156.39,69.93 157.89,71.43 157.89,79.5 158.86,80.47 158.86,81.36 v1(159.17,81.68)
  BOTTOM w0.102: v1(159.17,81.68) 159.49,81.68 U6000.Y8
GPU_DBG_DATA2: length 10.6
  TOP w0.102: T6915.1 158.43,69.81 158.43,76.11 v1(158.74,76.42)
  BOTTOM w0.102: v1(158.74,76.42) 158.74,78.11 U6000.AB2
GPU_DBG_DATA3: length 6.1
  BOTTOM w0.102: U6000.AB4 157.4,79.22 157.2,79.02 157.2,77.4 155.55,75.75 T6914.1
GPU_DBG_DATA4: length 12.2
  TOP w0.102: T6913.1 157.48,72.72 157.48,79.67 158.45,80.63 158.45,81.38 v1(158.21,81.61)
  BOTTOM w0.102: U6000.AB7 158.24,81.61 v1(158.21,81.61)
GPU_DBG_DATA5: length 14.6
  TOP w0.102: v1(158.19,82.45) 158.65,81.99 158.65,80.55 157.68,79.58 157.68,71.55 T6912.1
  BOTTOM w0.102: U6000.AB8 158.2,82.45 v1(158.19,82.45)
GPU_DBG_DATA6: length 12.9
  TOP w0.102: v1(158.1,83.07) 157.71,82.67 157.71,81.31 157.61,81.21 157.61,80.37 157.35,80.11 157.35,79.83 157.28,79.75 157.28,74.5 T6911.1
  BOTTOM w0.102: v1(158.1,83.07) 158.1,83.07 158.38,83.07 U6000.AB9
GPU_DBG_DATA7: length 10.5
  TOP w0.102: T6910.1 153.21,76.28 153.21,78.97 155.47,81.23 156.8,81.23 v1(157.21,81.64)
  BOTTOM w0.102: U6000.AC7 v1(157.21,81.64)
GPU_DBG_DATA8: length 10.9
  TOP w0.102: T6909.1 152.86,77.8 152.98,77.93 152.98,79.03 155.75,81.8 155.89,81.8 156.14,82.06 156.91,82.06 v1(157.25,82.4)
  BOTTOM w0.102: v1(157.25,82.4) 157.63,82.02 U6000.AC8
GPU_DBG_DATA9: length 9.4
  TOP w0.102: T6908.1 156.44,75.64 v1(156.44,80.8)
  BOTTOM w0.102: U6000.AD7 156.83,81.19 v1(156.44,80.8)
GPU_DBG_DATA10: length 12.7
  TOP w0.102: T6907.1 148.46,77.45 149.15,78.13 151.03,78.13 152.12,79.23 152.12,79.86 v1(156.34,84.08)
  BOTTOM w0.102: v1(156.34,84.08) 157.18,84.08 157.63,83.62 U6000.AC10
GPU_DBG_DATA11: length 10.2
  TOP w0.102: v1(156.43,82.46) 156.26,82.46 155.81,82.01 155.55,82.01 152.73,79.19 152.73,78.97 150.06,76.3 T6906.1
  BOTTOM w0.102: v1(156.43,82.46) 156.48,82.46 U6000.AD9
GPU_DBG_DATA12: length 12.1
  TOP w0.102: T6929.1 147.8,75.87 148.49,76.56 148.75,76.56 149.08,76.89 149.43,76.89 149.91,77.37 150.84,77.37 152.53,79.06 152.53,79.38 155.56,82.41 v1(155.64,82.41)
  BOTTOM w0.102: v1(155.64,82.41) 155.64,82.41 U6000.AE8
GPU_DBG_DATA13: length 1.5
  TOP w0.102: v1(159.89,84.91) 160.33,85.35 T6928.1
  BOTTOM w0.102: U6000.Y11 159.93,84.91 v1(159.89,84.91)
GPU_DBG_DATA14: length 12.7
  TOP w0.102: v1(156.43,83.22) 155.87,83.22 152.32,79.67 152.32,79.14 151.11,77.93 150.18,77.93 149.34,77.09 148.99,77.09 148.66,76.76 147.98,76.76 T6927.1
  BOTTOM w0.102: U6000.AE9 v1(156.43,83.22)
GPU_DBG_DATA15: length 5.3
  TOP w0.102: v1(166.24,82.4) 165.91,82.07 165.91,79.76 165.25,79.1 T6926.1
  BOTTOM w0.102: v1(166.24,82.4) 166.61,82.4 U6000.L9
GPU_DBG_DATA16: length 5.7
  TOP w0.102: T6925.1 165.41,79.58 165.71,79.89 165.71,81.81 v1(165.31,82.22)
  BOTTOM w0.102: v1(165.31,82.22) 165.83,82.74 U6000.N9
GPU_DIECRACKMON: length 4.9
  TOP w0.102: T6940.1 150.11,92.69 v1(151.74,94.31)
  BOTTOM w0.102: v1(151.74,94.31) 151.6,94.45 151.6,95.99 U6000.AM26
GPU_DISCHARGE: length 3.5
  BOTTOM w0.102: Q7204.1 208.75,103.07 208.75,102.02 208.44,101.71 R7205.2 207.19,101.71 v2(206.65,101.17)
GPU_EVENT_MCP#: length 7
  TOP w0.102: T1510.1 109.88,32.22 109.88,33.94 109.53,34.29 109.53,35 109.89,35.37 109.89,36.46 109.75,36.6 109.75,36.96 110.14,37.35 v3(110.14,37.64)
  BOTTOM w0.089: U0400.AN8 110.36,37.22 110.14,37.44 v3(110.14,37.64)
GPU_GPIO6: length 1.5
  TOP w0.102: v1(162.94,82.5) 162.92,82.48 T6941.1
  BOTTOM w0.102: U6000.T8 162.95,82.5 v1(162.94,82.5)
GPU_GPIO11: length 16
  BOTTOM w0.102: T6931.1 171.88,68.81 171.45,68.81 170.94,69.32 170.94,70 171.25,70.31 171.25,71.02 170.94,71.33 169.88,71.33 169.34,71.86 169.34,72.19 168.88,72.65 168.88,73.28 167.89,74.27 167.89,74.51 166.37,76.04 166.37,77.45 166.22,77.6 166.22,78.14 166.21,78.15 166.08,78.36 166.08,78.81 165.96,78.92 165.96,80.08 U6000.N6
GPU_GPIO12: length 14
  BOTTOM w0.102: T6930.1 170.43,68.96 170.43,69.77 169.87,70.34 169.18,70.34 168.71,70.81 168.71,71.94 168.28,72.37 168.28,72.98 167.26,73.99 167.26,74.28 165.76,75.78 165.76,77.14 165.3,77.6 165.3,78.14 165.36,78.33 165.36,78.62 165.3,78.72 165.3,79.29 U6000.N5
GPU_GPIO13: length 9.3
  BOTTOM w0.102: T6932.1 169.11,71.38 169.11,72.11 168.68,72.54 168.68,73.18 167.67,74.2 167.67,74.45 166.17,75.95 166.17,77.36 166.01,77.52 166.01,78.08 165.87,78.3 165.87,78.58 U6000.N3
GPU_GPIO15: length 10.5
  BOTTOM w0.102: T6933.1 169.83,70.72 169.73,70.61 169.19,70.61 168.91,70.9 168.91,72.03 168.48,72.46 168.48,73.08 167.46,74.09 167.46,74.37 165.96,75.87 165.96,77.28 165.63,77.61 U6000.N1
GPU_GPIO16: length 8.7
  BOTTOM w0.102: T6934.1 169.29,73.03 169.29,73.48 168.37,74.4 168.37,74.61 166.78,76.2 166.78,77.62 166.7,77.7 166.7,78.14 166.76,78.27 166.76,78.89 U6000.M4
GPU_GPIO20: length 4.9
  TOP w0.102: T6935.1 162.26,80.34 v1(161.77,79.86)
  BOTTOM w0.102: U6000.P8 164.24,81.62 164.24,81.21 163.58,80.55 163.58,80.3 163.27,79.99 161.9,79.99 v1(161.77,79.86)
GPU_GPIO21: length 13.8
  BOTTOM w0.102: U6000.P7 164.63,80.76 164.5,80.63 164.5,78.28 164.56,78.18 164.56,77.67 164.53,77.64 164.53,76.72 167.06,74.2 167.06,73.89 168.05,72.9 168.05,72.29 168.5,71.83 168.5,70.73 169.38,69.85 T6936.1
GPU_GPIO29: length 11.6
  TOP w0.102: v1(150.72,80.04) 150.72,79.56 150.14,78.97 149.49,78.97 147.04,76.52 147.04,75.77 146.86,75.59 T6937.1
  BOTTOM w0.102: v1(150.72,80.04) 151.49,80.8 151.49,82.83 151.92,83.26 152.48,83.26 U6000.AK10
GPU_GPIO30: length 10.9
  TOP w0.102: v1(150.72,80.65) 150.32,80.24 150.32,79.44 150.06,79.17 145.34,79.17 T6938.1
  BOTTOM w0.102: U6000.AM10 151.89,83.62 151.26,82.98 151.26,81.18 v1(150.72,80.65)
GPU_I2C_SCL: length 11
  BOTTOM w0.102: T6921.1 167.46,70.36 167.46,70.97 167.13,71.3 166.24,71.3 166.12,71.43 166.12,71.97 165.38,72.7 165.14,72.7 164.9,72.94 164.9,73.56 R6912.2 165.39,75.29 163.86,76.82 163.86,77.84 U6000.R1
GPU_I2C_SDA: length 12.7
  BOTTOM w0.102: U6000.R3 164.26,78.59 164.26,78.28 164.36,78.12 164.36,77.78 164.33,77.75 164.33,76.64 165.84,75.13 165.84,74.45 166.24,74.05 R6913.2 166.7,74.05 166.83,73.92 166.83,73.82 167.79,72.85 167.79,72.24 168.3,71.73 168.3,70.61 168.43,70.49 168.43,69.45 T6920.1
GPU_OVERT: length 51.8
  IN1 w0.102: v1(147.24,78.31) 148.03,79.1 149.8,79.1 154.12,74.78 159.41,74.78 162.41,71.78 163.7,71.78 164.29,72.37 165.1,72.37 167.16,70.31 167.95,70.31 168.1,70.16 171.45,70.16 172.39,69.22 173.1,69.22 173.48,68.84 v1(173.61,68.84)
  BOTTOM w0.102: v1(147.24,78.31) 146.84,77.9 146.84,77.57 146.66,77.4 R6914.1 146.2,76.63 146.02,76.46 146.02,75.33 Q6901.1 ; U6000.M2 166.43,77.68 166.57,77.53 166.57,76.12 168.1,74.6 168.1,74.37 169.09,73.38 169.09,72.75 169.6,72.24 169.6,71.91 169.98,71.53 171.07,71.53 171.45,71.15 171.45,70.21 171.17,69.93 171.17,69.4 171.55,69.01 173.43,69.01 v1(173.61,68.84) 173.89,68.56 v2(173.89,68.15)
GPU_OVERT_R: length 235.5
  TOP w0.102: v1(16.82,16.97) 14.96,18.82 R2403.1 ; v2(48.67,96.26) v1(48.03,96.26)
  IN1 w0.102: v1(48.03,96.26) 49.1,97.32 49.1,97.64 51.1,99.65 52.02,99.65 56.46,104.09 57.07,104.09 60.68,107.7 72.14,107.7 72.92,108.49 81.07,108.49 83.07,110.49 92.81,110.49 95.92,107.37 100.22,107.37 102.51,105.08 v1(102.51,103.66) ; v1(25.41,59.26) 24.4,58.24 22.67,58.24 20.48,56.06 20.48,50.64 20.96,50.17 20.96,48.73 18.66,46.43 18.18,46.43 17.84,46.09 17.84,44.65 20.57,41.91 20.57,38.59 21.18,37.98 21.18,36.11 22.33,34.97 22.33,22.48 v1(16.82,16.97)
  IN2 w0.102: v1(48.03,96.26) 48.03,91.67 47.19,90.84 47.19,86.61 45.76,85.18 45.76,76.23 45.03,75.51 45.03,73.96 43.54,72.46 v1(43.54,71.83)
  IN3 w0.102: v1(102.51,103.66) 102.73,103.87 107.33,103.87 108.03,103.18 113.65,103.18 114.81,102.02 114.81,101.99 115.96,100.84 116.87,100.84 116.99,100.71 116.99,96.07 118.97,94.08 118.97,92.65 121.16,90.46 126,90.46 127.15,89.31 127.15,88.64 138.2,77.6 146.41,77.6 148.05,75.96 v1(148.54,75.96)
  BOTTOM w0.102: v1(25.41,59.26) 28.98,62.83 28.98,67.72 30.28,69.01 33.73,69.01 35.84,71.12 39.48,71.12 39.86,71.5 43.21,71.5 v1(43.54,71.83) ; Q6901.3 147.88,75.36 148.47,75.96 v1(148.54,75.96)
GPU_PWR_LEVEL: length 396.5
  TOP w0.102: v1(199.52,68.25) 199.92,67.85 200.3,67.85 200.89,68.43 206.7,68.43 v1(207.54,67.59) ; v1(154.81,75.49) 154.81,74.98 153.44,73.61 R6938.2 152.76,73.08 155.19,70.64 156.11,70.64 v1(157,71.53) ; v1(22.56,44.45) 24.23,46.13 v2(24.99,46.13) 26.29,46.13 27.13,45.29 27.13,44.22 30.35,41 34.65,41 37.19,38.46 37.62,38.46 37.92,38.76 37.92,41.05 37.3,41.67 37.3,42.97 37.3,42.98 U2300.10
  IN1 w0.102: v1(164.03,83.8) 163.4,83.16 163.4,80.91 159.43,76.94 156.85,76.94 155.4,75.49 v1(154.81,75.49) ; v1(199.52,68.25) 195.94,68.25 195.81,68.13 195.81,62.89 194.98,62.07 191.68,62.07 191.36,61.75 177.53,61.75 175.88,60.1 166.7,60.1 164.68,62.12 164.68,63.2 162.81,65.07 162.81,65.76 161.82,66.75 161.82,67.85 158.14,71.53 v1(157,71.53)
  IN2 w0.102: v1(213.21,35.84) 210.39,33.02 210.39,21.85 201.24,12.7 179.72,12.7 179.36,13.06 172.54,13.06 172.4,12.93 165.89,12.93 164.82,14 153.97,14 152.33,12.36 152.33,11.8 151.99,11.46 150.09,11.46 149.73,11.1 147.49,11.1 147.28,11.31 143.33,11.31 143,11.64 138.71,11.64 137.69,10.62 123.67,10.62 123.16,11.13 119.77,11.13 118.95,10.32 108.88,10.32 108.3,10.9 107.43,10.9 106.77,10.24 104.94,10.24 102.59,7.89 102.59,6.17 100.36,3.94 96.96,3.94 94.19,6.71 72.95,6.71 72.14,5.9 65.75,5.9 64.96,5.11 61.3,5.11 60.49,5.92 59.41,5.92 59.03,5.54 55.37,5.54 53.42,7.5 49.4,7.5 48.89,8 48.21,8 47.09,9.12 35.18,9.12 22.3,22 22.3,37.9 21.51,38.68 21.51,39.98 21.36,40.13 21.36,43.26 v1(22.56,44.45)
  IN3 w0.102: v1(207.54,67.59) 207.06,67.11 207.06,54.37 207.37,53.59 208.94,52.01 208.94,38.41 211.51,35.84 v1(213.21,35.84)
  BOTTOM w0.102: v1(164.03,83.8) 164.03,83.62 163.43,83.02 U6000.T9
GPU_SCLK: length 17.8
  TOP w0.102: v1(164.94,76.93) 164.94,75.7 169.15,71.48 175.91,71.48 T6945.1
  BOTTOM w0.102: v1(164.94,76.93) 164.83,77.03 U6000.P2
GPU_SI: length 17.8
  TOP w0.102: T6943.1 177.44,71.69 169.74,71.69 165.35,76.08 v1(165.35,76.48)
  BOTTOM w0.102: U6000.P4 165.1,78.95 165.1,78.65 165.16,78.56 165.16,78.36 165.1,78.18 165.1,77.52 165.35,77.26 v1(165.35,76.48)
GPU_SO: length 2.1
  TOP w0.102: v1(164.07,83.06) 163.5,82.49 T6944.1
  BOTTOM w0.102: v1(164.07,83.06) U6000.P10
GPU_TCK: length 6.7
  BOTTOM w0.102: U6000.L3 166.9,78.09 166.9,77.78 166.98,77.7 166.98,76.29 168.58,74.69 168.58,74.55 T6902.1
GPU_TDI: length 12.9
  BOTTOM w0.102: U6000.L5 167.56,79.29 167.56,78.71 167.5,78.58 167.5,78.28 167.56,78.13 167.56,77.77 167.39,77.6 167.39,76.46 168.98,74.86 168.98,74.78 169.52,74.25 169.88,74.25 170.74,73.38 170.74,73.03 173.23,70.54 T6901.1
GPU_TDO: length 5.6
  BOTTOM w0.102: T6904.1 169.22,74.91 167.59,76.54 167.59,77.51 167.76,77.69 167.76,78.18 167.7,78.32 167.7,78.53 167.79,78.72 167.79,78.98 U6000.K4
GPU_TESTEN: length 31.1
  TOP w0.102: R6936.2 168.1,79.71 168.1,80.39 v1(167.67,80.83)
  IN1 w0.102: v1(167.67,80.83) 167.67,82.4 166.23,83.84 165.13,83.84 164.52,83.22 164.52,81.43 159.92,76.84 159.92,75.42 159.77,75.27 159.77,74.71 162.49,71.99 163.55,71.99 164.14,72.57 165.2,72.57 167.06,70.72 v1(167.87,70.72)
  BOTTOM w0.102: v2(167.23,72.75) 167.49,72.49 R6943.2 167.49,71.71 167.87,71.33 v1(167.87,70.72) ; v1(167.67,80.83) 167.67,80.85 U6000.K7
GPU_THERMAL_INT#: length 6.4
  BOTTOM w0.102: U6000.R6 163.32,79.71 163.17,79.71 162.69,79.23 162.37,79.23 161.96,78.81 161.96,78.17 160.27,76.48 T6948.1
GPU_THM_SMBCLK: length 228.4
  TOP w0.102: U2300.12 36.5,43.08 36.27,42.85 v1(36.27,42.8) ; v1(53.85,99.6) 53.85,99.04 54.25,98.63 54.25,97.46 v2(53.21,96.42) 51.18,94.39 v1(51.18,93.6)
  IN1 w0.097: v1(28.04,38.51) 28.04,38.86 22.99,43.91 22.99,46.81 21.77,48.03 21.06,48.03 18.95,45.93 v1(18.25,45.93) ; v1(53.85,99.6) 53.85,100.77 56.59,103.51 57.76,103.51 61.47,107.22 72.39,107.22 73.1,107.93 81.19,107.93 83.27,110.01 92.61,110.01 95.73,106.89 100.02,106.89 101.91,105.01 101.91,103.56 102.44,103.02 v1(102.49,103.02)
  IN3 w0.127: v1(36.27,42.8) 36.27,46.18 35.54,46.91 35.54,50.52 35.29,50.76 35.29,50.76 35.23,50.83 35.23,51.99 36.32,53.08 41.34,53.08 42.42,54.15 42.42,56.3 43.88,57.76 43.88,65.61 48.63,70.36 48.63,91.5 50.72,93.6 v1(51.18,93.6) ; v1(148.73,75.35) 147.95,75.35 146.2,77.09 138,77.09 126.64,88.45 126.64,88.92 125.59,89.97 120.96,89.97 118.47,92.46 118.47,93.88 117.42,94.92 115.82,94.92 112.05,98.69 111.03,98.69 109.32,100.4 109.32,100.42 106.72,103.02 v1(102.49,103.02)
  BOTTOM w0.102: v1(28.04,38.51) 29.67,36.88 v2(29.85,36.88) 30.75,36.88 32.58,38.71 32.58,39.78 35.6,42.8 v1(36.27,42.8) ; R1910.2 17.91,44.25 18.25,44.59 Q1900.6 v1(18.25,45.93) ; v1(148.73,75.35) 149.51,76.13 149.99,76.13 150.34,76.48 150.34,78.29 148.72,79.91 148.72,80.5 148.23,80.98 148.23,83.11 147.9,83.44 147.5,83.44 147.29,83.64 147.29,83.82 147.16,83.96 Q6900.6
GPU_THM_SMBCLK_R: length 27.9
  TOP w0.102: v1(161.65,80.98) 160.83,80.98 R6934.2 ; v1(145.03,83.83) 144.51,83.83 143.03,82.35 v2(142.47,82.35)
  IN1 w0.102: v1(161.65,80.98) 157.96,77.29 156.41,77.29 155.8,76.69 152.56,76.69 148.06,81.19 148.06,82.31 146.27,84.1 145.3,84.1 v1(145.03,83.83)
  BOTTOM w0.102: Q6900.1 144.91,83.96 v1(145.03,83.83) ; v1(161.65,80.98) 161.99,80.98 U6000.U7
GPU_THM_SMBDAT: length 234.3
  TOP w0.102: v1(51.87,93.65) 51.87,94.39 v2(54.79,97.31) 54.81,97.34 54.81,98.89 v1(54.39,99.32) ; v1(36.9,42.8) U2300.11
  IN1 w0.097: v1(54.39,99.32) 54.39,100.64 56.79,103.03 57.96,103.03 61.67,106.74 72.63,106.74 73.3,107.42 81.36,107.42 83.47,109.53 92.41,109.53 95.53,106.41 99.81,106.41 101.42,104.8 101.42,103.36 102.24,102.54 102.25,102.54 102.43,102.36 v1(102.49,102.36) ; v1(28.17,35.13) 28.55,35.51 28.55,36.11 27.08,37.58 27.08,38.53 22.15,43.46 22.15,46.16 v1(21.31,46.99)
  IN3 w0.127: v1(149.33,75.22) 148.94,74.84 147.69,74.84 145.95,76.58 137.79,76.58 126.14,88.24 126.14,88.71 125.41,89.44 119.18,89.44 117.42,91.19 117.42,92.56 117.91,93.04 117.91,93.7 117.22,94.39 115.64,94.39 111.84,98.19 110.82,98.19 108.71,100.3 108.71,100.32 106.66,102.36 v1(102.49,102.36) ; v1(51.87,93.65) 51.26,93.05 50.89,93.05 49.14,91.29 49.14,70.15 44.39,65.4 44.39,57.55 42.93,56.09 42.93,53.52 41.91,52.5 37.14,52.5 36.36,51.73 36.36,50 36.05,49.69 36.05,47.12 36.9,46.27 v1(36.9,42.8)
  BOTTOM w0.102: Q6900.3 144.8,85.26 145.2,85.67 147.79,85.67 149.48,83.98 149.48,79.89 150.83,78.54 150.83,76.28 150.19,75.64 149.74,75.64 v1(149.33,75.22) ; v1(36.9,42.8) 36.41,42.32 35.8,42.32 33.06,39.58 33.06,37.97 30.23,35.13 v1(28.17,35.13) ; v1(21.31,46.99) 20.83,47.47 Q1900.3 19.55,48.2 19.69,48.34 R1909.2
GPU_THM_SMBDAT_R: length 28.1
  TOP w0.102: v1(162.79,81.54) 162.69,81.43 161.85,81.43 R6935.2
  IN1 w0.102: v1(162.79,81.54) 161.63,81.54 157.59,77.5 156.31,77.5 155.7,76.89 152.64,76.89 148.29,81.24 148.29,82.39 v1(145.41,85.26)
  BOTTOM w0.102: v1(145.41,85.26) Q6900.4 147.58,85.26 v2(147.83,85.02) ; U6000.U8 162.71,81.54 v1(162.79,81.54)
GPU_TMS: length 10.4
  BOTTOM w0.102: T6903.1 171.83,71.65 170.54,72.94 170.54,73.28 169.77,74.04 169.43,74.04 168.78,74.7 168.78,74.78 167.18,76.37 167.18,77.68 167.23,77.73 U6000.L1
GPU_TREST#: length 1.6
  TOP w0.102: T6900.1 167.61,79.96 v1(167.69,79.96)
  BOTTOM w0.102: v1(167.69,79.96) 167.24,80.42 U6000.L6
GPU_WAKE#_R: length 23.3
  TOP w0.102: v2(143.79,80.88) 143.23,81.43 142.19,81.43 R6937.2 142.01,81.61 142.01,82.55 142.27,82.81 142.27,83.38 149.25,90.36 149.25,91.01 149.54,91.3 v1(150.29,91.3)
  BOTTOM w0.102: v1(150.29,91.3) 150.73,91.3 152.45,93.02 152.45,93.45 152.81,93.8 152.81,94.26 152.45,94.62 152.45,95.05 152.83,95.43 152.83,95.79 153.23,96.18 U6000.AJ27
H_CPU_SVIDALERT#: length 7.3
  BOTTOM w0.076: 129.18,68.57 127.6,68.57 127.46,68.71 127.14,68.71 126.87,68.44 U0400.B63
  BOTTOM w0.102: 129.18,68.57 129.37,68.57 131.53,66.41 v2(131.71,66.41) 132.48,65.64 R0603.1
H_CPU_SVIDCLK: length 6.9
  BOTTOM w0.076: U0400.A63 127.5,68.44 127.55,68.39 128.87,68.39
  BOTTOM w0.102: R0604.2 132.48,64.66 131.35,65.79 131.35,66.09 129.04,68.39 128.87,68.39
H_CPU_SVIDDAT: length 8
  BOTTOM w0.076: 128.7,68.76 127.65,68.76 127.53,68.87 127.07,68.87 126.91,68.71 126.26,68.71 126.15,68.76 125.92,68.76 U0400.D64
  BOTTOM w0.102: 128.7,68.76 129.45,68.76 130.42,67.78 130.94,67.78 132.23,66.49 R0605.2
H_PECI: length 2.1
  TOP w0.102: R2300.1 v2(40.03,26.93) 40.03,27.31 40.1,27.37 U2300.94
HDA_BCLK_R: length 8
  BOTTOM w0.076: U0400.AY22 105.74,44.87 105.31,44.43 104.04,44.43 103.45,43.84 102.79,43.84 102.59,43.64 102.57,43.64
  BOTTOM w0.102: 102.57,43.64 102.35,43.42 100.83,43.42 v2(100.61,43.64) 100.43,43.82 R1014.1
HDA_RST#: length 103.7
  TOP w0.102: v1(17.45,41.71) 18.83,41.71 19.57,42.45 v2(22.2,42.45) 22.89,41.76 22.89,41.35 23.27,40.97 25.36,40.97 v1(25.57,40.76)
  IN1 w0.102: v1(87.71,25.58) 86.74,24.62 86.74,24.28 86.4,23.94 86.4,23.21 84.78,21.59 81.77,21.59 80.47,20.3 79.81,20.3 79.56,20.05 77.58,20.05 76.05,18.52 70.41,18.52 69.87,17.97 59.45,17.97 58.24,19.18 55.12,19.18 54.66,19.63 52.5,19.63 43.97,28.16 43.97,29.05 42.44,30.57 42.44,31.49 41.78,32.15 41.78,38.08 40.94,38.92 38.9,38.92 38.13,39.7 38.13,40.03 35.81,42.35 v1(35.81,45.07)
  BOTTOM w0.102: D3807.2 19.04,39.62 17.45,41.22 17.45,41.71 v1(17.45,41.71) ; R1016.2 90.88,22.33 88.72,24.49 88.72,25.3 88.44,25.58 v1(87.71,25.58) ; v1(35.81,45.07) 35.34,44.6 32.84,44.6 28.96,40.72 25.61,40.72 v1(25.57,40.76)
HDA_RST#_R: length 39.1
  BOTTOM w0.076: U0400.AW22 106.62,44.47 106.59,44.43 106.59,44.17 106.41,44 105,44 104.9,44.1 104.2,44.1 103.61,43.51 103,43.51 102.84,43.36
  BOTTOM w0.102: 102.84,43.36 102.49,43 100.2,43 100.1,43.11 95.94,43.11 87.12,34.29 87.12,29.57 v2(88.49,28.2) 88.49,25.89 88.95,25.43 88.95,24.61 90.7,22.86 91.39,22.86 91.75,22.51 R1016.1
HDA_SDI1_DSP: length 2.6
  TOP w0.102: T1002.1 107.14,44.99 v3(107.19,45.04)
  BOTTOM w0.076: v3(107.19,45.04) 107.04,45.19 106.48,45.19 106.29,45 U0400.AY21
HDA_SDO_R: length 8.2
  BOTTOM w0.076: 101.83,44.43 102.26,44.43 102.44,44.6 102.97,44.6 103.13,44.76 104.57,44.76 U0400.BB22
  BOTTOM w0.102: 101.83,44.43 101.78,44.43 101.75,44.4 101.75,44.4 101.57,44.22 101.13,44.22 101.07,44.29 100.44,44.29 99.75,44.99 v2(99.52,44.99) 99.26,44.99 99.01,45.24 99.01,45.7 98.88,45.82 R1012.2 98.3,45.82 98.17,45.7 R1015.1
HDA_SYNC_R: length 7.3
  BOTTOM w0.076: 103.28,44.15 103.51,44.15 103.96,44.6 105.05,44.6 U0400.BA22
  BOTTOM w0.102: R1013.1 98.76,44.68 99.09,44.35 99.29,44.35 99.54,44.1 100.99,44.1 101.09,44 v2(102.31,44) 102.46,44.15 103.28,44.15
HDD_DET#: length 3.6
  BOTTOM w0.102: T1100.1 122.57,30.26 121.34,31.49 121.34,32.5 U0400.M1
HDD_DEVSLP: length 4.4
  BOTTOM w0.076: U0400.J1 122.46,32.54 123.67,31.32 123.67,30.89
  BOTTOM w0.102: 123.67,30.89 123.67,29.49 123.91,29.25 R1407.1
HDD_EN_PCH: length 44
  IN3 w0.102: v1(125.48,21.21) 125.29,21.4 124.23,21.4 123.04,20.21 123.04,18.79 117.84,13.59 114.38,13.59 113.8,13.01 112.13,13.01 111.88,13.26 111.06,13.26 110.65,12.85 v1(108.33,12.85)
  BOTTOM w0.076: U0400.J4 122.78,34.18 122.78,33.69 122.83,33.64 122.89,33.48 122.89,33.24 122.85,33.14 122.85,32.92 122.89,32.83 122.89,32.64 124.08,31.45 124.08,30.89
  BOTTOM w0.102: 124.08,30.89 124.08,30.36 124.59,29.85 124.59,29.52 124.79,29.31 125.2,29.31 125.32,29.19 125.32,27.69 125.15,27.51 125.15,26.75 v2(125.37,26.52) 125.81,26.09 126.2,26.09 126.67,25.62 126.67,23.55 126.87,23.35 126.87,21.85 126.24,21.21 v1(125.48,21.21) ; U3100.4 105.77,11.56 106.28,11.05 107.99,11.05 108.33,11.39 v1(108.33,12.85)
HDMI_CLKN_SNK: length 6.1
  TOP w0.102: R2909.2 21.59,67.44 21.29,67.13 20.9,67.13 v5(20.65,67.39)
  BOTTOM w0.102: R2909.2 21.18,67.11 20.93,67.11 v5(20.65,67.39) 20.42,67.16 19.91,67.16 R2610.1 19.28,67.19 18.31,67.19 18.17,67.05 18.05,67.05 17.89,67.21 L2603.3
HDMI_CLKP_SNK: length 6.3
  TOP w0.102: v1(20.64,66.69) 20.88,66.93 21.34,66.93 21.59,66.68 R2910.2
  BOTTOM w0.102: v2(18.72,66.75) 18.72,66.98 ; 18.72,66.98 19.23,66.98 R2610.2 19.91,66.96 20.37,66.96 v1(20.64,66.69) 20.85,66.91 21.34,66.91 21.59,66.65 R2910.2 ; 18.72,66.98 18.4,66.98 18.26,66.84 18.1,66.84 17.91,66.66 L2603.2
HDMI_DATA0: length 151.4
  IN3 w0.127: v1(23.93,59.41) 24.28,59.77 24.48,59.77 24.74,60.03 24.74,63.82 27.2,66.28 27.2,67.42 30.43,70.65 30.43,72.21 32.84,74.63 32.84,77.45 33.4,78.01 33.4,80.22 33.73,80.55 35.3,80.55 37.8,83.05 41.84,83.05 47.57,88.78 47.57,91.17 52.16,95.76 54.46,95.76 54.92,95.3 56.88,95.3 58.38,93.81 64.57,93.81 64.72,93.66 64.72,92.87 65.72,91.87 66.8,91.87 67.06,92.14 68.05,93.12 70.8,93.12 72.24,91.67 75.67,91.67 76.06,91.28 100.52,91.28 100.99,91.75 107.54,91.75 110.8,88.5 111.76,88.5 118.05,82.2 119.97,82.2 123.39,78.77 123.39,76.35 124.37,75.38 124.37,71.88 124.49,71.76 124.49,70.95 124.32,70.79 124.32,68.54 123.93,68.15 122.98,67.2 122.98,64.87 123.34,64.51 124.37,64.51 124.46,64.42 124.46,64.29 v3(124.27,64.09)
  BOTTOM w0.102: U0400.F55 124.27,64.06 v3(124.27,64.09) ; 23.19,59.92 22.76,59.92 22.4,59.57 C2903.2 ; 23.19,59.92 v2(23.19,59.69) ; 23.19,59.92 23.44,59.92 23.67,59.69 23.67,59.54 23.8,59.41 v1(23.93,59.41)
HDMI_DATA0#: length 151.3
  IN3 w0.127: v3(124.96,64.1) 124.69,64.36 124.69,64.51 124.47,64.73 123.44,64.73 123.21,64.96 123.21,67.1 124.55,68.44 124.55,70.69 124.71,70.86 124.71,71.86 124.6,71.97 124.6,75.47 123.62,76.45 123.62,78.87 120.07,82.43 118.15,82.43 111.85,88.72 110.89,88.72 107.64,91.98 100.89,91.98 100.42,91.51 76.15,91.51 75.76,91.9 72.34,91.9 70.89,93.35 67.95,93.35 66.83,92.23 66.71,92.1 65.81,92.1 64.95,92.97 64.95,93.75 64.67,94.04 58.47,94.04 56.98,95.53 55.02,95.53 54.56,95.99 52.07,95.99 47.35,91.27 47.35,88.88 41.74,83.28 37.71,83.28 35.2,80.77 33.64,80.77 33.17,80.31 33.17,78.1 32.61,77.54 32.61,74.72 30.2,72.31 30.2,70.74 26.98,67.52 26.98,66.38 24.51,63.91 24.51,60.12 24.38,60 24.13,60 v5(24.02,60.11)
  BOTTOM w0.102: C2902.2 22.65,60.41 22.94,60.12 23.53,60.12 23.68,59.97 23.88,59.97 v5(24.02,60.11) ; U0400.E55 v3(124.96,64.1)
HDMI_DATA1: length 147.1
  IN3 w0.127: v3(124.24,66.04) 124.31,66.11 124.31,67.03 124.99,67.72 124.99,68.2 125.5,68.71 125.5,69.5 125.15,69.86 125.15,71.55 125.4,71.81 125.4,75.36 124.59,76.18 124.59,78.57 120.3,82.86 118.33,82.86 111.95,89.23 111,89.23 107.8,92.43 104.07,92.43 103.67,92.83 100.96,92.83 100.07,91.94 76.33,91.94 75.9,92.37 72.67,92.37 72.48,92.37 71.07,93.78 67.41,93.78 66.72,94.47 58.65,94.47 56.93,96.19 55.23,96.19 54.79,96.62 52.09,96.62 46.91,91.44 46.91,89.39 44.75,87.23 43.84,87.23 41.53,84.91 40.68,84.91 39.88,84.11 37.88,84.11 36.6,82.83 35.77,82.83 35.39,83.21 34.54,83.21 32.64,81.31 32.64,78.44 31.52,77.32 31.52,74.3 28.46,71.24 28.46,69.74 27.69,68.96 27.2,68.96 26.44,68.21 26.44,67.29 25.37,66.22 25.37,65.39 23.98,63.99 23.98,62.73 23.72,62.47 23.6,62.47 v5(23.22,62.08)
  BOTTOM w0.102: C2906.2 22.38,62.1 22.63,62.36 22.81,62.36 23.09,62.08 v5(23.22,62.08) ; U0400.F58 124.11,65.54 124.24,65.67 v3(124.24,66.04)
HDMI_DATA1#: length 147.2
  IN3 w0.127: v1(23.19,62.77) 23.26,62.7 23.62,62.7 23.75,62.82 23.75,64.09 25.15,65.48 25.15,66.31 26.21,67.38 26.21,68.3 27.1,69.19 27.59,69.19 28.23,69.83 28.23,71.34 31.29,74.4 31.29,77.41 32.41,78.53 32.41,81.41 34.44,83.44 35.48,83.44 35.87,83.06 36.51,83.06 37.79,84.34 39.79,84.34 40.59,85.14 41.43,85.14 43.75,87.45 44.65,87.45 46.69,89.49 46.69,91.54 52,96.85 54.89,96.85 55.32,96.42 57.02,96.42 58.75,94.7 66.82,94.7 67.51,94.01 71.16,94.01 72.57,92.6 76,92.6 76.43,92.17 99.98,92.17 100.87,93.06 103.77,93.06 104.17,92.66 107.89,92.66 111.09,89.46 112.05,89.46 118.42,83.09 120.4,83.09 124.82,78.67 124.82,76.27 125.63,75.45 125.63,71.72 125.37,71.46 125.37,69.95 125.73,69.6 125.73,68.61 125.22,68.11 125.22,67.63 124.54,66.94 124.54,66.34 v3(124.83,66.04)
  BOTTOM w0.102: v1(23.19,62.77) 23.15,62.77 22.94,62.56 22.69,62.56 C2900.2 ; v3(124.83,66.04) 124.57,65.78 U0400.E58
HDMI_DATA2: length 154.8
  IN3 w0.127: v5(23.04,64.39) 23.04,64.47 23.57,65 23.57,69.44 24.05,69.92 28.26,74.13 28.26,78.38 30.35,80.47 30.35,83.85 31.59,85.09 33.22,85.09 33.66,84.66 34.59,84.66 35.54,85.61 39.21,85.61 51.72,98.12 62.06,98.12 64.39,95.79 66.91,95.79 67.27,95.79 67.96,95.1 71.62,95.1 72.71,94.01 81.18,94.01 81.74,93.45 94.46,93.45 94.84,93.83 99.5,93.83 99.84,94.17 103.85,94.17 104.27,94.59 105.46,94.59 105.94,94.11 109.31,94.11 109.7,93.71 109.7,92.97 110.62,92.05 111.4,92.05 111.76,91.7 111.76,91.29 118.75,84.31 120.97,84.31 126.06,79.21 126.06,76.57 126.72,75.91 126.72,71.08 127.15,70.65 127.15,68.25 127,68.1 127,67.33 126.21,66.54 126.21,64.65 125.25,63.68 124.13,63.68 v3(123.64,63.19)
  BOTTOM w0.102: C2907.2 21.59,64.37 21.84,64.62 22.81,64.62 v5(23.04,64.39) ; v3(123.64,63.19) 123.44,62.99 123.44,62.97 U0400.G53
HDMI_DATA2#: length 155
  IN3 w0.127: v3(124.2,63.19) 124.46,63.45 125.34,63.45 126.44,64.55 126.44,66.45 127.23,67.24 127.23,68 127.38,68.15 127.38,70.74 126.95,71.17 126.95,76 126.29,76.67 126.29,79.31 121.06,84.53 118.84,84.53 111.99,91.39 111.99,91.79 111.5,92.28 110.71,92.28 109.93,93.06 109.93,93.81 109.4,94.34 106.04,94.34 105.56,94.82 104.18,94.82 103.76,94.4 99.75,94.4 99.41,94.06 94.75,94.06 94.36,93.68 81.83,93.68 81.27,94.24 72.8,94.24 71.71,95.33 68.05,95.33 67.37,96.02 66.82,96.02 64.49,96.02 62.15,98.35 51.63,98.35 39.12,85.84 35.45,85.84 34.49,84.89 33.75,84.89 33.32,85.32 31.5,85.32 30.12,83.95 30.12,80.56 28.03,78.47 28.03,74.22 23.95,70.14 23.95,70.14 23.34,69.53 23.34,65.1 23.26,65.01 23.1,65.01 v1(23.04,65.08)
  BOTTOM w0.102: C2904.2 21.59,65.15 21.92,64.82 22.38,64.82 ; 22.38,64.82 v2(22.38,65.05) ; 22.38,64.82 22.89,64.82 23.04,64.98 v1(23.04,65.08) ; v3(124.2,63.19) 124.2,63.08 U0400.F53
HDMI_DATA3: length 147.4
  IN3 w0.127: v3(123.6,65.13) 124.11,65.64 124.99,65.64 125.4,66.05 125.4,66.8 126.18,67.58 126.18,68.44 126.49,68.75 126.49,70.37 126.06,70.8 126.06,75.63 125.3,76.4 125.3,78.89 120.55,83.64 118.48,83.64 112.21,89.91 111.25,89.91 108.07,93.09 104.4,93.09 103.98,93.51 100.11,93.51 99.72,93.12 99.31,93.12 98.91,92.71 97.59,92.71 97.26,93.04 95.05,93.04 94.73,92.73 76.48,92.73 75.86,93.35 72.44,93.35 71.34,94.44 67.69,94.44 67,95.13 59.8,95.13 57.92,97.01 55.56,97.01 55.23,97.34 51.87,97.34 39.41,84.88 36.07,84.88 35.17,83.97 33.36,83.97 33.13,84.2 31.72,84.2 31.09,83.58 31.09,80.2 30.48,79.59 30.48,74.2 25.73,69.45 25.73,67.59 25.15,67.01 24.51,67.01 v5(24.13,66.63)
  BOTTOM w0.102: v3(123.6,65.13) 123.6,64.96 U0400.G56 ; C2905.2 22.45,66.6 22.78,66.93 23.82,66.93 v5(24.13,66.63)
HDMI_DATA3#: length 147.6
  IN3 w0.127: v3(124.21,65.13) 124.21,65.31 124.31,65.41 125.08,65.41 125.63,65.96 125.63,66.71 126.41,67.48 126.41,68.35 126.72,68.66 126.72,70.46 126.29,70.89 126.29,75.73 125.53,76.49 125.53,78.98 120.64,83.87 118.58,83.87 112.3,90.14 111.35,90.14 108.17,93.32 104.5,93.32 104.08,93.74 100.02,93.74 99.63,93.35 99.22,93.35 98.81,92.94 97.68,92.94 97.35,93.27 94.95,93.27 94.64,92.96 76.57,92.96 75.95,93.58 72.53,93.58 71.44,94.67 67.78,94.67 67.09,95.36 59.89,95.36 58.01,97.23 55.65,97.23 55.32,97.56 51.78,97.56 39.32,85.11 35.97,85.11 35.07,84.2 33.45,84.2 33.22,84.43 31.62,84.43 30.86,83.67 30.86,80.29 30.25,79.68 30.25,74.29 25.5,69.54 25.5,67.69 25.05,67.24 24.23,67.24 v1(24.15,67.32)
  BOTTOM w0.102: v3(124.21,65.13) 124.21,64.91 U0400.F56 ; v1(24.15,67.32) 23.97,67.13 23.5,67.13 ; 23.5,67.13 22.83,67.13 C2901.2 ; 23.5,67.13 v2(23.5,67.36)
HDMI_HPD: length 181.9
  TOP w0.102: v1(122.73,21.64) 122.86,21.77 124.51,21.77 127.1,24.36 127.1,25.17 127.74,25.81 127.74,27.64 127.36,28.02 127.03,28.02 126.62,28.43 126.25,28.43 126.12,28.55 R0408.2 ; Q2901.4 30.09,69.84 30.1,69.85 R2913.1 30.1,70.77 29.87,71 29.87,71.76 v1(29.77,71.86)
  IN1 w0.102: v1(25.63,36.19) 25.63,35.99 27.15,34.47 28.12,34.47 28.52,34.06 28.52,33.33 27.36,32.16 27.36,26.2 27.76,25.79 27.76,20.43 38.6,9.6 45.19,9.6 46.26,10.67 50.57,10.67 51.29,11.38 52.49,11.38 54.11,9.76 55.45,9.76 55.73,9.48 58.39,9.48 59.64,8.23 62,8.23 v1(62.48,7.75)
  IN2 w0.102: v1(29.77,71.86) 29.77,71.05 27.99,69.27 27.61,69.27 26.21,67.87 26.21,65.41 25.01,64.2 25.01,56.33 25.73,55.6 25.73,42.29 26.72,41.3 26.72,37.28 v1(25.63,36.19)
  IN3 w0.102: v1(122.73,21.64) 122.73,19.01 117.54,13.82 114.33,13.82 113.72,13.21 112.22,13.21 111.96,13.46 110.97,13.46 110.64,13.13 108.84,13.13 108.71,13.26 105.26,13.26 103.74,11.74 96.67,11.74 95.47,10.53 90.91,10.53 90.13,9.76 84.68,9.76 84.08,9.15 71,9.15 69.03,7.18 63.06,7.18 v1(62.48,7.75)
  BOTTOM w0.102: v1(29.77,71.86) v2(30.25,72.34)
HDMI_HPD_SNK: length 34.2
  TOP w0.102: Q2901.3 30.09,67.25 v1(29.59,67.74) ; R2602.2 13.82,76.61 13.53,76.9 D2600.1 v1(13.06,76.2)
  IN1 w0.102: v1(13.06,76.2) 13.08,76.2 14.15,75.14 14.15,74.77 17.3,71.62 22.2,71.62 26.43,67.39 29.24,67.39 v1(29.59,67.74)
  IN2 w0.102: v1(13.31,71.15) 13.31,71.78 14.28,72.75 14.28,75.39 13.46,76.2 v1(13.06,76.2)
  BOTTOM w0.102: CON2600.19 11.12,70.9 11.41,71.19 12.41,71.19 12.67,70.92 13.08,70.92 v1(13.31,71.15) ; v1(29.59,67.74) v2(29.59,67.06)
HDMI_POWER: length 4.6
  TOP w0.762: CON2600.18 11.73,71.09 13.55,72.91 14.86,72.91
  vias: v2(15.62,71.63)
HDMI_SCLK_SNK: length 24.6
  TOP w0.102: v1(13.86,68.61) 14.15,68.61 14.28,68.48 R2912.2 14.7,68.5 14.7,69.19 14.71,69.21 D2900.1 13.94,69.88 v1(13.31,70.51) ; v1(24.44,65.39) 24.54,65.39 25.25,66.1 25.25,66.5 25.04,66.7 C2908.1 25.5,67.01 25.61,66.9 Q2900.6
  IN1 w0.097: v1(13.86,68.61) 14.04,68.43 16.36,68.43 16.82,68.89 20.93,68.89 v1(24.44,65.39)
  BOTTOM w0.102: v1(24.44,65.39) v2(24.44,64.75) ; v1(13.31,70.51) 13.13,70.69 12.58,70.69 12.31,70.96 11.5,70.96 10.87,70.33 10.87,69.59 CON2600.15
HDMI_SDATA_SNK: length 29.4
  TOP w0.102: Q2900.3 27.29,63.87 26.82,63.4 26.82,62.92 v1(26.54,62.64) 27.2,62.64 27.33,62.77 C2909.1 ; v1(13.9,67.56) 13.9,66.56 14.27,66.19 D2901.1 14.71,66.77 14.71,66.78 R2911.2 14.71,67.72 14.33,68.1 13.04,68.1 CON2600.16
  IN1 w0.097: v1(13.9,67.56) 16.58,67.56 17.48,68.46 20.73,68.46 v1(26.54,62.64)
  BOTTOM w0.102: v2(27.82,65.51) 26.54,64.23 v1(26.54,62.64)
HDMI_TMDS_CLK_N: length 4.7
  BOTTOM w0.102: L2603.4 15.71,67.21 15.46,66.96 15.21,66.96 15.1,67.07 U2600.1 U2600.10 13.67,67.07 13.58,66.98 12.16,66.98 CON2600.12
HDMI_TMDS_CLK_P: length 4.6
  BOTTOM w0.102: L2603.1 15.14,66.66 15.05,66.57 U2600.2 U2600.9 13.52,66.57 13.32,66.77 12.1,66.77 CON2600.10
HDMI_TMDS_DATA0_N: length 13.3
  TOP w0.102: v1(12.55,64.72) 12.93,64.34 12.93,62.65 12.07,61.79 11.42,61.79 11.07,62.14 11.07,65.29 10.85,65.51 10.57,65.51 CON2600.9
  BOTTOM w0.102: v1(12.55,64.72) 12.9,65.07 12.9,65.21 13.12,65.43 13.34,65.43 13.47,65.57 U2600.7 U2600.4 14.95,65.57 15.34,65.18 15.34,64.98 15.47,64.85 15.65,64.85 15.72,64.92 L2600.4
HDMI_TMDS_DATA0_P: length 13.3
  TOP w0.102: CON2600.7 10.59,65.31 10.77,65.31 10.87,65.2 10.87,62.06 11.34,61.59 12.16,61.59 13.13,62.56 13.13,64.32 v1(13.36,64.54)
  BOTTOM w0.102: 14.62,65.07 U2600.6 13.55,65.07 13.39,65.23 13.21,65.23 13.11,65.13 13.11,64.8 v1(13.36,64.54) ; 14.62,65.07 U2600.5 ; 14.62,65.07 14.71,65.15 15.08,65.15 15.14,65.09 15.14,64.89 15.51,64.52 15.67,64.52 15.82,64.37 L2600.1
HDMI_TMDS_DATA1_N: length 6.6
  BOTTOM w0.102: 12.85,63.3 12.85,63.65 12.47,64.04 12.1,64.04 CON2600.6 ; 12.85,63.3 12.85,62.31 13.07,62.09 13.25,62.09 13.4,62.24 U2601.5 U2601.6 15.04,62.24 15.14,62.34 15.14,62.46 15.28,62.6 15.58,62.6 15.79,62.81 L2601.4 ; 12.85,63.3 v2(13.08,63.3)
HDMI_TMDS_DATA1_P: length 6.6
  BOTTOM w0.102: L2601.1 15.69,62.26 15.56,62.4 15.43,62.4 15.34,62.31 15.34,62.1 15.12,61.88 15.01,61.88 14.88,61.74 U2601.7 U2601.4 13.44,61.74 13.3,61.89 12.99,61.89 12.65,62.22 12.65,63.57 12.39,63.83 12.16,63.83 CON2600.4
HDMI_TMDS_DATA2_N: length 7.1
  BOTTOM w0.102: CON2600.3 10.6,62.49 10.85,62.49 12.78,60.56 13.26,60.56 13.44,60.74 U2601.2 U2601.9 14.88,60.74 15.04,60.58 15.16,60.58 15.41,60.33 15.56,60.33 15.73,60.5 L2602.4
HDMI_TMDS_DATA2_P: length 7.1
  BOTTOM w0.102: CON2600.1 10.57,62.28 10.76,62.28 12.69,60.35 13.31,60.35 13.42,60.24 U2601.1 U2601.10 14.85,60.24 14.94,60.33 15.12,60.33 15.33,60.12 15.55,60.12 15.72,59.95 L2602.1
HDMI_TXN0_SNK: length 4.9
  TOP w0.102: v5(19.91,64.98) 20.07,64.82 20.45,64.82 20.73,65.1 R2903.2
  BOTTOM w0.102: C2904.1 20.73,65.15 20.41,64.84 20.05,64.84 v5(19.91,64.98) 19.75,64.81 19.12,64.81 R2607.1 18.52,64.75 18.06,64.75 17.89,64.92 L2600.3
HDMI_TXN1_SNK: length 6.2
  TOP w0.102: v1(20.66,62.57) 20.83,62.41 21.18,62.41 21.54,62.77 R2905.2
  BOTTOM w0.102: L2601.3 17.84,62.81 18.09,62.56 18.69,62.56 ; C2900.1 21.51,62.79 21.16,62.44 20.8,62.44 v1(20.66,62.57) 20.55,62.46 20.12,62.46 19.63,62.94 R2608.1 19.53,62.94 19.15,62.56 18.69,62.56 ; 18.69,62.56 v2(18.69,62.79)
HDMI_TXN2_SNK: length 6.2
  TOP w0.102: v1(20.7,60.35) 20.99,60.06 21.17,60.06 R2907.2
  BOTTOM w0.102: 18.75,60.07 18.54,60.07 18.29,60.33 18.05,60.33 17.87,60.5 L2602.3 ; 18.75,60.07 v2(18.75,60.3) ; 18.75,60.07 19.2,60.07 19.53,60.4 R2609.1 19.69,60.4 19.96,60.12 20.47,60.12 v1(20.7,60.35) 20.98,60.07 21.26,60.07 21.54,60.35 C2902.1
HDMI_TXP0_SNK: length 5.1
  TOP w0.102: v1(19.91,64.29) 20.19,64.57 20.55,64.57 20.73,64.39 R2904.2
  BOTTOM w0.102: C2907.1 20.73,64.37 20.46,64.63 20.26,64.63 v1(19.91,64.29) 19.6,64.61 19.24,64.61 R2607.2 18.52,64.54 18.06,64.54 17.89,64.37 L2600.2
HDMI_TXP1_SNK: length 5.8
  TOP w0.102: v5(20.68,61.88) 21.01,62.21 21.36,62.21 21.54,62.03 R2906.2
  BOTTOM w0.102: L2601.2 17.86,62.26 17.96,62.36 19.23,62.36 19.51,62.08 R2608.2 19.69,62.08 19.86,62.26 20.29,62.26 v5(20.68,61.88) 21.03,62.23 21.31,62.23 21.51,62.03 C2906.1
HDMI_TXP2_SNK: length 6
  TOP w0.102: v5(20.7,59.67) 20.88,59.84 21.31,59.84 21.54,59.62 R2908.2
  BOTTOM w0.102: L2602.2 17.89,59.95 18.06,60.12 18.2,60.12 18.46,59.87 19.15,59.87 19.48,59.54 R2609.2 19.66,59.54 20.04,59.92 20.45,59.92 v5(20.7,59.67) 20.91,59.87 21.21,59.87 21.54,59.54 C2903.1
HOST_DEBUG_TX: length 7.1
  TOP w0.102: v1(34.44,33.25) 33.81,32.62 33.81,30.25 33.99,30.08 34.3,30.08 34.9,29.48 U2300.81
  BOTTOM w0.102: T2304.1 33.25,33.25 v1(34.44,33.25)
HPOUT1_JD#: length 10.9
  BOTTOM w0.152: J3800.6 10.38,42.04 10.51,41.91 12.65,41.91 12.9,41.66 v2(12.9,38.31) 13.01,38.2 14.03,38.2 D3806.1 15.28,38.95 15.26,38.93 R3810.1
HPOUT_L: length 22.7
  TOP w0.381: v1(11.33,27.66) 11.33,28.35 11.07,28.6 11.07,39.02 v2(11.86,39.8) 11.86,40.16 13.06,41.35 v1(13.06,42.24)
  BOTTOM w0.229: 13.01,27.36 13.23,27.59 13.41,27.59 13.66,27.84 U3800.27
  BOTTOM w0.381: R3802.1 14.15,44.27 13.87,44 R3829.2 13.87,42.83 13.28,42.24 v1(13.06,42.24) ; 13.01,27.36 11.9,27.36 11.6,27.05 C3830.1 11.25,27.59 v1(11.33,27.66)
HPOUT_R: length 20.8
  TOP w0.381: v1(12.09,38.59) 11.9,38.39 v2(11.9,37.57) 11.9,36.37 11.9,36.37 11.9,28.49 11.9,28.49 11.9,26.91 v1(12.07,26.75)
  BOTTOM w0.229: 13.5,27.17 13.77,27.44 U3800.26
  BOTTOM w0.381: v1(12.09,38.59) 11.3,37.8 9.12,37.8 8.71,38.21 R3828.2 8.71,39.45 R3803.1 ; v1(12.07,26.75) 12.34,26.47 C3831.1 12.8,26.47 13.5,27.17
HW_ACAV_IN: length 9.7
  TOP w0.102: R2307.1 43.43,47.17 43.4,47.13 43.04,46.78 v1(42.71,46.44) ; v1(42.58,43.07) 41.75,43.07 41.45,42.78 41.45,42.45 41.6,42.3 U2300.128
  IN3 w0.102: v1(42.58,43.07) 42.57,43.07 42.95,43.45 42.95,46.2 v1(42.71,46.44)
  BOTTOM w0.102: v2(41.94,43.07) v1(42.58,43.07)
HW_ACAVIN_NB: length 50.2
  TOP w0.102: v1(37.29,86.3) 37.53,86.54 PR7614.2 ; U2300.24 31.7,44.89 v1(31.32,45.27)
  IN1 w0.102: v1(31.32,45.27) 31.67,45.62 31.67,51.99 29.46,54.21 29.46,58.95 28.86,59.54 28.86,64.08 v1(31.67,66.9)
  IN2 w0.102: v1(31.67,66.9) 31.67,68.75 32.94,70.02 32.94,72.09 35.16,74.3 35.16,80.89 36.65,82.39 36.65,83.22 37.49,84.06 37.49,86.1 v1(37.29,86.3)
  BOTTOM w0.102: v2(32.11,44.99) 31.83,45.27 v1(31.32,45.27) ; v1(31.67,66.9) v2(31.67,66.19)
I2C0_SCL_TCH_PAD: length 107.7
  IN1 w0.097: v1(55.33,14.42) 54.66,13.74 50.44,13.74 49.63,12.94 42.64,12.94 v1(40.87,14.71)
  IN3 w0.127: v3(117.75,35.92) 117.55,35.92 117.12,35.49 117.12,35.16 116.23,34.27 116.23,33.03 115.33,32.12 115.33,26.92 113.26,24.86 113.26,24.13 v1(113.21,24.08) 113.21,24.03 112.32,23.14 111.76,23.14 111.2,22.58 109.68,22.58 109.46,22.36 107.87,22.36 107.13,23.09 105.75,23.09 105.1,22.44 105.1,21.81 103.26,19.96 101.64,19.96 100.83,19.15 95.03,19.15 93,17.12 91.81,17.12 89.77,19.17 83.99,19.17 82.61,20.55 81.98,20.55 80.53,22 76.6,22 74.8,20.2 74.8,19.52 74.01,18.72 74.01,18.28 72.64,16.91 70.47,16.91 69.89,16.32 61.58,16.32 61.51,16.25 57.16,16.25 v1(55.33,14.42)
  BOTTOM w0.102: R1515.2 113.28,24.01 v1(113.21,24.08) ; U0400.U6 118.24,35.43 v3(117.75,35.92) ; Q5103.3 41.72,8.93 40.87,9.78 v2(40.87,10.75) v1(40.87,14.71)
I2C0_SDA_TCH_PAD: length 103.3
  TOP w0.102: v1(50.19,7.09) 50.19,11.81 53.21,14.84 53.21,15.27 v2(53.61,15.67) 54.05,15.67 54.67,15.05 v1(54.67,14.39)
  IN1 w0.097: v1(50.19,7.09) 50.17,7.11 v1(46.69,7.11)
  IN3 w0.127: v3(117.7,36.48) 117.35,36.48 116.54,35.66 116.54,35.29 115.72,34.48 115.72,33.24 114.82,32.33 114.82,28.77 114.2,28.15 114.2,26.51 112.71,25.02 112.71,24.28 v1(112.46,24.03) 112.28,23.85 111.73,23.85 110.97,23.09 109.47,23.09 109.25,22.87 108.08,22.87 107.34,23.6 105.54,23.6 104.57,22.63 104.57,22.17 103.12,20.72 101.67,20.72 100.81,19.85 94.06,19.85 92.8,18.59 92.8,17.87 92.56,17.63 92.02,17.63 89.98,19.67 84.2,19.67 82.82,21.06 82.19,21.06 80.74,22.51 76.58,22.51 76.58,22.51 76.39,22.51 73.34,19.46 73.34,18.33 72.43,17.41 66.13,17.41 65.54,16.83 63.93,16.83 63.65,17.11 56.84,17.11 54.67,14.94 v1(54.67,14.39)
  BOTTOM w0.102: v1(46.69,7.11) 46.17,7.63 Q5103.6 ; v1(112.46,24.03) 112.73,23.77 112.73,22.13 112.45,21.85 R1516.2 ; U0400.U7 117.86,36.48 v3(117.7,36.48)
I2C_SCL_TP_MOS: length 14.6
  TOP w0.102: v2(51.79,9.71) 52.02,9.71 v1(52.4,9.32) 52.42,9.32 D5101.1 53.79,10.14 54.13,9.81 54.13,9.25 53.59,8.71 C5128.1 R5104.2
  IN1 w0.097: v1(46.86,9.96) 51.77,9.96 v1(52.4,9.32)
  BOTTOM w0.102: v1(46.86,9.96) 46.86,9.32 46.47,8.93 Q5103.4 ; CON5100.6 52.73,9.66 v1(52.4,9.32)
I2C_SDA_TP_MOS: length 17.8
  TOP w0.102: C5127.1 R5103.2 51.74,8.71 50.83,9.63 D5100.1 51.57,10.14 52.32,10.89 v1(52.34,10.89) 52.34,11.57 v2(52.3,11.61)
  IN1 w0.097: v1(43.94,8.51) 44.42,8.51 46.35,10.44 51.89,10.44 v1(52.34,10.89)
  BOTTOM w0.102: Q5103.1 43.77,7.63 43.94,7.8 v1(43.94,8.51) ; CON5100.7 52.03,10.17 52.34,10.48 v1(52.34,10.89)
I2S1_SFRM: length 12.7
  TOP w0.102: v3(103.32,42.82) 102.93,43.21 97.6,43.21 95.69,41.3 T1003.1
  BOTTOM w0.076: v3(103.32,42.82) 103.46,42.95 103.77,42.95 104.24,43.42 104.47,43.42 104.54,43.41 105.64,43.41 U0400.AY20
I2S1_TXD: length 16
  BOTTOM w0.076: 102.77,41.68 103.43,41.68 103.76,42.01 105.21,42.01 105.37,42.18 106.12,42.18 106.32,42.38 106.32,43.42 U0400.AW20
  BOTTOM w0.102: T1004.1 96.8,39.12 97.43,39.12 98.53,40.21 100.3,40.21 101.76,41.68 102.77,41.68
I_ADP: length 6.9
  TOP w0.102: U2300.110 43.29,35.1 43.94,34.44 44.09,34.44 44.35,34.19 44.35,33.81 45.01,33.15 C2317.1 R2311.1 46.22,33.56 47.65,33.56 v2(48.01,33.2)
I_BATT: length 5.9
  TOP w0.102: R2305.1 46.84,36.02 v2(46.69,36.17) 46.56,36.3 46.56,36.67 46.3,36.93 45.97,36.93 45.87,37.04 45.14,37.04 C2321.1 44.22,36.58 43.91,36.88 43.59,36.88 43.4,36.7 U2300.114
IC_DELAY: length 2.1
  TOP w0.102: PC7603.1 35.59,88.6 v2(35.31,88.32) 35.31,88.04 35.74,87.6 PU7600.3
ICSP_CLK: length 7.1
  TOP w0.102: U2300.101 41.38,31.5 41,31.11 41,30.38 41.75,29.62 42.72,29.62 43.23,29.11 43.23,28.02 T2306.1
ICSP_CLR: length 1.9
  TOP w0.102: U2300.87 37.3,27.21 37.21,27.12 T2307.1
ICSP_DAT: length 5.3
  TOP w0.102: U2300.102 41.5,31.9 40.79,31.19 40.79,30.29 41.75,29.34 42.06,29.34 T2305.1
IMON_A_VCPU: length 4.1
  TOP w0.102: PC7825.2 v2(177.14,50.68)
  TOP w0.254: PR7825.1 PC7825.2 178.28,49.76 v1(178.31,49.8)
  BOTTOM w0.229: v1(178.31,49.8) 177.94,49.8 177.79,49.65 PU7800.14
IMON_B_VCPU: length 6.3
  TOP w0.102: PC7824.2 172.36,54.46 172.36,54.99 172.49,55.12 PR7824.2 ; PC7824.2 PR7856.2 171.86,52.7 v1(172.31,52.25) ; PC7824.2 v2(171.09,53.95)
  BOTTOM w0.102: v1(172.31,52.25) 172.71,51.85 173.3,51.85 173.5,51.64 PU7800.2
IMON_C_VCPU: length 5.3
  BOTTOM w0.102: 178.08,45.04 PR7849.2 178.69,45.04 179.02,44.71 v2(179.02,43.54)
  BOTTOM w0.229: PU7800.23 175.9,46.3 177.17,45.04 PC7835.2 178.08,45.04
INT1: length 5.1
  TOP w0.254: v2(151.16,25.15) R3705.2 151.16,23.83 151.71,23.27 151.71,22.92 151.74,22.89 151.74,22.89 152.04,22.58 152.43,22.58 152.73,22.89 153.39,22.89 153.65,22.63 U3701.12
INT2: length 3
  TOP w0.254: U3701.11 154.15,22.71 153.47,23.4 v2(152.96,23.4) 152.96,24.06 R3704.2
INTRUDER#: length 22.9
  IN2 w0.109: v1(109.59,25.95) 110.01,26.38 110.01,27.1 109.91,27.21 109.91,30.58 109.7,30.79 109.7,33.05 111.28,34.62 111.76,34.62 111.96,34.83 111.96,39.78 111.71,40.03 111.28,40.03 111,40.31 111,40.62 110.79,40.82 110.36,40.82 110.08,41.1 110.08,41.3 v3(110.08,41.3)
  BOTTOM w0.076: U0400.AP16 110.08,41.42 110.08,41.3 v3(110.08,41.3)
  BOTTOM w0.102: R1206.2 109.7,24.63 109.18,25.15 109.18,25.55 v1(109.59,25.95) 108.89,26.65 v2(108.89,27.18)
IR_CAM_DET#: length 17
  TOP w0.102: T1509.1 120.4,22.53 v1(120.4,21.67)
  IN3 w0.102: v1(120.4,21.67) 120.4,21.92 122.53,24.06 122.53,25.01 122,25.55 v1(122,26.51)
  BOTTOM w0.076: 119.72,30.89 119.72,31.88 120.24,32.41 120.24,32.84 120.2,32.94 120.2,33.14 120.24,33.23 120.24,33.49 120.2,33.6 120.2,34.04 119.81,34.43 U0400.P4
  BOTTOM w0.102: 119.72,30.89 119.72,29.97 120.46,29.23 120.46,28.77 120.54,28.69 120.54,27.62 120.54,27.61 120.54,27.32 120.73,27.13 121.23,27.13 121.86,26.51 v1(122,26.51)
ISH_I2C0_SCL: length 24.3
  BOTTOM w0.076: U0400.N3 120.7,34.1 120.7,33.89 120.74,33.76 120.74,33.58 120.7,33.5 120.7,33.25 120.74,33.11 120.74,32.93 120.7,32.84 120.7,32.41 120.99,32.12 120.99,31.1 121.21,30.89
  BOTTOM w0.102: 121.21,30.89 121.89,30.21 121.89,29.38 121.89,29.37 121.89,27.86 122.43,27.32 122.43,26.91 122.97,26.37 123.54,26.37 124.3,25.62 126.1,25.62 126.24,25.48 126.24,25.3 126.24,25.3 126.24,23.66 125.9,23.32 125.12,23.32 124.82,23.01 124.52,23.01 R3711.2 124.89,22.29 124.89,21.64 124.46,21.21 v2(124.1,21.21) 123.77,21.21 122.48,19.92 122.48,19.38 122.35,19.26 121.86,19.26 121.29,18.69 Q3701.6
