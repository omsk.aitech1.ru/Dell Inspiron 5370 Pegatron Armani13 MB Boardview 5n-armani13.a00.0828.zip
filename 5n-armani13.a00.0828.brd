# Allegro board 5n-armani13.a00.0828.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
RTCRST_ON: length 123.3
  TOP w0.102: v1(31.64,41.7) 31.12,42.22 29.64,42.22 28.9,42.96 U2300.31
  IN3 w0.102: v1(31.64,41.7) 32.28,41.05 32.28,35.82 33.68,34.42 33.68,32.79 35.56,30.91 35.56,29.52 39.54,25.54 41.65,25.54 44.76,22.43 45.99,22.43 48.28,20.14 50.01,20.14 52.9,17.26 52.9,15.01 52.82,14.93 52.82,13.97 53.57,13.22 57.07,13.22 58.46,14.61 72.63,14.61 75.9,17.87 75.9,18.25 78.24,20.59 78.95,20.59 79.67,19.87 79.67,18.43 81.54,16.56 90.22,16.56 91.16,15.62 91.41,15.62 91.99,15.05 93.23,15.05 93.73,15.55 93.73,16.07 94.74,17.08 101.36,17.08 102.24,17.96 102.24,18.26 102.68,18.71 105.24,18.71 105.89,19.36 107.69,19.36 v1(108,19.05)
  BOTTOM w0.102: v2(31.56,42.67) 31.55,42.67 31.55,41.79 v1(31.64,41.7) ; Q1000.1 108.42,21.32 107.32,22.43 107.32,23.5 107.14,23.68 R1019.1 106.83,22.63 106.62,22.42 106.62,21.9 107.44,21.07 107.44,20.45 108,19.89 v1(108,19.05) 108,18.27 105.83,16.09 104.91,16.09 R2425.2
RUNPWROK: length 82.6
  TOP w0.102: v1(71.65,16.49) 70.76,15.6 70.76,12.83 70.1,12.17 70.1,10.98 70.28,10.8 70.89,10.8 71.02,10.67 71.02,9.83 v2(70.61,9.43) 70.18,8.99 70.18,8.66 69.95,8.44 69.95,7.75 69.82,7.62 R1805.2 ; v1(36.22,37.49) 35.89,37.82 35.66,37.82 35.53,37.95 30.35,37.95 28.96,36.55 27.97,36.55 27.71,36.3 U2300.48
  IN1 w0.102: v1(36.22,37.49) 35.2,36.48 35.2,35.26 36.73,33.73 37.76,33.73 39.04,32.45 39.04,31.68 42.31,28.4 42.31,27.56 43.27,26.61 43.27,26.03 43.76,25.53 44.4,25.53 46.74,23.19 46.74,20.81 49.53,18.01 57.66,18.01 60.28,15.39 70.56,15.39 v1(71.65,16.49) 72.14,16.97 75.84,16.97 76.18,17.3 76.48,17.3 77.52,18.34 80.15,18.34 v1(80.24,18.44)
  BOTTOM w0.102: U1800.2 79.71,19.31 80.24,18.77 v1(80.24,18.44)
RX1N_P1: length 13
  TOP w0.102: v1(10.52,85.98) 10.67,85.83 10.67,85.78 11,85.45 11.1,85.45 11.28,85.27 11.74,84.81 U5700.2 U5700.9 13.81,84.81 13.95,84.94 15.37,84.94 15.41,84.9 15.42,84.9 16.33,84.9 16.63,85.2 L5702.4
  IN1 w0.097: v1(10.52,85.98) 10.52,85.74 9.5,84.73 8.02,84.73 7.69,85.06 5.92,85.06 CON5700.B10
RX1N_P1_MUX: length 6.7
  TOP w0.102: U5703.31 24.86,84.09 22.89,84.09 22.27,84.71 19.69,84.71 19.2,85.2 L5702.3
RX1P_P1: length 12.8
  TOP w0.102: L5702.1 16.61,85.75 16.16,85.31 15.58,85.31 15.54,85.35 13.78,85.35 13.64,85.21 13.29,85.21 13.2,85.31 U5700.10 U5700.1 11.82,85.31 11.22,85.91 v1(11.13,85.91)
  IN1 w0.097: CON5700.B11 5.9,84.71 7.54,84.71 7.88,84.38 9.65,84.38 11.13,85.85 v1(11.13,85.91)
RX1P_P1_MUX: length 6.8
  TOP w0.102: U5703.30 23.06,84.5 22.44,85.12 19.85,85.12 19.22,85.75 L5702.2
RX2N_P1: length 17.9
  TOP w0.102: L5703.1 16.23,79.02 15.67,79.38 14.12,79.38 13.54,79.96 13.54,80.01 13.28,80.27 U5701.2 U5701.9 11.45,80.27 11,80.72 11,82.99 9.96,84.03 9.96,84.86 10.11,85.02 10.11,87.63 v1(10.29,87.81)
  BOTTOM w0.102: CON5700.A10 7.98,88.75 8.26,89.03 8.61,89.03 9.07,88.57 9.85,87.79 9.85,87.51 9.98,87.38 10.21,87.38 10.29,87.46 v1(10.29,87.81)
RX2N_P1_MUX: length 7.4
  TOP w0.102: L5703.2 18.75,79.02 18.8,78.97 20.25,78.97 20.94,79.66 22.16,79.66 23.72,80.6 24.01,80.6 24.31,80.9 U5703.39
RX2P_P1: length 17.9
  TOP w0.102: L5703.4 16.33,78.47 15.55,78.97 13.95,78.97 13.15,79.77 U5701.1 U5701.10 11.41,79.77 11.32,79.87 11.28,79.87 10.59,80.56 10.59,82.83 9.55,83.87 9.55,85.03 9.7,85.18 9.7,88.14 v1(9.89,88.33)
  BOTTOM w0.102: v1(9.89,88.33) 8.78,89.44 8.08,89.44 7.89,89.25 CON5700.A11
RX2P_P1_MUX: length 7.5
  TOP w0.102: L5703.3 18.75,78.47 18.85,78.56 20.42,78.56 21.11,79.25 22.27,79.25 23.83,80.19 24.18,80.19 24.48,80.49 24.86,80.49 U5703.40
SATA0_RXN_HDD: length 56.6
  IN3 w0.127: v3(124.19,43.1) 124.19,43.23 124.7,43.74 125.25,43.74 125.73,43.26 125.73,42.87 127.25,41.35 129.16,41.35 129.81,40.7 130.62,40.7 131.12,40.2 131.12,38.88 130.71,38.48 130.71,35.71 132.28,34.13 132.28,31.85 133.96,30.18 133.96,29.56 134.29,29.23 134.29,27.31 135.53,26.06 135.53,21.54 134.59,20.6 134.04,20.6 132.51,19.08 132.51,15.32 134.65,13.19 134.65,12.4 134.77,12.27 v1(134.8,12.27)
  BOTTOM w0.102: v3(124.19,43.1) 123.92,43.37 U0400.F20 ; 123.29,12.04 122.68,12.04 122.42,12.3 C3122.1 ; 123.29,12.04 v2(123.29,12.27) ; 123.29,12.04 124.92,12.04 125.29,11.67 125.53,11.43 131.56,11.43 133.13,13.01 134.35,13.01 134.54,12.81 134.54,12.52 v1(134.8,12.27)
SATA0_RXN_HDD_C: length 10.8
  BOTTOM w0.102: CON3101.5 115.18,14.12 115.09,14.02 115.09,11.61 115.29,11.41 115.9,11.41 117.3,12.8 119.86,12.8 120.12,12.54 120.12,12.19 120.35,11.97 121.03,11.97 121.23,12.17 C3122.2
SATA0_RXP_HDD: length 55.9
  IN3 w0.127: v3(124.81,43.1) 124.72,43.2 124.72,43.38 124.85,43.51 125.15,43.51 125.5,43.16 125.5,42.78 127.15,41.13 129.06,41.13 129.72,40.47 130.53,40.47 130.89,40.11 130.89,38.98 130.48,38.57 130.48,35.62 132.05,34.04 132.05,31.76 133.73,30.08 133.73,29.47 134.06,29.14 134.06,27.21 135.31,25.97 135.31,21.64 134.5,20.83 133.94,20.83 132.28,19.17 132.28,15.22 134.42,13.09 134.42,12.96 134.29,12.83 133.94,12.83 133.85,12.74 133.85,12.54 v5(134.11,12.27)
  BOTTOM w0.102: v5(134.11,12.27) 134.08,12.31 134.08,12.49 134.16,12.58 134.24,12.58 134.32,12.65 134.32,12.75 134.26,12.8 133.22,12.8 131.64,11.23 131.47,11.23 125.44,11.23 125.09,11.59 124.83,11.84 122.25,11.84 122.1,11.69 C3123.1 ; v3(124.81,43.1) 124.57,43.34 U0400.E20
SATA0_RXP_HDD_C: length 11.4
  BOTTOM w0.102: CON3101.6 114.68,14.15 114.88,13.95 114.88,11.53 115.21,11.2 115.98,11.2 117.38,12.6 119.77,12.6 119.91,12.46 119.91,12.11 120.26,11.76 120.47,11.76 ; C3123.2 121.23,11.48 120.96,11.76 120.47,11.76 ; 120.47,11.76 v2(120.47,11.51)
SATA0_TXN_HDD: length 62.2
  IN3 w0.127: v5(135.85,12.23) 135.97,12.35 135.97,12.58 133.81,14.74 133.81,19.2 136.02,21.41 136.02,26.44 135.03,27.43 135.03,29.73 133.34,31.42 133.34,33.7 131.14,35.89 131.14,38.27 132.03,39.16 132.03,40.64 131.54,41.13 130.05,41.13 129.39,41.79 127.43,41.79 126.59,42.62 126.59,43.97 127.38,44.76 128.58,44.76 128.88,45.06 v3(128.88,45.32)
  BOTTOM w0.102: C3121.1 122.09,13.36 122.35,13.62 123.95,13.62 125.73,11.84 131.39,11.84 132.97,13.41 133.05,13.41 133.05,13.41 135.23,13.41 136.04,12.6 136.04,12.42 v5(135.85,12.23) ; U0400.B21 126.94,45.09 127.45,45.09 127.63,44.91 128.52,44.91 128.88,45.27 v3(128.88,45.32)
SATA0_TXN_HDD_C: length 6
  BOTTOM w0.102: C3121.2 117.15,13.24 116.48,13.9 116.48,14.03 116.18,14.33 CON3101.3
SATA0_TXP_HDD: length 62.4
  IN3 w0.127: v3(129.36,45.01) 129.16,45.01 128.68,44.53 127.48,44.53 126.82,43.88 126.82,42.72 127.53,42.01 129.49,42.01 130.14,41.36 131.64,41.36 132.26,40.74 132.26,39.07 131.37,38.18 131.37,35.99 133.57,33.79 133.57,31.51 135.26,29.82 135.26,27.53 136.25,26.54 136.25,21.31 134.04,19.1 134.04,14.84 136.17,12.7 136.17,12.7 v1(136.61,12.26)
  BOTTOM w0.102: C3120.1 122.1,14.05 122.33,13.82 123.22,13.82 ; v3(129.36,45.01) 129.24,44.88 128.79,44.88 128.61,44.71 127.54,44.71 127.52,44.73 127.35,44.73 U0400.A21 ; 123.22,13.82 124.04,13.82 125.81,12.04 131.31,12.04 132.88,13.62 133.13,13.62 135.31,13.62 136.42,12.51 136.42,12.45 v1(136.61,12.26) ; 123.22,13.82 v2(123.22,14.05)
SATA0_TXP_HDD_C: length 6.4
  BOTTOM w0.102: 120.7,13.9 120.7,13.57 120.57,13.44 117.23,13.44 116.68,13.99 CON3101.2 ; 120.7,13.9 v2(120.47,13.9) ; 120.7,13.9 120.7,14 120.85,14.15 C3120.2
SATA_LED#: length 330.7
  TOP w0.102: v1(147.41,21.98) 147.94,21.98 148.69,21.23 148.69,20.89 148.36,20.56 148.36,19.46 150.72,17.1 150.72,11.53 152.58,9.68 189.61,9.68 191.9,11.97 199.49,11.97 200.58,10.87 204.55,10.87 v1(205,10.42) ; v1(217.2,14.89) 217.56,15.25 217.56,16.58 216.2,17.94 214.6,17.94 213.23,16.57 v1(213.23,15.73) ; R3116.1 219.43,17.4 v1(219.23,17.2)
  IN1 w0.102: v1(205,10.42) 204.65,10.77 204.65,14.63 209.14,19.13 210.41,19.13 213.21,16.33 213.21,15.75 v1(213.23,15.73) ; v1(125.02,29.72) 125.22,29.52 128.18,29.52 128.51,29.19 130.1,29.19 130.73,29.82 131.45,29.82 131.78,29.49 132.84,29.49 132.87,29.52 133.02,29.52 139.95,22.58 146.76,22.58 147.37,21.98 v1(147.41,21.98) ; v1(219.23,17.2) 219.23,16.92 v1(217.2,14.89)
  IN2 w0.102: v1(18.19,87.12) 18.19,88.17 18.9,88.88 20.78,88.88 21.56,89.66 31.17,89.66 v1(31.6,90.1) 32.28,89.41 33.33,89.41 35.85,86.89 35.85,85.64 32.49,82.27 32.49,70.21 30.53,68.25 30.53,67.62 30,67.08 30,66.52 28.83,65.36 28.83,59.56 29.82,58.57 29.82,50.9 33.07,47.65 33.07,37.77 34.38,36.46 34.38,34.73 35.22,33.89 35.22,32.02 36.6,30.63 36.6,28.8 37.41,27.99 37.41,20.55 40.36,17.6 46.22,17.6 46.73,17.1 52.22,17.1 54.33,14.99 63.68,14.99 64.29,14.38 66.39,14.38 68.78,11.98 82.33,11.98 83.2,12.85 96.27,12.85 98.3,14.89 v1(99.03,14.89)
  IN3 w0.102: v1(99.03,14.89) 99.29,14.63 101.57,14.63 102.09,15.15 107.74,15.15 108.78,16.18 110.31,16.18 110.58,15.92 116.63,15.92 120.45,19.73 120.45,21.14 120.96,21.64 120.96,22.18 122.73,23.95 122.73,25.1 122.21,25.61 122.21,26.08 122.43,26.29 122.43,27.41 123.39,28.37 123.67,28.37 v1(125.02,29.72)
  BOTTOM w0.076: 124.05,31.75 123.12,32.68 U0400.H1
  BOTTOM w0.102: v1(18.19,87.12) 17.6,87.71 16.87,87.71 16.74,87.58 Q5002.2 ; v1(31.6,90.1) v2(31.6,91.39) ; R1409.2 125.85,29.3 125.43,29.72 v1(125.02,29.72) 124.28,30.46 124.28,31.52 124.05,31.75
SATA_LED_Q: length 18.3
  TOP w0.102: R5002.2 24.44,90.32 24.82,89.94 25.95,89.94 v1(26.12,90.11)
  IN3 w0.102: v1(16,85.73) 16.71,85.73 17.42,86.44 22.17,86.44 22.35,86.62 22.35,87.4 25.06,90.11 v1(26.12,90.11)
  BOTTOM w0.102: Q5002.5 16.74,85.45 16.46,85.73 v1(16,85.73) 16,85.27 16.09,85.18 Q5002.6 ; v1(26.12,90.11) v2(26.76,90.11)
SCS#_TPM: length 3
  TOP w0.102: R3913.1 31.7,63.12 R3908.1 31.7,62.23 v2(32.22,61.71) 32.37,61.57 U3901.20
SD_READ_MODE: length 20.1
  TOP w0.102: R1517.1 93.93,32.36 94.77,31.52 v1(94.77,31.51)
  IN2 w0.102: v1(94.77,31.51) 95.26,32.01 101.97,32.01 104.79,34.83 v3(109.91,34.83)
  BOTTOM w0.102: v2(94.31,32.36) 94.77,31.9 v1(94.77,31.51) ; v3(109.91,34.83) 110.38,35.3 U0400.AN5
SDATA_IN_R: length 3.7
  BOTTOM w0.102: R3805.2 20.27,24.82 19.94,25.15 v2(19.94,25.38) 19.84,25.48 18.52,25.48 18.04,25.95 U3800.16
SERIRQ_TPM: length 5
  TOP w0.102: U3901.27 34.73,58.51 34.52,58.3 33.88,58.3 33.66,58.07 R3911.1 34.04,57.64 34.11,57.56 34.11,55.27 v2(34.06,55.22)
SIO_EXT_SCI#: length 5.8
  BOTTOM w0.076: 123.47,30.89 123.47,31.27 122.19,32.55 122.19,33.09 U0400.J2
  BOTTOM w0.102: 123.47,30.89 123.47,29.27 122.99,28.79 T1402.1
SIO_EXT_SMI#: length 12.4
  TOP w0.102: v1(124.55,26.23) 124.13,25.81 T0409.1
  IN2 w0.102: v1(124.55,26.23) 124.95,26.63 124.95,28.06 124.26,28.75 124.26,32.06 122.4,33.93 122.4,34.36 121.66,35.09 v3(120.9,35.09)
  BOTTOM w0.089: v3(120.9,35.09) 120.98,35.09 U0400.L6
SIO_EXT_WAKE#: length 107.6
  TOP w0.102: v1(39.3,37.44) 39.59,37.73 41.55,37.73 41.78,37.5 U2300.116
  IN2 w0.102: v1(112.29,24.62) 111.54,23.87 106.44,23.87 106.31,23.99 105.12,23.99 104.8,24.31 101.33,24.31 100.72,24.92 98.17,24.92 97,23.75 89.56,23.75 88.98,24.34 87.22,24.34 86.76,23.87 85.18,23.87 85.1,23.95 81.79,23.95 78.35,20.51 75.68,20.51 75.31,20.14 70.64,20.14 70.51,20.28 63.8,20.28 63.55,20.53 58.88,20.53 58.17,19.81 55.88,19.81 54.15,21.54 51.7,21.54 51.17,22.08 49.3,22.08 49.05,21.82 44.91,21.82 43.04,23.69 42.95,23.78 42.8,23.93 42.8,24.27 39.8,27.27 39.8,34.69 39.3,35.2 v1(39.3,37.44)
  BOTTOM w0.076: 114.97,32.53 114.97,32.77 114.92,32.88 114.9,32.93 114.9,33.61 U0400.AD3
  BOTTOM w0.102: 114.97,32.53 114.97,31.82 115.33,31.46 115.33,29.8 115.7,29.43 R1506.2 116.15,28.5 116.15,27.76 116.33,27.59 116.33,27.31 115.42,26.39 113.13,26.39 112.69,25.95 112.69,25.02 v1(112.29,24.62) ; v2(39.78,38.13) 39.55,37.9 39.55,37.7 39.29,37.44 39.29,37.44 v1(39.3,37.44)
SIO_PWRBTN#: length 121.6
  TOP w0.102: U2300.52 28.55,34.7 29.67,35.82 29.67,36.38 v1(30.63,37.34) ; R1200.2 95.58,33.68 v1(95.86,33.68)
  IN2 w0.102: v1(46.05,49.35) 45.36,48.67 45.36,40.67 46.84,39.19 46.84,39.02 48.92,36.93 48.92,26.84 52.19,23.57 v1(53.52,23.57)
  IN3 w0.102: v1(95.86,33.68) 95.86,33.63 95,32.77 93.89,32.77 93.02,31.9 91.94,31.9 90.29,30.25 89.38,30.25 88.39,29.26 84.81,29.26 80.19,24.64 75.83,24.64 74.04,22.85 70.3,22.85 68.77,21.31 62.74,21.31 62.31,21.74 56.48,21.74 54.65,23.57 v1(53.52,23.57)
  BOTTOM w0.076: U0400.BA15 105.05,41.52 103.99,41.52 103.54,41.07 102.77,41.07
  BOTTOM w0.102: v1(95.86,33.68) 95.71,33.84 v2(95.71,35.26) 95.71,36.43 98.88,39.6 100.59,39.6 102.07,41.07 102.77,41.07 ; v1(46.05,49.35) 45.59,48.9 45.59,48.12 43.12,45.65 39.7,45.65 38.46,44.4 35.21,44.4 30.63,39.82 v2(30.63,38.66) v1(30.63,37.34)
SIO_SLP_A#: length 3.4
  TOP w0.102: v3(110.67,41.25) 111.02,40.9 111.68,40.9 111.84,41.05 111.84,41.38 112.4,41.94 T1203.1
  BOTTOM w0.089: v3(110.67,41.25) 110.38,41.54 U0400.AN16
SIO_SLP_S0#: length 338.8
  TOP w0.102: v1(203.05,22) 203.05,19.61 v1(204.29,18.37) ; v1(34.62,56.2) 34.57,56.25 R3903.2 ; v1(88.77,11.23) 88.77,11.38 90.83,13.44 90.83,16.07 90.22,16.68 90.22,18.41 87.58,21.05 87.58,21.32 86.33,22.56 86.33,25.5 87.5,26.67 87.5,28.44 86.89,29.05 86.89,31.4 86.56,31.73 86.56,32.44 v2(89.03,34.9) 90.3,36.17 90.3,38.56 90.91,39.17 91.99,39.17 93.41,40.59 95.56,40.59 97.23,42.26 97.77,42.8 102.34,42.8 103.78,41.35 104.49,41.35 106.81,39.04 106.81,38.71 107.28,38.23 107.67,38.23 v3(108.03,38.59) ; PU9000.2 46.99,72.85 v1(46.63,72.49) ; R3914.2 40.59,59.06 v1(40.84,58.8)
  IN1 w0.102: v3(108.03,38.59) 107.67,38.23 107.01,38.23 106.48,37.7 106.48,37.29 102.4,33.21 101.13,33.21 100.54,32.62 87.13,32.62 84.33,29.82 84.33,29.82 84.26,29.75 83.8,29.75 78.03,23.98 76.19,23.98 75.68,23.47 73.36,23.47 73.15,23.68 70.46,23.68 69.06,25.07 67.34,25.07 66.55,25.86 63.11,25.86 62.01,26.96 62.01,29.05 56.51,34.55 50.62,34.55 50.17,35 50.17,50.07 47.12,53.11 v1(47.12,53.37)
  IN2 w0.102: v1(88.77,11.23) 88.77,11.23 89.81,12.27 96.33,12.27 96.91,12.85 100.19,12.85 100.71,13.37 100.71,14.04 101.3,14.63 101.64,14.63 102.3,15.29 109.91,15.29 110.21,14.99 117.88,14.99 118.47,14.4 124.18,14.4 124.31,14.53 126.8,14.53 127.28,14.05 131.8,14.05 134.7,16.94 142.56,16.94 143.45,17.83 150.65,17.83 151.64,18.82 152.88,18.82 154.1,17.6 155.53,17.6 156.47,16.66 198.61,16.66 203.05,21.1 v1(203.05,22) ; v1(204.65,39.82) 204.77,39.93 205.36,39.93 206.71,38.58 206.71,21.26 205.08,19.63 205.08,18.96 204.49,18.37 v1(204.29,18.37)
  IN3 w0.102: v1(34.62,56.2) 35.01,56.59 37.67,56.59 39.88,58.8 v1(40.84,58.8) 41.22,58.42 42.16,58.42 43.18,59.44 43.18,67.75 46.63,71.21 v1(46.63,72.49)
  BOTTOM w0.089: v3(108.03,38.59) 108.03,38.62 U0400.AT11
  BOTTOM w0.102: CON5103.35 205.3,40.26 205.26,40.21 205.05,40.21 v1(204.65,39.82) ; v1(47.12,53.37) 46.25,54.23 46.25,55.21 44.87,56.59 35.01,56.59 v1(34.62,56.2)
SIO_SLP_S3#: length 438.3
  TOP w0.102: v1(44.22,70.03) PR9004.1 44.74,70.74 v1(45.2,71.21) 45.86,71.86 46.89,71.86 47.64,72.61 PU9000.1 ; v1(73.79,19.32) 73.79,19.87 v1(71.96,21.71)
  TOP w0.254: PR8604.1 106.76,93.55 106.35,93.14 102.28,93.14 100.81,91.67 98.63,91.67 96.57,93.73 95.81,93.73 v2(95.58,93.5) 95.34,93.26 v1(95.34,92.61)
  IN1 w0.102: v1(195.35,51.1) 195.94,50.52 195.94,49.91 198.2,47.65 199.9,47.65 203.44,44.11 203.44,41.63 202.91,41.11 202.91,40.53 v1(203.45,40) ; v1(90.19,20.4) 90.29,20.4 91.08,19.61 93.65,19.61 94.52,18.75 104.88,18.75 105.19,18.43 109.31,18.43 110.84,16.9 113.92,16.9 118.45,12.37 122.39,12.37 124.72,14.71 126.75,14.71 130.91,10.54 v1(139.47,10.54)
  IN1 w0.254: v1(95.34,92.61) 94.84,92.61 93.83,93.62 82.98,93.62 77.67,98.94 62.59,98.94 60.66,97.01 60.66,95.94 60.3,95.59 58.78,95.59 56.08,92.89 54.15,92.89 53.05,91.8 50.66,91.8 48.74,89.88 48.74,73.92 46.03,71.21 v1(45.2,71.21)
  IN2 w0.102: v1(34.6,55.59) 34.6,52.86 37.59,49.86 37.59,41.96 40.39,39.17 40.39,35.43 42.44,33.38 42.44,25.92 43.96,24.4 43.96,24.06 45.03,22.99 45.59,22.99 46.3,23.7 50.84,23.7 52.08,22.46 56.26,22.46 56.78,21.94 64.08,21.94 64.37,21.65 70.64,21.65 71.1,22.11 71.55,22.11 v1(71.96,21.71) 72.14,21.88 77.76,21.88 82.07,26.19 83.29,26.19 83.54,25.94 84.4,25.94 84.84,26.37 84.84,26.71 86.06,27.94 87.46,27.94 89.59,30.08 90.12,30.08 92.17,32.13 93.21,32.13 94.22,33.15 101.48,33.15 106.6,38.27 106.6,39.8 107.67,40.87 109.01,40.87 v3(109.4,40.49) ; v1(215.62,28.93) 215.62,26.27 215.25,25.9 215.25,23.38 213.79,21.92 211.7,21.92 204.09,14.31 204.09,11.81 202.19,9.91 178.56,9.91 v1(178.08,10.39) 177.75,10.73 172.62,10.73 172.44,10.54 165.82,10.54 165.21,11.15 156.26,11.15 155.65,10.54 151.64,10.54 150.96,9.87 146.97,9.87 146.45,10.39 144.53,10.39 144.27,10.14 139.88,10.14 v1(139.47,10.54) ; v1(80.37,20.77) 81.19,21.59 85.05,21.59 86.7,19.94 89.74,19.94 v1(90.19,20.4)
  IN3 w0.102: v1(203.45,40) 203.69,40.24 206.24,40.24 215.62,30.86 v1(215.62,28.93) ; v1(34.6,55.59) 34.21,55.97 34.21,56.37 34.64,56.8 36.81,56.8 39.27,59.26 41,59.26 41.5,58.75 42.04,58.75 42.98,59.69 42.98,67.84 44.22,69.08 v1(44.22,70.03)
  BOTTOM w0.089: v3(109.4,40.49) 109.39,40.49 109.39,40.5 U0400.AP15
  BOTTOM w0.102: PR9100.1 182.19,10.67 181.44,9.91 178.56,9.91 v1(178.08,10.39) ; v1(80.37,20.77) 80.37,20.63 79.7,19.96 U1800.1 78.22,19.96 77.17,21.01 75.06,21.01 74.93,20.88 74.93,19.49 74.77,19.32 v1(73.79,19.32) ; PR9109.1 195.65,50.8 v1(195.35,51.1)
SIO_SLP_S4#: length 326.7
  TOP w0.102: v1(55.44,24.74) 55.44,24.3 v2(57.4,22.33) 57.4,19.05 57.78,18.68 v1(57.78,15.64) 57.78,15.19 61.09,11.88 61.09,6.23 v1(61.56,5.75) ; PR8813.1 46.94,11.1 47.01,11.17 PD8800.1 47.83,10.95 v1(47.83,9.28) ; PR9200.1 143.76,22.91 143.43,23.24 v1(143.08,23.24)
  TOP w0.254: PCE8601.2 104.74,90.03 104.56,90.21 PR8615.1 103.77,90.14 v1(104.36,89.55)
  IN1 w0.102: v1(55.44,24.74) 55.44,26.1 54.38,27.16 52.74,27.16 52.1,27.8 52.1,28.57 52.96,29.43 52.96,31.24 51.56,32.64 50.47,32.64 49.63,33.48 49.63,34.24 49.49,34.38 49.49,49.34 46.36,52.48 46.36,55.03 46.41,55.08 46.41,63.03 48.43,65.05 51.95,65.05 54.1,67.21 54.1,67.62 58.29,71.81 58.29,90.76 63.57,96.04 63.75,96.04 63.75,96.04 66.61,96.04 66.61,96.04 67.39,96.04 68.43,97.08 76.23,97.08 80.95,92.36 92.51,92.36 93.8,91.06 102.84,91.06 v1(104.36,89.55) ; v1(133.12,12.12) 129.66,12.12 126.86,14.91 124.64,14.91 122.3,12.58 118.53,12.58 114.01,17.1 111.32,17.1 110.46,17.96 110.46,19.19 109.39,20.27 105.95,20.27 105.75,20.06 104.96,20.06 104.48,20.54 104.48,22.81 101.92,25.37 99.27,25.37 98,24.11 93.97,24.11 v1(92.65,25.43) 92.38,25.43 91.57,24.62 88.75,24.62 88.19,24.05 88.19,23.01 88,22.82 88,20.34 91.67,16.66 91.67,14.76 91.46,14.54 89.37,14.54 88.65,15.26 88.12,15.26 87.03,14.18 82.28,14.18 80.13,12.03 75.85,12.03 74.38,10.57 70.76,10.57 68.2,13.13 60.68,13.13 59.97,13.85 59.57,13.85 v1(57.78,15.64)
  IN2 w0.102: v1(144.32,15.47) 142.21,13.36 134.37,13.36 v1(133.12,12.12) ; v1(61.56,5.75) 61.54,5.75 60.6,6.68 59.53,6.68 58.84,6 55.56,6 53.74,7.82 53.61,7.95 49.59,7.95 49.08,8.46 48.65,8.46 v1(47.83,9.28)
  IN3 w0.102: v1(144.32,15.47) 143.92,15.88 143.92,16.6 144.35,17.03 144.35,21.97 v1(143.08,23.24)
  BOTTOM w0.076: U0400.BA16 105.32,41.88 105.3,41.85 103.85,41.85 103.47,41.47 102.77,41.47
  BOTTOM w0.102: 102.77,41.47 101.87,41.47 100.41,40.01 98.71,40.01 94.06,35.36 94.06,33.1 93.32,32.36 93.32,30.23 92.86,29.77 92.86,26.24 92.65,26.03 v1(92.65,25.43)
SIO_SLP_S5#: length 16.1
  BOTTOM w0.076: 102.77,41.27 103.5,41.27 103.92,41.68 105.12,41.68 105.22,41.58 106,41.58 U0400.AY16
  BOTTOM w0.102: T1201.1 95.15,36.16 98.79,39.8 100.51,39.8 101.97,41.27 102.77,41.27
SLEEVE: length 28.4
  IN2 w1.016: 8.51,54.13 9.32,53.32 12.83,53.32 14.14,52 14.14,39.6 14.3,39.45 14.3,37.54 11.61,34.85 11.61,31.3
  vias: v1(8.33,54.56) v1(8.97,54.56) v1(12.45,29.72) v1(13.06,29.72)
SLP_SUS#: length 21.6
  TOP w0.102: T1207.1 92.1,39.73 93.17,40.79 95.48,40.79 97.03,42.34 97.67,42.98 97.69,43 102.42,43 103.87,41.56 104.58,41.56 106.05,40.08 109.71,40.08 v3(110.02,40.39)
  BOTTOM w0.089: v3(110.02,40.39) 110.03,40.39 110.03,40.5 U0400.AN15
SM_RCOMP_0: length 1.5
  TOP w0.305: v3(109.37,42.19) 109.37,42.34 109.55,42.52 R0500.1
  BOTTOM w0.254: U0400.AR18 109.19,42.57 109.37,42.39 v3(109.37,42.19)
SM_RCOMP_1: length 1.4
  TOP w0.305: v3(108.03,42.24) 108.03,42.83 R0501.1
  BOTTOM w0.254: v3(108.03,42.24) 108.03,42.27 U0400.AT18
SM_RCOMP_2: length 1.3
  TOP w0.305: R0502.1 v3(107.49,43.18)
  BOTTOM w0.254: U0400.AU18 107.49,42.97 v3(107.49,43.18)
SMB_ALERT#: length 12.9
  TOP w0.102: R1114.2 123.06,29.28 123.06,30.18 123.19,30.3 v2(123.19,30.69) 123.19,31.37 122.06,32.5 121.26,32.5 119.23,34.53 119.23,36.1 119.48,36.35 119.48,38.03 v3(119.86,38.41)
  BOTTOM w0.089: v3(119.86,38.41) 119.69,38.41 U0400.R10
SMB_THERMAL_CLK: length 189.2
  IN3 w0.127: v1(19.02,48.44) 18.54,48.92 18.54,51.67 17.95,52.26 17.95,54.15 18.25,54.46 18.25,55.84 16.41,57.69 16.41,64.98 14.32,67.06 14.32,69.87 15.81,71.36 15.81,74.62 15.39,75.03 15.39,76.5 14.21,77.68 14.21,78.82 13.42,79.61 13.42,81.23 14.49,82.29 14.49,85.83 14.84,86.17 15.19,86.17 15.51,85.85 15.51,85.63 15.9,85.23 21.78,85.23 22.94,86.39 22.94,87.29 25.06,89.41 27.48,89.41 28.1,90.02 30.42,90.02 38.13,97.73 38.13,99.09 38.67,99.63 44.41,99.63 46.24,101.47 52.72,101.47 53.53,102.28 60.87,102.28 62.23,100.92 79.83,100.92 83.35,97.4 93.38,97.4 100.88,104.9 106.19,104.9 106.29,104.99 107.2,104.99 108.31,103.89 113.94,103.89 115.52,102.31 116.74,102.31 118.54,100.51 126.19,100.51 126.67,100.03 126.67,93.68 127.93,92.42 129.6,92.42 v1(130.64,91.37)
  BOTTOM w0.102: C1901.1 18.29,48.29 18.25,48.25 Q1900.1 ; C1901.1 18.72,48.75 v1(19.02,48.44) ; C1901.1 17.7,48.75 17.63,48.67 R1911.2 v2(17.09,47.86) ; U3700.8 131.93,89.24 131.19,89.97 131.19,90.38 130.64,90.93 v1(130.64,91.37)
SMB_THERMAL_DATA: length 195.2
  IN3 w0.127: v1(131.27,91.37) 131.27,91.46 129.81,92.92 128.14,92.92 127.98,93.09 127.98,99.45 126.23,101.2 118.59,101.2 116.97,102.82 115.75,102.82 113.36,105.21 109.58,105.21 109.28,105.5 105.18,105.5 105.08,105.41 100.67,105.41 93.16,97.91 83.56,97.91 80.04,101.42 62.51,101.42 61.15,102.78 53.32,102.78 52.5,101.97 46.03,101.97 44.2,100.14 38.46,100.14 37.62,99.3 37.62,97.94 30.21,90.53 25.07,90.53 21.84,87.3 21.11,87.3 20.49,86.68 14.63,86.68 13.98,86.04 13.98,82.51 12.92,81.44 12.92,79.4 13.63,78.69 13.63,77.55 14.88,76.29 14.88,71.26 13.01,69.38 13.01,67.66 14.85,65.82 14.85,58.16 v1(15.88,57.13)
  BOTTOM w0.102: v1(15.88,57.13) 16.64,57.13 17.04,56.72 17.04,54.19 16.15,53.3 16.15,51.84 16.33,51.67 17.49,51.67 18.66,50.5 20.12,50.5 21.31,49.3 v2(21.31,48.52) 21.95,47.88 21.95,46.99 21.21,46.26 21.21,45.42 R1912.2 20.07,44.94 19.91,45.09 Q1900.4 19.55,44.51 19.79,44.27 C1902.1 ; U3700.7 131.99,89.89 131.72,90.15 131.72,90.91 v1(131.27,91.37)
SML0_ALERT#: length 12.4
  BOTTOM w0.076: U0400.W1 117.15,32.44 116.94,32.23 116.94,30.98
  BOTTOM w0.102: R1109.2 122.07,23.69 121.04,24.72 119.89,24.72 119.58,25.02 v2(119.58,25.66) 119.58,25.94 118.86,26.66 118.86,27.11 117.78,28.19 117.78,29.94 116.94,30.78 116.94,30.98
SML0_SMBCLK: length 16.8
  IN3 w0.127: v3(118.85,37.62) 119.48,36.98 119.48,33.4 120.03,32.86 120.03,29 119.51,28.48 119.51,28.13 119.52,28.12 119.52,24.42 v1(119.66,24.28)
  BOTTOM w0.089: v3(118.85,37.62) 119.08,37.62 U0400.R9
  BOTTOM w0.102: v1(119.66,24.28) 119.84,24.11 T1103.1 120.65,24.11 121.13,23.62 R1102.2
SML0_SMBDATA: length 13
  BOTTOM w0.076: U0400.W2 117.4,32.88 117.42,32.81 117.42,32.46
  BOTTOM w0.102: R1103.2 122.92,23.23 122.62,23.54 122.55,23.54 120.38,25.71 120.17,25.71 119.09,26.79 119.09,27.21 118.33,27.96 T1104.1 118.33,28.99 118.02,29.31 118.02,29.98 117.13,30.86 117.13,32.17 117.42,32.46 117.42,32.46
SML1_SMBCLK: length 168.8
  TOP w0.102: v1(33.73,51.39) 32.89,51.39 32.68,51.6 v2(32.08,51.6) 30.51,51.6 29.82,50.91 26.58,50.91 25.86,50.19 24.1,50.19 24.09,50.18 v1(24.1,50.18)
  IN3 w0.127: v3(117.55,31.57) 117.42,31.45 117.42,30.08 118.2,29.31 118.2,25.91 117.94,25.66 115.75,25.66 115.05,24.96 115.05,23.15 113.06,21.16 112.04,21.16 111.63,20.75 110.44,20.75 110.24,20.55 106.02,20.55 104.92,19.45 101.85,19.45 101.04,18.65 95.24,18.65 93.21,16.61 91.6,16.61 89.56,18.66 81.81,18.66 81.31,19.16 81.31,20.51 80.32,21.49 77.01,21.49 75.34,19.81 75.34,18.75 75.15,18.56 75.15,18.18 72.33,15.37 58.12,15.37 56.71,13.97 53.88,13.97 53.57,14.28 53.57,14.62 53.65,14.7 53.65,17.57 52.9,18.32 52.9,20.03 48.54,24.39 43.87,24.39 41.96,26.29 40.26,26.29 37.14,29.42 37.14,30.51 35.59,32.06 35.59,33.87 33.05,36.41 33.05,41.38 32.69,41.73 32.69,45.96 32.27,46.38 32.27,49.29 33.73,50.75 v1(33.73,51.39)
  BOTTOM w0.076: U0400.W3 117.55,33.61 117.55,32.94 117.63,32.72 117.63,32.39 117.48,32.24 117.48,31.9 117.54,31.84 117.54,31.58 v3(117.55,31.57)
  BOTTOM w0.102: R1104.2 122.36,24.87 122.26,24.96 121.96,24.96 120.73,26.19 120.37,26.19 119.57,26.99 119.57,27.41 118.81,28.16 118.81,29.22 118.5,29.54 118.5,29.76 117.45,30.81 117.45,31.48 v3(117.55,31.57) ; R1910.1 17.91,42.62 17.75,42.47 17.75,42.09 18.09,41.76 18.92,41.76 19.71,42.55 20.68,42.55 20.98,42.85 20.98,44.45 21.69,45.16 21.69,46.06 22.43,46.79 22.43,48.51 v1(24.1,50.18)
SML1_SMBDATA: length 163.3
  TOP w0.102: v1(33.16,52.03) 33.11,52.08 29.91,52.08 29.34,51.51 26.22,51.51 25.38,50.68 23.9,50.68 23.52,50.3 23.52,49.79 v2(23.24,49.51) 22.89,49.15 20.8,49.15 v1(20.52,48.87)
  IN3 w0.127: v1(33.16,52.03) 33.16,50.9 31.69,49.43 31.69,45.66 32.11,45.24 32.11,41.58 32.54,41.15 32.54,36.2 35.08,33.66 35.08,31.85 36.63,30.3 36.63,29.14 39.98,25.78 41.75,25.78 44.8,22.74 46.08,22.74 47.7,21.11 51.08,21.11 52.39,19.8 52.39,18.1 53.14,17.36 53.14,14.91 53.06,14.83 53.06,14.07 53.67,13.46 56.97,13.46 58.37,14.86 72.54,14.86 75.65,17.97 75.65,18.35 78.27,20.96 79.22,20.96 79.98,20.2 80.44,20.2 80.76,19.88 80.76,18.99 80.77,18.98 80.77,18.95 81.59,18.14 89.36,18.14 91.39,16.11 93.42,16.11 95.45,18.14 96.8,18.14 97.62,17.32 100.43,17.32 102.06,18.95 105.14,18.95 106.24,20.04 110.46,20.04 110.64,20.22 111.86,20.22 112.29,20.65 113.27,20.65 115.56,22.94 115.56,24.65 116.05,25.15 118.26,25.15 118.71,25.59 118.71,29.89 118.26,30.33 118.26,31.38 v3(118.11,31.54)
  BOTTOM w0.076: 118.29,30.89 118.29,31.36 v3(118.11,31.54) 118.29,31.71 118.29,32.24 118.05,32.48 118.05,32.81 118.08,32.95 118.08,33.86 117.82,34.13 U0400.V3
  BOTTOM w0.102: R1105.2 123.7,24.87 123.22,25.34 123.11,25.34 123.01,25.45 122.16,25.45 120.93,26.67 120.57,26.67 120.05,27.19 120.05,27.61 119.35,28.31 119.35,29.39 118.29,30.46 118.29,30.89 ; R1909.1 19.99,49.63 20.14,49.48 20.14,49.25 v1(20.52,48.87)
SML1ALERT#: length 10.4
  TOP w0.102: R1106.2 111.49,28.31 111.79,28.6 111.79,28.98 111.94,29.14 v2(111.94,29.8) 111.77,29.96 111.77,32.35 110.57,33.56 110.57,35.38 110.32,35.63 110.32,36.38 v3(110.7,36.76)
  BOTTOM w0.102: U0400.AM7 110.7,36.61 v3(110.7,36.76)
SPI_CLK: length 142.3
  TOP w0.102: v1(42.37,63.6) 42.34,63.57 J5301.7 ; R3907.2 v1(30.84,65.18)
  IN1 w0.097: v1(105.44,24.79) 105.44,26.6 105.11,26.93 105.11,27.66 103.79,28.97 89.4,28.97 85.83,25.4 85.5,25.4 83.52,23.42 81.46,23.42 79.17,21.14 77.32,21.14 76.43,20.25 71.22,20.25 70.46,19.48 66.37,19.48 65.74,18.85 60.02,18.85 58.82,20.05 55.58,20.05 54.93,20.7 52.67,20.7 45.52,27.86 45.52,30.03 42.66,32.88 42.66,39.34 41.38,40.62 39.11,40.62 38.25,41.49 38.25,43.05 37.16,44.14 37.16,48.9 37.01,49.05 37.01,57.31 37.64,57.94 37.64,60.76 39.88,62.99 41.76,62.99 v1(42.37,63.6)
  IN3 w0.127: v1(42.37,63.6) 42.37,64.04 41.61,64.8 31.22,64.8 v1(30.84,65.18)
  BOTTOM w0.076: 106.48,30.99 106.48,32.11 106.89,32.52 106.89,32.86 107.18,33.16 U0400.AV2
  BOTTOM w0.102: 106.48,30.99 105.28,29.8 105.28,28.68 105.11,28.5 105.11,27.37 105.32,27.15 105.32,25.3 105.44,25.19 v1(105.44,24.79) v2(105.44,23.14) 105.44,22.74 105.05,22.35 105.05,22.08 104.7,21.72 R1906.1
SPI_CLK_R: length 17.5
  BOTTOM w0.102: v2(106.27,20.98) 105.77,20.98 105.66,21.08 104.98,21.08 104.75,20.86 R1906.2 104.17,20.86 103.95,20.64 101.97,20.64 100.75,19.43 100.75,19.2 100.63,19.08 100.38,19.08 100.25,19.2 100.25,19.56 100.13,19.69 99.9,19.69 99.77,19.56 99.77,19.18 99.67,19.08 99.39,19.08 99.26,19.2 99.26,19.56 99.14,19.69 98.91,19.69 98.7,19.49 98.7,19.2 98.58,19.08 98.3,19.08 98.15,19.23 98.15,20.58 98.27,20.7 101.31,20.7 102.02,21.41 U1900.6
SPI_CS0#: length 139.7
  TOP w0.102: J5301.5 42.05,62.57 42.44,62.18 v1(42.44,61.8) 42.44,61.34 42.17,61.07 J5301.2
  IN1 w0.097: v1(105.99,27.74) 105.99,27.76 103.7,30.06 93.69,30.06 93.47,29.83 92.4,29.83 92.22,30.01 89.01,30.01 86.97,27.97 86.09,27.97 85.6,27.47 85.6,27.28 85.01,26.69 85.01,26.2 84.29,25.48 82.51,25.48 78.91,21.87 77.07,21.87 76.27,21.08 60.6,21.08 59.07,22.61 53.37,22.61 48.51,27.47 48.51,31.22 45.39,34.35 45.39,41.22 42.75,43.86 42.75,45.16 41.28,46.64 41.28,52.05 40.55,52.77 40.55,54.98 41.28,55.7 41.28,57.47 42.44,58.64 v1(42.44,61.8)
  BOTTOM w0.076: 107.12,30.83 107.12,31.45 107.59,31.91 107.59,33.45 107.63,33.55 107.63,33.76 U0400.AU3
  BOTTOM w0.102: 107.12,30.83 107.12,30.78 105.99,29.66 v1(105.99,27.74) 106.5,27.23 106.5,26.74 106.03,26.27 106.03,25.59 106.15,25.48 106.15,23.36 106.32,23.19 106.32,21.87 107.14,21.05 v2(107.14,19.43) 107.14,17.73 105.73,16.32 103.9,16.32 103.4,16.83 101.93,16.83 101.01,17.74 101.01,18.2 100.61,18.6 97.99,18.6 97.71,18.87 U1900.1 R1902.2
SPI_CS1#: length 7.1
  BOTTOM w0.102: U0400.AU2 108.15,33.08 108.15,32.55 107.96,32.36 107.96,31.77 107.5,31.31 107.5,30.63 106.96,30.09 106.96,27.41 T1101.1
SPI_CS2#: length 131.7
  TOP w0.102: v1(30.2,63.1) 30.43,63.1 30.84,62.69 R3908.2
  IN1 w0.097: v1(30.2,63.1) 31.93,63.1 34.68,65.84 42.5,65.84 43.03,65.31 43.03,58.91 41.5,57.38 41.5,54.69 41.05,54.23 41.05,52.96 41.5,52.5 41.5,46.92 45.61,42.81 45.61,34.56 48.76,31.41 48.76,27.55 53.47,22.84 59.16,22.84 60.69,21.3 76.18,21.3 76.97,22.1 78.81,22.1 82.45,25.73 84.23,25.73 84.68,26.19 84.68,26.68 85.38,27.37 85.38,27.57 86.16,28.35 87.03,28.35 88.92,30.23 92.32,30.23 92.5,30.05 93.37,30.05 93.6,30.28 104.17,30.28 106.41,28.04 106.41,26.94 106.44,26.9 v1(106.44,26.1)
  BOTTOM w0.102: v1(106.44,26.1) 106.73,26.39 106.73,28.09 v2(106.43,28.4) 106.43,29.82 107.31,30.71 107.31,31.38 107.77,31.85 107.77,32.6 U0400.AU1
SPI_HOLD#_IO3: length 141
  TOP w0.102: J5301.10 42.19,65.07 42.34,65.22 v1(42.34,65.31) 42.34,65.79 42.06,66.07 J5301.12
  IN1 w0.097: v1(105.94,26.79) 105.59,27.15 105.59,27.85 103.61,29.83 93.78,29.83 93.56,29.61 92.06,29.61 91.88,29.79 89.54,29.79 86.8,27.05 86.33,27.05 85.9,26.62 85.9,26.24 85.54,25.88 85.24,25.88 83.26,23.9 81.25,23.9 79,21.65 77.16,21.65 76.36,20.86 60.51,20.86 58.97,22.39 53.27,22.39 47.22,28.44 47.22,32.13 45.16,34.19 45.16,41.1 41.05,45.21 41.05,51.13 40.08,52.1 40.08,54.89 41.05,55.86 41.05,57.56 42.04,58.55 42.04,62.44 42.8,63.2 42.8,64.84 v1(42.34,65.31)
  BOTTOM w0.076: 106.93,30.89 106.93,31.5 107.42,31.98 107.42,33.49 107.46,33.58 107.46,34.24 U0400.AU4
  BOTTOM w0.102: 106.93,30.89 105.77,29.72 105.77,28.48 105.59,28.3 105.59,27.57 105.8,27.35 105.8,26.93 v1(105.94,26.79) 105.94,26.5 105.8,26.36 105.8,25.5 105.92,25.39 105.92,23.24 106.1,23.06 106.1,21.77 106.71,21.16 106.71,18.52 v2(106.12,17.93) 106.12,17.39 105.28,16.55 104,16.55 103.49,17.05 102.02,17.05 101.24,17.84 101.24,19.23 102.16,20.14 U1900.7 104.04,20.14 104.11,20.07 R1904.2
SPI_SI: length 137.9
  TOP w0.102: R3909.2 30.56,61.75 30.2,62.11 v1(30.2,62.49) ; v1(40.84,64.07) J5301.8
  IN1 w0.097: v1(104.62,27.43) 103.88,28.17 97.43,28.17 97.03,27.77 95.95,27.77 95.28,28.44 89.54,28.44 86.02,24.93 85.71,24.93 84.46,23.67 84.46,22.88 83.57,21.99 80.71,21.99 79.38,20.65 77.55,20.65 75.81,18.92 70.22,18.92 69.68,18.37 59.79,18.37 58.58,19.58 55.37,19.58 54.73,20.22 52.48,20.22 44.5,28.2 44.5,30.37 42.18,32.69 42.18,38.24 40.28,40.14 38.92,40.14 37.64,41.42 37.64,42.98 36.55,44.07 36.55,46.43 36.3,46.68 36.3,50.53 36.36,50.59 36.36,53.3 36.02,53.64 36.02,57.13 36.5,57.61 36.5,60.3 40.27,64.07 v1(40.84,64.07)
  IN3 w0.127: v1(40.84,64.07) 39.97,64.07 38.38,62.49 v1(30.2,62.49)
  BOTTOM w0.076: U0400.AV3 106.92,34.06 106.92,33.12 106.72,32.93 106.72,32.58 106.31,32.18 106.31,31.1 106.11,30.89
  BOTTOM w0.102: 106.11,30.89 104.62,29.41 104.62,27.44 v1(104.62,27.43) 104.62,27.17 104.84,26.95 104.84,25.09 v2(104.57,24.82) 104.24,24.82 103.91,24.49 103.91,24.02 104.03,23.9 R1900.1
SPI_SI_R: length 18.5
  BOTTOM w0.102: R1900.2 104.47,23.04 103.76,23.75 v2(103,23.75) 102.32,23.75 101.52,22.95 98.58,22.95 98.48,22.85 98.48,21.29 98.58,21.19 99.64,21.19 99.74,21.29 99.74,21.52 99.64,21.62 99,21.62 98.9,21.72 98.9,21.95 99,22.05 104.17,22.05 104.41,22.29 104.41,22.47 104.19,22.68 U1900.5
SPI_SO: length 153.2
  TOP w0.102: J5301.6 41.19,63.07 v1(40.84,63.43) ; R3910.2 32.69,56.25 v1(32.74,56.2) 32.74,56.01 v2(32.39,55.65)
  IN1 w0.097: v1(103.8,27.4) 103.31,27.89 100.68,27.89 99.96,27.17 98.21,27.17 97.97,26.93 95.97,26.93 94.66,28.24 89.8,28.24 86.36,24.81 86.36,24.43 83.72,21.79 80.82,21.79 79.43,20.4 77.61,20.4 75.93,18.72 70.33,18.72 69.78,18.17 59.65,18.17 58.45,19.38 55.22,19.38 54.72,19.88 52.54,19.88 44.17,28.25 44.17,29.2 42.7,30.67 42.7,31.55 41.98,32.26 41.98,38.16 40.23,39.92 38.86,39.92 37.44,41.33 37.44,42.9 36.3,44.05 36.3,46.11 35.66,46.74 35.66,50.47 35.08,51.05 35.08,56.65 36.3,57.86 36.3,60.4 40.46,64.57 41.08,64.57 41.3,64.35 41.3,63.88 v1(40.84,63.43)
  IN3 w0.127: v1(40.84,63.43) 40.56,63.43 37.95,60.81 37.95,59.79 35.46,57.3 33.85,57.3 v1(32.74,56.2)
  BOTTOM w0.076: 105.31,31.07 105.31,32.39 105.46,32.54 105.46,33 105.64,33.17 105.64,33.44 105.88,33.68 106.1,33.68 106.39,33.98 U0400.AW3
  BOTTOM w0.102: R1905.2 94.46,19.92 94.69,19.69 97.23,19.69 97.43,19.89 97.43,20.9 97.99,21.46 97.99,23.14 98.26,23.41 101.33,23.41 102.4,24.48 103.25,24.48 104.38,25.61 104.38,26.76 103.8,27.34 v1(103.8,27.4) 103.63,27.56 103.63,28.53 104.16,29.06 104.16,29.92 105.31,31.07
SPI_SO_R: length 3.2
  BOTTOM w0.102: v2(93.02,20.27) 93.37,20.27 R1905.1 94.51,20.14 U1900.2
SPI_WP_IO2: length 29.8
  BOTTOM w0.076: U0400.AW2 106.11,32.82 106.11,31.5 105.53,30.92
  BOTTOM w0.102: U1900.3 94.51,21.41 94.36,21.57 R1903.2 93.09,21.57 92.74,21.21 92.74,20.67 92.53,20.46 92.53,20.09 93.17,19.46 97.33,19.46 97.66,19.8 97.66,20.81 98.22,21.36 98.22,22.92 98.48,23.18 101.43,23.18 102.49,24.25 103.34,24.25 104.61,25.51 104.61,26.85 104.21,27.26 104.21,27.72 104.14,27.79 v2(104.14,28.12) 104.14,28.53 104.39,28.78 104.39,29.78 105.53,30.92
SPK_ID: length 137.3
  TOP w0.102: R3826.2 11.23,21.64 v1(11.16,21.72) ; v2(45.26,20.17) 45.53,20.44 v1(45.53,20.94)
  IN2 w0.152: v1(117.06,29.19) 118.16,29.19 118.36,28.98 118.36,25.05 118.14,24.82 118.14,24.58 117.77,24.21 117.58,24.21 116.87,23.5 115.69,23.5 115.15,24.03 113.77,24.03 113.23,23.5 106.45,23.5 106.21,23.74 105.02,23.74 104.7,24.06 101.23,24.06 100.62,24.66 98.27,24.66 97.1,23.49 96.61,23.49 95.99,22.86 90.24,22.86 88.74,21.36 87.3,21.36 84.96,23.7 81.9,23.7 78.46,20.26 77.17,20.26 74.54,17.63 70.82,17.63 70.69,17.76 69.77,17.76 69.04,18.49 66.75,18.49 65.86,19.39 63.89,19.39 63.35,18.85 62.42,18.85 62.09,19.18 56.14,19.18 54.03,21.29 51.6,21.29 51.12,21.77 49.36,21.77 48.53,20.94 v1(45.53,20.94)
  BOTTOM w0.102: R3825.2 11.13,21.75 v1(11.16,21.72) 11.16,21.12 12.13,20.14 14.01,20.14 14.81,19.35 14.81,17.66 17.99,14.48 30.13,14.48 37.36,21.72 37.36,22.38 38.05,23.07 43.41,23.07 v1(45.53,20.94) ; 116.79,29.45 116.79,29.49 116.13,30.15 116.13,30.99 116.12,31 116.12,31.88 115.77,32.22 115.77,32.65 U0400.AB1
  BOTTOM w0.152: 116.79,29.45 v1(117.06,29.19)
SPK_ID_R: length 5.9
  BOTTOM w0.102: v2(13.77,19.71) 11.86,19.71 11.15,20.42 CON3800.6 10.33,21.9 10.26,21.97 R3825.1
SPK_L+: length 26.6
  IN3 w1.016: 17.36,32.22 19.39,32.22 20.24,31.37 20.24,23.52 10.26,13.54 8.94,13.54 8.92,13.52
  vias: v1(8.66,14.35) v1(9.27,14.35) v1(16.31,34.18) v1(16.74,33.75) v2(15.67,34.34)
SPK_L+_R:
  vias: v1(8.46,18.82) v1(8.51,18.21) v2(9.88,16.46)
SPK_L-: length 29.7
  IN3 w1.016: 20.27,33.17 21.51,31.93 21.51,22.99 10.43,11.92 8.36,11.92 7.47,12.8
  vias: v1(7.21,14.33) v1(7.82,14.3) v1(17.27,34.71) v1(17.27,34.09) v2(17.09,35.46)
SPK_L-_R:
  vias: v1(7.37,18.77) v1(7.37,18.16) v2(7.95,17.55)
SPK_R+: length 32.7
  IN1 w1.016: 4.65,12.68 4.65,12.35 5.39,11.61 10.13,11.61 21.51,22.99 21.51,31.96 20.45,33.02
  vias: v1(4.47,14.35) v1(5.08,14.35) v1(18.79,34.48) v1(18.81,33.86) v2(19.23,35)
SPK_R+_R:
  vias: v1(5.28,19.1) v1(5.26,18.47)
SPK_R-: length 29.3
  IN1 w1.016: 6.2,13.46 6.76,12.91 9.63,12.91 20.24,23.52 20.24,31.37 19.44,32.17 18.68,32.17 18.04,32.82
  vias: v1(5.87,14.33) v1(6.48,14.33) v1(18.05,34.76) v1(18.05,34.13) v2(6.6,13.59)
SPK_R-_R:
  vias: v1(6.2,18.49) v1(6.58,18.98) v2(6.22,17.86)
SPKR: length 74.9
  TOP w0.102: v1(97.43,31.5) 97.43,32.34 97.55,32.46 101.83,32.46 106.65,37.29 107.58,37.29 v3(107.94,37.65) ; v1(56.16,20.63) 56.52,20.27 v2(56.52,20.07)
  IN2 w0.102: v1(56.16,20.63) 56.74,21.21 63.84,21.21 64.08,20.96 70.79,20.96 70.91,20.84 75.04,20.84 75.4,21.2 78.07,21.2 82.37,25.5 82.96,25.5 83.21,25.25 85.38,25.25 85.59,25.45 85.9,25.45 89.38,28.93 92.38,28.93 94.49,31.04 96.97,31.04 v1(97.43,31.5)
  BOTTOM w0.089: v3(107.94,37.65) 107.82,37.65 107.27,37.1 107.27,36 107.24,35.98 107.24,35.77 107.07,35.59 U0400.AW5
  BOTTOM w0.102: R1021.2 97.43,31.39 v1(97.43,31.5) ; v1(56.16,20.63) 55.19,19.66 55.19,16.7 D3805.2
SRTC_RST#: length 26.8
  IN2 w0.109: v1(108.79,24.89) 108.98,24.7 v1(110.2,24.7) 110.28,24.7 111.1,25.52 111.1,27.4 110.89,27.61 110.89,30.99 110.68,31.19 110.68,32.33 111.58,33.23 111.71,33.23 112.52,34.04 112.52,40.29 111.81,41 111.81,41.38 111.43,41.76 111.18,41.76 v3(110.69,42.24)
  BOTTOM w0.102: R1009.2 110.64,24.06 111.11,24.53 T1000.1 110.23,24.73 v1(110.2,24.7) ; v1(108.79,24.89) 108.56,24.89 108.26,24.59 108.26,23.04 108.59,22.71 C1006.1 ; v3(110.69,42.24) 110.69,42.37 U0400.AN18
SSD1_PEDET_R: length 84.4
  TOP w0.102: R3107.1 R3114.2 217.05,3.53 217.02,3.56 R3106.1 215.42,3.56 v1(214.63,4.35)
  IN1 w0.102: v1(214.63,4.35) 215.23,4.95 215.23,14.63 210.46,19.41 209.1,19.41 204.37,14.68 v1(204.37,10.14)
  IN3 w0.102: v1(204.37,10.14) 202.98,10.14 202.5,9.66 165.35,9.66 163.65,11.36 161.29,11.36 v1(160.35,12.3)
  BOTTOM w0.102: CON3100.69 215.13,3.85 v1(214.63,4.35) ; v2(161.95,13.46) 161.52,13.46 v1(160.35,12.3) 160.79,11.85 Q3100.1
SSD_DEVSLP: length 6.2
  BOTTOM w0.076: U0400.J3 122.46,33.78 122.69,33.55 122.73,33.45 122.73,33.27 122.69,33.16 122.69,32.89 122.73,32.8 122.73,32.55 123.88,31.4 123.88,30.89
  BOTTOM w0.102: R1408.1 124.68,28.89 124.31,29.26 124.31,29.49 v2(124.13,29.67) 123.88,29.92 123.88,30.89
SUS_PWRGD: length 389.8
  TOP w0.102: v1(31.75,55.4) 31.72,55.43 31.06,55.43 v2(30.59,54.96) 30.3,54.66 21.74,54.66 21.46,54.38 v1(19.28,54.38) 18.54,54.38 R2404.1 ; R1220.2 63.35,13.36 63.25,13.46 63.25,14.86 63.47,15.09 63.47,16.48 v1(64.5,17.5) ; R1220.2 R1221.2 ; R1220.2 v1(63.35,11.86)
  IN1 w0.102: v1(172.57,41.63) 172.61,41.63 174.09,43.12 174.09,44.33 v1(175.41,45.65)
  IN2 w0.102: v1(71.37,7.27) 70.92,6.81 61.45,6.81 60.89,7.37 58.99,7.37 v1(58.52,6.9) ; v1(197.74,58.14) 197.46,58.42 195.28,58.42 194.46,57.6 194.46,54.68 191,51.21 184.91,51.21 182.84,49.13 182.28,49.13 178.49,45.34 175.72,45.34 v1(175.41,45.65) 174.77,45.65 172.82,47.59 172.82,47.72 172.13,48.42 171.48,48.42 170.72,49.18 165.38,49.18 164.39,50.17 159.97,50.17 159.59,50.55 155.19,50.55 154.33,49.69 154.33,45.57 159.16,40.74 159.16,33.87 156.64,31.35 148.98,31.35 146.75,29.11 141.66,29.11 138.96,26.42 135.94,26.42 135.89,26.47 133.93,26.47 133.59,26.13 132.52,26.13 131.47,25.07 131.47,22.1 130.1,20.73 129.34,20.73 128.02,19.41 122.09,19.41 121.69,19 118.69,19 117.86,18.16 115.63,18.16 115.02,17.55 113.4,17.55 112.83,18.13 110.63,18.13 110.11,18.64 106.85,18.64 106.52,18.32 105,18.32 104.47,18.85 95.83,18.85 94.74,17.76 81.75,17.76 78.73,14.73 75.23,14.73 74.97,14.99 73.43,14.99 73.01,14.57 69.29,14.57 68.12,15.74 68.12,16.06 67.61,16.56 64.09,16.56 63.71,16.95 62.09,16.95 61.48,17.55 55.36,17.55 54.3,18.62 47.14,18.62 46.79,18.98 43.73,18.98 38.99,23.72 38.99,34.06 37.57,35.49 37.57,38 34.75,40.82 34.75,44.38 34.09,45.04 34.09,49.51 31.75,51.84 v1(31.75,55.4)
  IN3 w0.102: v1(72.01,18.06) 71.93,18.14 65.14,18.14 v1(64.5,17.5) ; v1(71.37,7.27) 71.37,6.56 69.09,4.27 51.04,4.27 49.37,5.95 45.08,5.95 41.1,9.92 41.1,11.44 32.31,20.23 32.31,21.9 31.75,22.46 29.07,22.46 27.64,23.9 27.64,24.34 26.87,25.1 26.87,25.78 25.1,27.55 25.1,27.58 24.66,28.01 24.66,41.6 23.55,42.72 23.55,44.18 19.99,47.74 19.99,53.67 v1(19.28,54.38)
  BOTTOM w0.102: v1(63.35,11.86) 63.32,11.89 63.31,11.89 63.22,11.98 61.93,11.98 v2(60.63,10.68) 58.52,8.57 v1(58.52,6.9) ; U1201.2 72.18,17.88 v1(72.01,18.06)
  BOTTOM w0.203: PU8900.7 198.63,58.81 198.35,58.52 198.12,58.52 v1(197.74,58.14)
  BOTTOM w0.254: v1(172.57,41.63) 172.69,41.76 172.84,41.76 172.9,41.81 PR8702.1
SUSACK#: length 25.9
  TOP w0.102: R1229.1 90.6,29.57 v1(90.79,29.38)
  IN2 w0.102: v1(90.79,29.38) 92.28,30.86 93.98,30.86 94.36,31.24 94.36,31.79 94.81,32.24 101.87,32.24 104.77,35.13 106.35,35.13 108.38,37.16 109.6,37.16 109.75,37.32 109.75,38.38 v3(109.57,38.56)
  BOTTOM w0.089: v3(109.57,38.56) 109.58,38.56 109.58,38.86 U0400.AP11
  BOTTOM w0.102: v2(90.6,30.08) 90.6,29.57 v1(90.79,29.38)
SUSCLK: length 108.1
  TOP w0.102: R2329.2 45.8,42.5 45.52,42.22 v1(44.96,42.22)
  IN1 w0.102: v1(44.2,26.22) 44.53,26.22 47.65,23.09 47.65,21.05 50.48,18.22 57.74,18.22 60.34,15.62 64.03,15.62 64.72,16.31 69.9,16.31 70.76,17.17 75.76,17.17 76.09,17.5 76.4,17.5 77.44,18.54 79.71,18.54 80,18.84 80.77,18.84 81.96,20.03 83.12,20.03 83.87,19.28 85.95,19.28 87.59,20.92 87.59,23.03 87.78,23.22 87.78,24.26 89.48,25.96 90.25,25.96 90.67,26.39 v1(92.44,26.39)
  IN2 w0.102: v1(44.2,26.22) 44.6,26.62 45.72,26.62 48.69,29.59 48.69,36.66 47.3,38.05 46.69,38.05 44.95,39.79 44.95,42.22 v1(44.96,42.22)
  BOTTOM w0.076: U0400.BA17 105.13,42.45 104.86,42.18 103.68,42.18 103.38,41.88 102.77,41.88
  BOTTOM w0.102: 102.77,41.88 101.64,41.88 100.18,40.41 98.43,40.41 97.37,39.36 96.15,39.36 93.17,36.38 v2(93.17,35) 93.17,33.89 91.69,32.41 91.69,29.94 92.15,29.49 v2(92.15,27.51) 92.15,26.68 v1(92.44,26.39)
SYS_PWROK: length 139.4
  TOP w0.102: v1(29.71,45.91) 30.1,45.52 U2300.28 ; v1(62.84,14) 62.84,15.14 v2(63.04,15.34) 63.04,16.72 64.26,17.93 64.7,17.93 v1(65.11,17.53) ; R1211.1 R1212.1 127.53,25.3 127.36,25.12 127.36,24.33 124.57,21.54 123.5,21.54 v1(123.16,21.21)
  IN2 w0.102: v1(65.11,17.53) 65.72,16.92 67.58,16.92 68.35,16.15 68.35,15.84 69.39,14.8 72.92,14.8 73.33,15.22 75.07,15.22 75.32,14.96 78.63,14.96 81.68,18.01 90.35,18.01 91.8,19.46 98.52,19.46 98.75,19.23 104.47,19.23 105.16,18.54 106.43,18.54 107.34,19.45 110.2,19.45 110.49,19.17 110.49,18.83 110.97,18.35 112.92,18.35 112.99,18.29 115.44,18.29 115.54,18.39 117.75,18.39 118.59,19.23 121.59,19.23 123.16,20.81 v1(123.16,21.21) ; v1(29.71,45.91) 29.28,45.49 29.28,39.51 32.77,36.03 32.77,30.14 33.88,29.02 33.88,23.43 41.26,16.06 42.12,16.06 42.66,15.52 45.24,15.52 45.78,16.06 47.35,16.06 47.78,16.49 49.68,16.49 49.81,16.36 49.81,16.36 53.19,12.98 56.51,12.98 57.93,14.4 62.43,14.4 v1(62.84,14)
SYS_PWROK_R: length 28.1
  TOP w0.102: R1211.2 128.6,26.95 128.75,26.8 128.75,25.73 129.08,25.4 v2(129.08,24.18) 129.08,23.61 131.14,21.56 v1(132.74,21.56)
  IN3 w0.102: v1(129.59,34.98) 129.59,34.42 130.71,33.3 130.71,30.89 131.94,29.66 132.31,29.66 132.64,29.34 132.87,29.34 133.43,28.79 133.43,26.92 133.71,26.64 133.71,23.79 133.27,23.36 133.27,22.09 v1(132.74,21.56)
  BOTTOM w0.076: 129.54,34.98 128.4,34.98 127.61,35.77 127.2,35.77 127.1,35.82 126.59,35.82 U0400.B6
  BOTTOM w0.102: 129.54,34.98 v1(129.59,34.98)
SYS_RESET#: length 14.8
  TOP w0.102: v1(130.84,34.09) 131.45,34.09 132.27,33.26 135.55,33.26 136.5,34.22 138.48,34.22 v2(138.89,33.81) 138.91,33.78 R1205.2
  BOTTOM w0.076: U0400.B5 126.88,34.97 127.17,35.26 127.6,35.26 128.52,34.34 129.18,34.34
  BOTTOM w0.102: v1(130.84,34.09) 130.02,34.09 129.76,34.34 129.18,34.34
SYSPWR_PRES: length 6.5
  TOP w0.102: v2(47.86,39.5) 47.22,40.13 R2306.1 46.69,40.13 46.25,39.7 45.87,39.7 45.75,39.58 45.1,39.58 45.01,39.66 45.01,39.91 44.88,40.03 R2332.1 44.25,40.03 43.31,39.1 U2300.120
THERMAL_D+: length 145.3
  IN3 w0.254: v1(129.34,90.03) 130.29,89.08 130.45,89.08 130.78,88.75 130.78,87.58 140.08,78.29 143.97,78.29 144.48,78.79 147.75,78.79 148.34,78.21 148.34,77.18 151.27,74.25 156.14,74.25 160.38,70.01 160.38,69.15 160.82,68.7 160.82,65.81 163.74,62.9 166.45,62.9 167.11,63.56 168.73,63.56 172.52,59.77 176,59.77 178.26,62.03 190.91,62.03 192.79,63.91 192.79,67.59 193.19,68 195.48,68 v1(197.1,69.62)
  BOTTOM w0.254: v1(197.1,69.62) 197.03,69.7 197.03,70.33 197.51,70.82 199.95,70.82 v2(200.1,70.97) 200.25,70.82 202.21,70.82 206.3,74.9 206.3,80.47 205.06,81.71 203.38,81.71 202.36,82.74 202.36,86.24 202.11,86.49 202.11,98.45 205.18,101.52 205.18,103.08 203.96,104.29 C3706.1 203.96,106.38 202.81,107.53 Q3700.3 203.53,108.08 204.48,109.03 Q3700.1 ; v1(129.34,90.03) 129.19,89.89 U3700.2
THERMAL_D-: length 140.7
  IN3 w0.254: v1(130.05,90.05) 131.17,88.93 131.17,87.78 140.28,78.67 143.82,78.67 144.3,79.15 147.9,79.15 148.69,78.35 148.69,77.32 151.41,74.6 156.29,74.6 160.73,70.16 160.73,69.3 161.18,68.85 161.18,65.98 163.91,63.25 166.3,63.25 166.96,63.91 168.88,63.91 172.66,60.12 175.85,60.12 178.11,62.38 190.76,62.38 192.43,64.06 192.43,67.74 193.05,68.35 195.15,68.35 196.93,70.13 v1(197.51,70.13)
  BOTTOM w0.254: v1(197.51,70.13) 197.84,70.46 201.7,70.46 v2(201.9,70.26) 202.11,70.46 202.36,70.46 206.65,74.75 206.65,80.62 205.21,82.07 203.53,82.07 202.72,82.88 202.72,86.38 202.46,86.64 202.46,98.3 205.56,101.4 205.56,103.3 204.83,104.04 C3706.2 204.83,106.54 Q3700.2 ; U3700.3 129.56,90.54 v1(130.05,90.05)
THRMTRIP#: length 9
  BOTTOM w0.076: 128.12,68.2 127.52,68.2 127.49,68.18 127.22,68.18 127.13,68.2 126.89,68.2 126.76,68.18 126.54,68.18 126.51,68.19 126.49,68.2 126.3,68.32 126.14,68.32 126.09,68.36 U0400.C63
  BOTTOM w0.102: R0417.2 132.48,63.79 131.65,64.62 131.65,64.8 130.86,65.59 130.86,65.89 130.32,66.43 130.32,66.75 128.86,68.2 128.12,68.2
TOUCHPAD_INTR#_CON: length 16.4
  TOP w0.102: R5102.2 54.72,8.91 v1(54.76,8.94) ; v2(45.73,10.3) v1(46.25,9.77)
  IN1 w0.102: v1(54.76,8.94) 54.48,8.66 51.95,8.66 51.73,8.87 47.41,8.87 46.87,9.41 46.62,9.41 v1(46.25,9.77)
  BOTTOM w0.102: v1(46.25,9.77) 45.98,9.5 45.09,9.5 44.83,9.25 44.83,7.28 44.59,7.04 Q5102.4 ; CON5100.4 54.73,9.33 54.76,9.3 v1(54.76,8.94)
TP_CATERR#_R: length 6.6
  BOTTOM w0.076: 127.74,68.01 127.19,68.01 127.11,68.03 126.9,68.03 126.77,68.01 126.52,68.01 126.44,68.03 126.25,68.15 125.87,68.15 125.58,68.44 U0400.D63
  BOTTOM w0.102: T0410.1 130.13,65.88 130.13,66.67 128.79,68.01 127.74,68.01
TP_EN#: length 79.3
  TOP w0.102: v1(28.09,35.99) 27.99,35.9 U2300.49 25.91,35.9 25.8,35.79 25.46,35.79 25.23,36.03 25.23,36.17 24.6,36.79 R2335.2 ; v1(18.09,16.97) 17.45,16.33 v2(14.58,16.33) C5131.2
  IN2 w0.102: v1(45.65,5.22) 44.95,4.52 32.45,4.52 23.56,13.41 21.23,13.41 18.09,16.56 v1(18.09,16.97)
  BOTTOM w0.102: Q5102.2 45.24,4.81 v1(45.65,5.22) 46.09,5.67 46.51,5.67 47.35,6.5 47.35,11.61 46.57,12.38 Q5101.1 ; v1(28.09,35.99) 27.57,35.47 27.57,29.84 29.26,28.15 29.26,25.96 23.77,20.47 23.77,19.46 21.29,16.97 v1(18.09,16.97)
TP_WAKE_KBC#: length 139.7
  TOP w0.102: v1(44.17,10.04) 44.17,10.04 43.69,9.55 42.69,9.55 41.75,10.49 41.1,10.49 38,13.59 38,19.92 v1(38.63,20.55) ; R2334.2 25.53,43.21 25.53,42.8 26.03,42.3 U2300.33 28.52,42.3 30.24,40.58 34.78,40.58 36.91,38.45 v1(36.91,38.05)
  IN2 w0.102: v1(36.91,38.05) 37.34,37.62 37.34,35.31 38.1,34.55 38.1,21.09 v1(38.63,20.55) 40.71,20.55 42.94,18.32 42.95,18.32 42.97,18.29 46.33,18.29 46.33,18.29 46.5,18.29 47.01,17.78 53.21,17.78 v1(54.09,16.91)
  IN3 w0.102: v1(94.92,27.26) 94.99,27.26 95.68,26.56 95.68,26.22 93.39,23.93 91.27,23.93 91.27,23.93 90.76,23.93 90.76,23.93 90.74,23.93 90.4,23.58 90.4,22.79 89.2,21.59 82.07,21.59 80.91,22.75 76.24,22.75 73.1,19.61 73.1,18.58 72.17,17.66 66.03,17.66 65.44,17.07 64.11,17.07 63.83,17.35 54.53,17.35 v1(54.09,16.91)
  BOTTOM w0.076: U0400.BA5 104.97,34.92 104.19,34.92 103.91,34.64
  BOTTOM w0.102: 103.91,34.64 103.91,29.26 103.64,29 102.09,29 102.06,29.02 100.39,29.02 100.13,28.76 96.13,28.76 94.92,27.55 v1(94.92,27.26) 94.59,26.93 v2(93.9,26.93) ; v1(44.17,10.04) 44.17,9.5 44.58,9.1 44.58,7.32 44.26,7 44.26,4.92 44.59,4.59 Q5102.3
TPM_GPIO2: length 5
  TOP w0.102: v2(35.79,55.6) 35.49,55.6 35.03,56.07 35.03,57.53 34.93,57.64 R3903.1 34.57,57.97 34.77,58.17 35.15,58.17 35.73,58.75 U3901.29
TPM_ID: length 18.7
  TOP w0.102: R1017.2 124.43,24.46 124.49,24.51 R1018.1 124.87,23.9 v1(124.38,23.42) 123.88,23.42 v2(123.7,23.6)
  IN3 w0.102: v3(124.86,35.76) 123.7,34.6 123.7,32.82 124.08,32.44 124.08,31.32 125.53,29.87 125.53,29.29 124.03,27.79 124.03,23.78 v1(124.38,23.42)
  BOTTOM w0.102: U0400.D8 125.48,36.79 124.99,36.3 124.99,35.89 v3(124.86,35.76)
TPM_PP: length 5.5
  TOP w0.102: U3901.4 38.2,61.07 38.57,60.7 38.57,60.21 38.81,59.97 R3904.1 39.29,59.64 39.42,59.51 40.82,59.51 41.38,58.96 v2(41.38,58.35)
TPM_RST#: length 3.9
  TOP w0.102: U3901.17 33.14,64.3 33.48,64.64 33.48,64.8 33.6,64.92 R3905.1 34.11,64.92 34.34,64.7 v1(34.34,64.33)
  BOTTOM w0.102: v2(34.34,63.68) v1(34.34,64.33)
TPM_SPI_CLK: length 6.2
  TOP w0.102: v2(30.05,64.82) 30.05,64.97 30.67,65.59 31.19,65.59 31.7,65.08 R3907.1 31.7,64.39 32.2,63.89 32.2,62.52 32.65,62.07 U3901.19
TPM_SPI_IRQ#: length 156.7
  TOP w0.102: v1(30,65.81) 30.18,65.81 30.43,66.07 31.39,66.07 v2(32.17,65.29) 32.23,65.36 32.89,65.36 33.02,65.23 R3916.2 32.92,64.92 32.68,64.69 32.68,62.69 32.81,62.57 U3901.18
  IN2 w0.102: v1(30,65.81) 30,64.91 30.68,64.22 30.68,59.4 32.33,57.75 32.33,51.77 35.28,48.82 35.28,44.28 35,44 35,41.15 36.84,39.31 37.6,39.31 38.48,38.43 38.48,35.25 39.45,34.28 39.45,26.96 42.55,23.87 42.55,23.68 44.25,21.98 44.25,21.65 45.37,20.53 48.57,20.53 49.46,21.42 51,21.42 51.89,20.53 54.26,20.53 55.89,18.9 62.01,18.9 62.34,18.57 63.45,18.57 63.93,19.05 65.83,19.05 66.65,18.24 68.93,18.24 69.69,17.48 70.61,17.48 70.71,17.38 74.64,17.38 77.27,20.01 78.56,20.01 82,23.45 84.86,23.45 87.22,21.08 88.98,21.08 90.35,22.46 95.94,22.46 96.72,23.23 97.64,23.23 98.82,24.41 100.51,24.41 101.3,23.63 102.85,23.63 103.05,23.42 106.15,23.42 106.39,23.18 112.21,23.18 113.29,22.1 113.97,22.1 114.17,22.3 116.71,22.3 117.58,23.17 118.48,23.17 119.17,23.85 122.15,23.85 122.71,24.41 122.71,25.14 122.21,25.63 122.21,26.09 v1(123.16,27.04)
  BOTTOM w0.076: U0400.M2 121.13,33.35 121.39,32.83 121.4,32.77 121.4,32.71 121.52,32.59 121.52,31.6 122.23,30.89
  BOTTOM w0.102: v1(123.16,27.04) 122.83,27.37 122.83,27.49 122.3,28.03 122.3,28.91 122.58,29.19 122.77,29.19 123.05,29.47 123.05,30.07 122.23,30.89
