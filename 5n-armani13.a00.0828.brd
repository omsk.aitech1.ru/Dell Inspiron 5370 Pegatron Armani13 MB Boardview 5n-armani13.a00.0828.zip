# Allegro board 5n-armani13.a00.0828.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
WEA0#: length 44.4
  TOP w0.127: U6801.G12 188.56,97.37 v1(187.77,97.37) 186.75,97.37 184.73,95.35 183.35,95.35 183.22,95.48 183.22,96.64 183.1,96.76 182.84,96.76 182.69,96.61 v2(182.69,95.71) 182.69,94.9 182.56,94.77 182.31,94.77 182.18,94.9 182.18,96.64 182.05,96.76 181.83,96.76 181.67,96.61 181.67,94.9 181.55,94.77 181.29,94.77 181.17,94.9 181.17,96.64 181.04,96.76 180.81,96.76 180.66,96.61 180.66,94.9 180.53,94.77 180.28,94.77 180.15,94.9 180.15,96.64 180.02,96.76 179.79,96.76 179.67,96.64 179.67,95.48 179.54,95.35 179.29,95.35 179.16,95.48 179.16,96.64 179.03,96.76 178.78,96.76 178.65,96.64 178.65,95.48 178.52,95.35 178.27,95.35 178.14,95.48 178.14,96.64 178.02,96.76 177.76,96.76 177.64,96.64 177.64,95.48 177.51,95.35 177.25,95.35 177.13,95.48 177.13,96.64 177,96.76 176.75,96.76 176.62,96.64 176.62,95.48 176.49,95.35 176.24,95.35 176.11,95.48 176.11,96.64 175.98,96.76 175.65,96.76 174.42,95.53 173.23,95.53 172.47,94.77 171.3,94.77 v1(170.86,95.21)
  BOTTOM w0.127: v1(187.77,97.37) 188.56,97.37 U6801.G12 ; U6000.G25 170.45,95.62 v1(170.86,95.21)
WEA1#: length 49.9
  TOP w0.127: U6803.L12 195.78,78.39 195.77,78.39 195.77,78.39 ; 195.77,78.39 195.76,78.39 193.82,78.39 192.79,79.41 192.79,80.36 192.68,80.47 192.44,80.47 192.34,80.57 192.34,82.61 192.47,82.74 192.66,82.74 192.79,82.86 192.79,83.12 192.66,83.24 192.47,83.24 192.34,83.37 192.34,86.36 190.66,88.04 185.35,88.04 185.12,87.81 v2(184.07,87.81) 183.19,87.81 182.95,88.04 179.04,88.04 178.59,88.5 174.78,88.5 174.4,88.88 173.58,88.88 172.05,90.41 170.37,90.41 170,90.05 170,89.62 169.6,89.22 168.4,89.22 168,88.82 168,87.63 168.43,87.2 170.59,87.2 171.12,86.67 171.12,85.27 171.32,85.07 171.32,84.31 170.69,83.67 169.67,83.67 v1(169.22,83.21) ; 195.77,78.39 v1(195.77,78.41)
  BOTTOM w0.102: U6000.H10 169.62,83.62 v1(169.22,83.21)
  BOTTOM w0.127: v1(195.77,78.41) 195.77,78.39 196.16,78 U6803.L12
WHITE_LED_ON#: length 22.6
  TOP w0.102: R5000.2 13.56,92.05 14.02,92.51 16.03,92.51 16.54,93.02 19.36,93.02 20.8,91.57 20.8,87.58 20.36,87.14 v1(19.44,87.14) 19.44,86.86 v2(19.74,86.57)
  BOTTOM w0.102: Q5000.6 20.67,84.77 20.29,85.14 20.29,86.08 19.98,86.4 17.52,86.4 17.39,86.53 Q5002.3 17.72,87.01 18.01,86.72 19.02,86.72 v1(19.44,87.14)
WIFI_RF_EN: length 138
  TOP w0.102: v1(154.94,12.3) 155.4,12.75 156.44,12.75 157.05,13.36 163.99,13.36 165.24,12.12 171.58,12.12 172.34,12.88 176.23,12.88 176.94,12.17 187.39,12.17 188.43,13.21 198.88,13.21 202.22,16.55 v1(203.5,16.55)
  IN2 w0.102: v1(204.25,40.64) 204.88,41.27 205.24,41.27 207.39,39.12 207.39,20.97 205.77,19.35 205.77,18.55 203.76,16.55 v1(203.5,16.55)
  IN3 w0.102: v1(154.94,12.3) 153.67,13.56 150.54,13.56 150.12,13.15 148.15,13.15 147.01,12.01 138.19,12.01 137.9,11.71 132.95,11.71 131.86,12.8 131.86,19.37 133.5,21.01 133.5,23.3 133.91,23.7 133.91,26.72 133.63,27 133.63,28.88 133.2,29.31 133.2,30.01 132.6,30.61 131.42,30.61 130.91,31.12 130.91,33.4 130.18,34.14 v1(130.18,34.78)
  BOTTOM w0.076: 129.54,35.38 129.29,35.38 129.06,35.16 128.45,35.16 127.67,35.94 127.22,35.94 127,36.05 U0400.B7
  BOTTOM w0.102: CON5103.38 205.37,41.76 v1(204.25,40.64) ; v1(130.18,34.78) 130.18,34.97 129.76,35.38 129.54,35.38 ; v2(154.43,13.08) 154.94,12.58 v1(154.94,12.3)
XCLK_BIASREF: length 11.1
  TOP w0.102: R1005.2 126.54,52.66 127,53.11 127.51,53.11 127.64,53.24 128.19,53.24 128.63,52.81 R1006.1 129.24,52.81 v1(129.34,52.71)
  IN1 w0.097: v3(125.11,56.56) 127.75,56.56 128.35,55.96 128.35,53.7 v1(129.34,52.71)
  BOTTOM w0.102: v3(125.11,56.56) 124.95,56.4 U0400.E42
XDP_PRDY#: length 6.8
  TOP w0.102: v1(129.59,63.43) 129.59,62.67 129.08,62.16 T1400.1
  BOTTOM w0.076: U0400.D56 125.6,64.36 125.82,64.36 125.86,64.32 126.16,64.32 126.18,64.34 126.44,64.34 126.57,64.21 128.66,64.21 128.83,64.05 129.17,64.05 129.18,64.03
  BOTTOM w0.102: 129.18,64.03 129.59,63.62 v1(129.59,63.43)
XDP_PREQ#: length 8.1
  BOTTOM w0.076: 129.18,67.1 129.1,67.1 128.93,66.93 127.64,66.93 127.53,66.83 127.14,66.83 126.98,66.99 126.98,67.18 126.77,67.38 125.64,67.38 U0400.D61
  BOTTOM w0.102: 129.18,67.1 129.42,67.1 129.8,66.73 129.8,65.52 130.73,64.59 T1401.1
XRES: length 6
  TOP w0.102: U5800.10 44.08,78.99 45.01,79.91 C5807.1 R5802.1 45.01,82.1 v1(44.53,82.59)
  BOTTOM w0.102: T5802.1 44.53,83.06 44.53,82.59 v1(44.53,82.59)
XTAL_24M_IN: length 7.7
  BOTTOM w0.102: U0400.E37 124.99,53.65 125.22,53.88 125.5,53.88 125.54,53.83 125.8,53.83 125.84,53.88 126.15,53.88 126.19,53.83 126.45,53.83 126.79,54.18 128.17,54.18 128.65,53.7 130.78,53.7 131.12,54.03 R1001.1
XTAL_24M_IN_R: length 6.6
  BOTTOM w0.102: v2(135.45,56.03) X1000.3 135.45,54.55 134.65,53.75 132.97,53.75 132.61,54.1 C1001.2 132.54,53.34 R1000.2 132.13,53.34 131.95,53.16 R1001.2
XTAL_24M_IN_R_U42: length 4.9
  BOTTOM w0.102: v2(127.13,29.09) 127.18,29.03 R0904.2 127.18,27.79 127.41,27.56 C0900.2 R0903.2 128.17,26.75 128.63,26.29 128.63,25.9 X0900.3
XTAL_24M_IN_U42: length 8.2
  BOTTOM w0.076: U0400.E3 125.02,33.79 124.73,33.49 124.73,32.58 125.25,32.07
  BOTTOM w0.102: R0904.1 128.04,28.22 128.35,28.53 128.35,29.03 127.71,29.67 126.87,29.67 126.57,29.97 126.32,29.97 125.25,31.05 125.25,32.07
XTAL_24M_OUT: length 8.3
  BOTTOM w0.076: U0400.E35 125.1,53.27 126.76,53.27 126.96,53.46 126.96,53.76
  BOTTOM w0.102: 126.96,53.76 127.05,53.85 128.19,53.85 128.58,53.47 129.82,53.47 v2(130.73,52.55) 130.88,52.4 R1020.1
XTAL_24M_OUT_R: length 3
  BOTTOM w0.102: X1000.1 133.15,52.48 R1000.1 C1000.2 132.13,51.72 131.95,51.54 R1020.2
XTAL_24M_OUT_R_U42: length 6.2
  BOTTOM w0.102: X0900.1 130.37,24.56 130.25,24.69 129.46,24.69 129.34,24.82 129.34,26.34 129.03,26.65 R0903.1 129.31,27.21 129.46,27.36 C0901.2 129.77,27.74 129.67,27.84 R0905.2
XTAL_24M_OUT_U42: length 10.7
  BOTTOM w0.102: U0400.C7 125.65,35.88 125.65,34.8 125.35,34.49 125.35,33.87 125.28,33.81 125.28,33.55 125.36,33.48 125.36,32.5 125.45,32.41 125.45,31.11 126.4,30.17 127.54,30.17 128.14,29.57 128.6,29.57 v2(128.91,29.26) 128.8,29.16 R0905.1
XTALIN: length 15.1
  BOTTOM w0.102: R6900.1 147.68,87.81 147.8,87.94 147.8,88.19 147.9,88.29 C6900.1 R6942.1 148.94,87.51 149.45,88.02 v2(149.45,89.97) 149.45,92.77 150.25,93.56 150.25,96.85 151.63,98.23 151.81,98.23 U6000.AM28
XTALIN_GR: length 2.7
  BOTTOM w0.102: v2(146.99,89.51) 147.32,89.18 147.32,88.67 146.66,88.67 146.5,88.83 X6900.1
XTALOUT: length 19.4
  BOTTOM w0.102: X6900.3 144.67,86.63 144.77,86.73 144.77,87.23 145.19,87.66 146.69,87.66 C6901.1 147.7,86.64 R6942.2 148.69,86.64 v2(149.72,87.67) 149.89,87.84 149.89,92.62 150.65,93.39 150.65,96.68 151.46,97.49 152.02,97.49 152.23,97.7 152.51,97.7 U6000.AK28
ZVM#: length 1.6
  TOP w0.102: T0905.1 108.64,64.42 108.64,64.42 v3(108.87,64.19)
  BOTTOM w0.076: U0400.AR56 109.08,64.41 v3(108.87,64.19)
N50493: length 4.1
  TOP w0.102: v1(46.08,7.13) v2(44.58,7.13) 43.7,7.13 43.64,7.19 R5107.2
  BOTTOM w0.102: Q5102.6 45.89,6.94 v1(46.08,7.13)
N64175: length 14.2
  IN2 w0.508: v1(160.45,17.78) 160.45,18.04 160.96,18.54 169.19,18.54 v1(169.38,18.35)
  BOTTOM w0.356: v1(169.38,18.35) CON5101.4
  BOTTOM w0.432: v2(160.45,17.15) v1(160.45,17.78) 160.45,18.06 160.78,18.39 162.51,18.39 Q5100.3
N16940974: length 5.9
  TOP w0.102: v1(15.16,91.16) 15.16,91.69 14.6,92.26 14.16,92.26 13.03,91.13 13.03,89.99 R5907.1
  BOTTOM w0.102: v1(15.16,91.16) 15.19,91.19 U5900.14
N16941233: length 3.9
  BOTTOM w0.102: R5905.2 21.08,88.47 20.93,88.62 18.34,88.62 18.18,88.78 U5900.8
N16941314: length 2
  TOP w0.102: R2104.1 46.79,52.81 v2(46.18,52.81)
  TOP w0.254: R2104.1 C2109.2
N17285432: length 7.1
  TOP w0.102: v2(219.72,7.84) 220.19,7.37 v1(220.4,7.37) 221.11,7.37 221.36,7.11 C3115.1 220.85,6.73 220.68,6.56 R3103.2
  BOTTOM w0.102: v1(220.4,7.37) 220.55,7.37 221.78,8.6 CON3100.50
N19673410: length 20.4
  IN3 w0.102: v3(110.7,38.58) 111.12,38.17 111.12,35.53 111.05,35.46 111.05,33.58 110.4,32.94 110.4,28.35 110.69,28.06 110.69,24.62 110.37,24.3 110.03,24.3 108.26,26.07 v1(107.28,26.07)
  BOTTOM w0.076: v3(110.7,38.58) 110.7,38.44 U0400.AM10
  BOTTOM w0.102: v1(107.28,26.07) 107.94,26.07 T1206.1
N31955539: length 8.7
  BOTTOM w0.076: 113.7,32.22 113.7,32.62 113.61,32.84 113.57,32.93 113.57,33.41 113.18,33.81 U0400.AG3
  BOTTOM w0.102: 113.7,32.22 113.7,31.25 113.56,31.11 113.56,30.56 113.13,30.13 112.46,30.13 112.25,29.92 112.25,29.69 111.99,29.43 R1410.1 112.19,28.96 112.45,28.7 112.45,27.82 112.42,27.79 111.95,27.32 v2(111.73,27.32)
N42937574: length 14.3
  TOP w0.102: v2(127.08,27.36) 127,27.36 126.57,27.79 R0414.2 125.83,27.79 125.44,28.18 125.44,29.89 124.59,30.74 124.59,31.69 122.5,33.78 121.67,33.78 120.49,34.96 120.49,36.42 v3(119.88,37.04)
  BOTTOM w0.076: v3(119.88,37.04) 120.08,37.04 U0400.N8
N144273293: length 2.1
  TOP w0.102: R2006.1 C2008.2 58.36,49.24 v2(57.96,48.85)
N144773302: length 3.2
  BOTTOM w0.432: 200.74,38.25 PC8909.1 v2(201.52,35.87)
N144773400:
  vias: v2(178.71,57.91)
N145129059:
  vias: v2(50.83,18.47)
N145246305: length 4.4
  TOP w0.254: v2(144.51,69.41) v1(144.04,68.94) 144.15,68.84 PR8009.1
  BOTTOM w0.152: PJP8002.1 145.59,69.83 145.36,69.6
  BOTTOM w0.254: v1(144.04,68.94) 144.04,69.37 144.27,69.6 145.36,69.6
N145248377: length 6.1
  BOTTOM w0.152: PJP7901.1 145.8,47.27 145.59,47.07
  BOTTOM w0.254: 145.59,47.07 144.58,47.07 144.4,46.89 144.4,44 PR7904.1 PR7906.1
N145248379: length 7.7
  BOTTOM w0.102: PR7921.1 142.65,43.77 141.86,42.98 v2(141.86,42.67)
  BOTTOM w0.152: 142.7,47.04 142.6,47.14 PJP7902.1
  BOTTOM w0.254: 142.7,47.04 142.75,46.99 143.79,46.99 143.92,46.87 143.92,43.97 PR7905.1 PR7921.1
N145785510: length 3.7
  TOP w0.254: R5803.2 R5804.2 C5804.1 41.25,81.05 41.58,80.72 v2(41.58,80.42) 41.58,80.42 41.66,80.34 U5800.13
N146310019: length 3.8
  TOP w0.102: v2(142.72,69.55) 142.72,69.45 v1(143.23,68.94)
  TOP w0.254: PR8010.1 143.21,68.91 v1(143.23,68.94)
  BOTTOM w0.152: PJP8003.1 142.39,69.78 142.52,69.65
  BOTTOM w0.254: 142.52,69.65 142.93,69.65 143.23,69.34 v1(143.23,68.94)
N146862019: length 4.1
  TOP w0.102: v2(152.1,19.84) 151.82,20.12 R3703.1
  TOP w0.254: U3701.3 152.89,21.24 152.71,21.06 R3701.2 R3703.1
N146862127: length 2.2
  TOP w0.254: U3701.2 152.7,21.74 152.58,21.62 v2(152.2,21.62) 151.84,21.62 151.46,22 R3700.2
N146967179: length 3.5
  BOTTOM w0.102: U1203.4 98.72,24.4 98.48,24.16 R1227.2 97.84,23.75 97.71,23.62 v2(96.08,23.62)
N146992205: length 22.6
  TOP w0.254: PR7601.1 70.49,110.44 v1(70.59,110.54) 70.69,110.44 PR7646.1
  BOTTOM w0.254: v1(70.59,110.54) 69.67,109.63 51.89,109.63 v1(50.29,108.03)
  vias: v2(48.77,108.54)
N146992240: length 3.1
  TOP w0.102: PQ7606.1 68.99,109.31 68.71,109.03 v2(68.71,108.51)
  TOP w0.254: PQ7606.1 69.75,109.81 69.76,109.82 PR7601.2
N147117574: length 4.4
  TOP w0.102: v2(21.73,53.49) 21.67,53.43 R2407.2 19.19,52.45 19.06,52.58 Q2400.3
N147117610: length 6.6
  TOP w0.102: v2(19.71,49.23) Q2400.5 19.71,51.51 19.84,51.64 20.22,51.64 20.36,51.5 Q2400.6 20.36,50.27 20.49,50.14 21.29,50.14 R2408.1 R2406.2
N147136954: length 5.6
  TOP w0.254: R5109.1 42.09,8.97 41.63,9.43 v1(41.63,10.04) 41.02,10.04 v2(40.84,9.86)
  BOTTOM w0.254: Q5101.3 42.29,11.43 41.63,10.77 v1(41.63,10.04)
N147156627: length 3.2
  BOTTOM w0.102: R3607.2 138.42,17.45 v2(138.15,17.17) 137.8,16.82 137.52,16.82 137.03,16.33 CON3601.6
N147808873: length 2.2
  TOP w0.102: v1(40.95,80.39) 41.16,80.18 U5800.14
  BOTTOM w0.102: v1(40.95,80.39) 40.31,81.03 T5805.1
N147968556: length 5.3
  TOP w0.102: PQ7603.2 65.84,100.43 66.7,101.3 PR7615.2 PR7616.1 68.28,101.12 68.83,101.12 v2(69.37,101.65)
N147968560: length 4.2
  TOP w0.102: PR7617.2 PC7604.1 ; PR7617.2 67.51,98.02 67.23,98.3 66.61,98.3 66.49,98.17 PQ7603.6 ; PR7617.2 67.92,98.94 v2(67.97,98.99)
N147968575: length 10.5
  TOP w0.102: PC7604.2 PR7618.1 v2(70.95,98.28) 70.95,99.73 70.71,99.96 68.29,99.96 67.35,99.03 66.91,99.03 65.84,97.95 PQ7603.5
N148388543: length 9.1
  TOP w0.102: R2411.2 R2409.2 26.92,23.73 26.67,23.47 C2400.1 27.13,23.32 27.15,23.29 R2410.2 27.56,22.02 27.7,21.89 Q2401.6 29.02,21.89 29.16,22.02 29.49,22.02 29.72,21.8 29.72,21.59 30.1,21.21 R2414.1 30.1,20.27 29.74,19.92 v2(29.74,19.46)
N148505031: length 31.5
  TOP w0.102: v1(17.48,16.97) v2(15.9,18.54) 14.37,20.07 D2401.1 ; v1(35.84,23.8) 36.17,23.8 36.37,24.01 R2400.2
  BOTTOM w0.102: v1(17.48,16.97) 19.56,14.89 24.2,14.89 28.67,19.36 31.39,19.36 v1(35.84,23.8)
N148505032: length 5.5
  TOP w0.102: R2403.2 R2424.2 11.94,19.15 10.26,19.15 10.07,19.35 D2401.2 v2(10.07,21.21)
N148738573: length 4.2
  BOTTOM w0.102: 14.94,74.81 14.58,75.16 v2(14.58,76.48)
  BOTTOM w0.254: Q5800.1 14.21,74.18 14,74.4 C5809.1 R5813.1
N148738591: length 5.9
  BOTTOM w0.254: v2(15.16,69.75) Q5800.3 15.65,71.43 R5815.2 17.2,72.29 17.71,72.81 U5802.3
N148740165: length 3.8
  BOTTOM w0.102: v2(24.05,72.37) 23.57,71.88 R5819.2
  BOTTOM w0.254: U5802.4 22.55,72.81 R5820.1 R5819.2
N148743428: length 8.3
  BOTTOM w0.102: R5723.2 21.96,81.75 21.97,81.74 R5721.2 21.56,81.31 21.03,81.84 21.03,81.99 20.83,82.2 20.83,82.76 21.03,82.96 21.03,83.14 v2(20.65,83.52) 18.63,83.52 17.68,82.56 U5702.3
N148743430: length 9.7
  IN1 w0.102: v1(21.31,82.4) 21.44,82.27 21.44,80.65 v1(21.39,80.6)
  BOTTOM w0.102: R5724.2 21.59,80.39 v1(21.39,80.6) 20.55,81.43 20.55,81.99 20.37,82.17 20.37,82.93 20.27,83.04 v2(18.92,83.04) 18.59,83.04 18.08,82.52 U5702.4 ; R5722.2 21.44,82.64 21.44,82.53 v1(21.31,82.4)
N148861333: length 6.4
  TOP w0.102: v2(76.76,16.33) 76.68,16.41 76.68,17.3 76.78,17.3 77.42,16.66 78.33,16.66 78.46,16.79 v1(78.46,17.32)
  BOTTOM w0.102: Q1901.2 78.78,17 v1(78.46,17.32) 78.3,17.48 77.73,17.48 77.25,17 Q1901.5
N148862035: length 5.6
  BOTTOM w0.102: Q1900.2 Q1900.5 18.9,44.43 18.85,44.38 R1913.2 18.76,43.83 18.39,43.46 18.39,42.34 v2(18.26,42.22)
N151615972: length 6.3
  BOTTOM w0.356: Q3101.6 155.88,16.01 155.75,16.14 155.75,16.54 155.88,16.66 Q3101.5 157.1,16.66 157.25,16.51 157.76,16.51
  BOTTOM w0.432: R3109.2 157.63,18.24 v2(157.89,17.99) 158.08,17.8 158.08,16.83 157.76,16.51
N151647275: length 16.6
  TOP w0.102: v2(86.79,9.98) R1920.2 87.58,11.02 v1(87.38,11.23)
  BOTTOM w0.102: 78.33,14.51 78.08,14.76 Q1902.5 ; 78.33,14.51 78.33,14.19 79.67,12.85 80.26,12.85 80.44,12.68 80.44,11.89 80.65,11.69 82.14,11.69 82.27,11.56 83.08,10.75 83.64,10.75 84.65,11.75 86.85,11.75 v1(87.38,11.23) ; 78.33,14.51 78.59,14.76 Q1902.2
N151759903: length 2.8
  TOP w0.102: T2308.1 25.86,28.99 25.86,30.17 25.98,30.3 U2300.63
N151878978: length 15.7
  TOP w0.102: U5703.17 29.59,83.7 v1(29.67,83.62)
  IN2 w0.102: v1(29.67,83.62) 30.64,84.59 v1(30.64,87.04)
  BOTTOM w0.102: v1(30.64,87.04) 27.6,87.04 27.2,87.43 24.31,87.43 23.37,86.49 23.37,85.04 23.24,84.91 R5709.2 ; v2(29.03,83.62) v1(29.67,83.62)
N151977162: length 18
  TOP w0.102: v3(107.32,37.72) 106.6,38.43 106.6,38.88 104.34,41.15 103.69,41.15 102.25,42.6 97.86,42.6 97.43,42.18 95.34,40.08 T1500.1
  BOTTOM w0.076: v3(107.32,37.72) 107.19,37.72 106.5,37.03 U0400.AY8
N151977628: length 6.5
  BOTTOM w0.102: v2(19.02,53.09) 19.02,53.88 18.75,54.15 PQ7602.3 20.04,55.4 20.55,54.89 PQ7601.5 20.55,53.65 21.03,53.16 PR7609.2
N152024780: length 2.9
  TOP w0.102: PR8812.1 46.96,13.62 47.12,13.77 PD8800.2 47.86,13.77 v2(48.87,14.79)
N152371418: length 6.6
  BOTTOM w0.102: Q0400.1 137.75,76.19 137.59,76.35 135.62,76.35 134.78,75.52 C0400.1 R0418.2 134.52,74.58 v2(135.03,74.07)
N152371714: length 4.4
  BOTTOM w0.102: Q0400.3 136.8,77.47 136.58,77.25 R0416.1 134.11,77.78 v2(134.4,78.07)
N152454489: length 3.6
  TOP w0.102: v2(177.09,34.19) v1(177.09,33.48)
  BOTTOM w0.254: PU8700.3 176.38,34.37 176.35,34.34 PC8705.1 177.01,33.56 v1(177.09,33.48) PR8711.2
N152454517: length 1.4
  BOTTOM w0.102: PR8705.1 173.66,38.38 173.88,38.16 PU8700.11
N152454563: length 5.5
  TOP w0.102: v1(175.17,40.13) 175.36,40.33 v2(176.99,40.33)
  BOTTOM w0.102: PR8706.1 174.35,40.08 174.45,40.19 175.12,40.19 v1(175.17,40.13) 175.31,39.99 175.31,38.59 175.38,38.51 PU8700.14
N152454665: length 4.6
  BOTTOM w0.254: PR8710.2 172.93,28.98 173.05,28.86 174.45,28.86 174.57,28.98 PC8704.2 174.98,29.87 PR8709.1 v2(176.25,29.87)
N152619359: length 6
  BOTTOM w0.152: PJP7903.1 145.19,61.19 144.75,60.76
  BOTTOM w0.254: PR7911.1 PR7910.1 143.99,58.78 143.99,60.48 144.27,60.76 144.75,60.76
N152619365: length 5.8
  BOTTOM w0.152: 142.19,60.76 141.96,60.99 PJP7904.1
  BOTTOM w0.254: 142.19,60.76 143.08,60.76 143.59,60.25 143.59,58.68 PR7912.1 142.62,58.07 142.55,58.14 PR7922.1
N152623996: length 8.4
  BOTTOM w0.102: PR8005.1 144.48,33.68 143.33,33.68 142.88,33.23 v2(142.88,32.26)
  BOTTOM w0.152: 144.5,37.24 PJP8001.1
  BOTTOM w0.254: 144.5,37.24 144.86,37.24 145.33,36.76 145.33,34.26 144.91,33.84 PR8005.1
N152624000: length 5.3
  BOTTOM w0.152: 146.99,37.11 PJP8000.1
  BOTTOM w0.254: PR8004.1 145.82,34.09 145.69,34.22 145.69,36.62 146.19,37.11 146.99,37.11
N152659585: length 6.8
  BOTTOM w0.102: U0400.AG4 113.63,34.2 113.75,34.2 114.21,33.75 114.21,32.56 114.39,32.38 114.39,31.19 114.11,30.91 114.11,30.37 113.63,29.89 113.63,29.76 R1411.1
N152732906: length 1.8
  TOP w0.102: U2300.96 40.9,27.61 41.3,27.21 T2300.1
N152732920: length 3.5
  TOP w0.102: U2300.97 43.41,29.9 43.68,29.63 43.68,29.23 44.3,28.6 T2303.1
N152732948: length 5.4
  TOP w0.102: T2302.1 22.89,40.57 24.88,40.57 25.68,39.77 25.68,39.42 26.01,39.1 U2300.41
N152733148: length 2.7
  TOP w0.102: T2301.1 25.7,41.9 U2300.34
N152789464: length 13.9
  TOP w0.254: v2(74.6,105.9) 74.6,106.05 73.77,106.87 PR7621.1 PR7620.2 ; PR7620.2 73,106.12 72.9,106.02 PQ7605.5 71.5,106.02 70.97,106.56 70.97,107.62 70.58,108.01 PQ7606.3 ; PR7620.2 74.17,105.59 74.17,104.95 74.03,104.82 71.29,104.82 70.08,106.02 PQ7605.2
N152790013: length 36.4
  TOP w0.254: PQ7600.4 44.73,106.5 v2(45.07,106.16) 45.59,105.64 v1(46.08,105.64) ; v1(68.28,110.39) 68.05,110.16 68.05,108.45 68.86,107.64 68.86,106.86 69.05,106.67 PQ7605.1 70.19,106.67 71.49,105.37 PQ7605.4 72.85,105.37 72.96,105.26 PR7620.1
  IN1 w0.254: v1(46.08,105.64) 49.23,108.79 66.68,108.79 v1(68.28,110.39)
N152790825: length 4.6
  TOP w0.254: PQ7606.2 70.56,108.66 70.69,108.79 70.69,109.6 70.82,109.73 72.59,109.73 72.8,109.93 PR7622.2
N152790828: length 5
  TOP w0.102: PR7624.2 74.04,109.35 v2(74.88,108.51)
  TOP w0.254: PQ7606.6 72.95,109.31 72.99,109.35 PR7624.2 73.63,109.83 73.66,109.86 PR7622.1 PR7623.1
N152790848: length 4.5
  TOP w0.254: PQ7606.5 72.72,108.66 72.9,108.49 PR7624.1 74.12,108.49 75.45,107.15 v2(76.01,107.15)
N152895939: length 6.7
  BOTTOM w0.102: PR9427.1 114.92,106.87 v2(115.01,106.96) 115.04,106.99 PR9421.2 PR9426.2 116.87,106.2 117.12,106.45 PD9400.2 117.12,108.05 116.48,108.69 PR9456.2
N152902736: length 4.2
  TOP w0.102: v2(64.8,105.69) 64.8,107.04 65.12,107.37 PQ7609.2 66.94,107.37 67.04,107.27 PR7627.2
N152903262: length 2.8
  TOP w0.102: PR7628.1 62.38,105.82 62.51,105.69 v2(63.02,105.69)
  TOP w0.254: PQ7609.6 62.65,106.72 PR7628.1
N152903293: length 2.3
  TOP w0.254: PR7643.2 67.34,108.26 67.1,108.02 PQ7609.3
N152903306: length 3.5
  TOP w0.102: PR7628.2 62.28,107.32 61.52,106.56 61.52,105.95 v2(61.29,105.72)
  TOP w0.254: PQ7609.5 63.07,107.37 63.02,107.32 PR7628.2
N152920482: length 0.8
  TOP w0.102: v1(98.55,93.4) v2(98.55,92.56)
  vias: v1(97.92,93.4)
N152920502: length 6.8
  TOP w0.102: PR8614.2 105.92,98.02 106.3,98.4 106.3,98.91 v2(106.78,99.39)
  TOP w0.229: PU8600.8 102.39,97.82 102.67,97.54 103.81,97.54 PR8606.1
  TOP w0.254: PR8614.2 105.57,97.59 105.04,97.06 104.39,97.06 PR8606.1
N152921519: length 14
  TOP w0.254: PCE8601.1 104.47,91.77 PR8615.2 103.23,91.07 103.19,91.03 PR8616.2 102.8,92.06 v2(103.1,92.36) 103.45,92.71 106.6,92.71 107.34,93.45 107.34,96.73 107.65,97.03 PC8621.1 PR8614.1
N152947604: length 14.3
  TOP w0.254: PR7636.2 36.82,109.21 36.83,109.22 PR7637.1 36.35,109.76 36.14,109.55 PQ7610.5 v1(34.27,109.55) PQ7610.2 ; v1(28.54,108.7) 29.92,107.32 30.55,107.32 30.72,107.14 PQ7611.3
  BOTTOM w0.254: v1(34.27,109.55) 29.38,109.55 v1(28.54,108.7)
N152947630: length 11.3
  TOP w0.254: PQ7614.4 39.85,108.49 39.67,108.66 38.13,108.66 37.9,108.44 37.35,108.44 PR7636.1 36.71,107.9 36.2,108.41 36.2,108.67 35.97,108.9 PQ7610.4 34.8,108.9 34.4,108.49 32.49,108.49 32.36,108.62 32.36,110.07 32.49,110.2 PQ7610.1
N152947648: length 1.3
  TOP w0.254: PQ7611.1 28.97,106.59 28.4,106.02 PR7641.2
N152947658: length 1.5
  TOP w0.254: PR7639.2 29.85,105.65 30.07,105.88 PQ7611.2
N152947660: length 8.9
  TOP w0.254: PQ7611.6 29.42,108.32 29.87,107.88 31.14,107.88 31.42,108.16 PR7640.2 31.69,107.81 31.45,107.57 31.45,107.17 31.65,106.96 v2(31.65,106.63) 31.65,106.55 30.71,105.61 PR7639.1 30.71,105.18 30.18,104.65 29.49,104.65 29.08,105.06 PR7638.1
N152947670: length 2.8
  TOP w0.254: PR7640.1 31.45,109.02 31.14,108.71 31.14,108.39 31.01,108.26 30.2,108.26 30.07,108.38 PQ7611.5
N152947720:
  vias: v2(34.57,101.07)
N152947898:
  vias: v2(31.06,101.91)
N152947961: length 12.7
  TOP w0.254: PR7634.2 PC7610.2 38.68,102.61 v1(38.76,102.69) 38.71,102.74 PQ7613.4 ; v2(32.69,104.07) PR7635.1 v1(33.38,104.83)
  BOTTOM w0.254: v1(33.38,104.83) 34.37,105.82 37.54,105.82 38.76,104.6 v1(38.76,102.69)
N152961167: length 4.7
  TOP w0.102: PR9815.2 PR9814.1 192.35,62.35 v1(193.04,61.66) 193.26,61.88 v2(193.78,61.88)
  BOTTOM w0.102: v1(193.04,61.66) 193.04,61.94 193.17,62.07 PD9800.2
N152966694: length 3.2
  TOP w0.102: PT9800.1 194.54,68.28 v1(193.7,69.12)
  BOTTOM w0.102: PU9800.13 193.45,68.53 193.7,68.79 v1(193.7,69.12)
N152966704: length 2.3
  BOTTOM w0.254: PU9800.4 192.43,65.15 192.56,65.03 PR9803.1 PR9807.2
N152966719: length 5.2
  BOTTOM w0.102: v2(196.98,63.76) 196.75,63.99 196.16,63.99 195.68,64.47 PR9802.1
  BOTTOM w0.254: PR9802.1 PR9806.2 194.39,64.47 193.94,64.92 193.37,64.92 193.37,64.92 193.06,64.92 192.93,65.05 PU9800.3
N152966728:
  vias: v2(175.59,69.29)
N152966831: length 2.3
  BOTTOM w0.254: PR9808.2 190.75,64.47 190.78,64.44 PR9804.1 191.29,65 191.43,65.14 PU9800.6
N153167341: length 43.7
  TOP w0.102: v2(176.89,58.7) 176.89,58.09 v1(176.23,57.43)
  IN1 w0.254: v1(142.85,56.37) 142.85,57.52 143.8,58.47 146.25,58.47 146.96,57.76 146.96,55.53 148.41,54.08 149.83,54.08 150.19,53.72 156.27,53.72 156.95,53.04 158.78,53.04 159.33,53.6 161.21,53.6 161.52,53.9 166.42,53.9 166.5,53.98 168.97,53.98 170.56,55.57 172.34,55.57 174.65,57.89 175.77,57.89 v1(176.23,57.43)
  BOTTOM w0.254: v1(142.85,56.37) 142.98,56.49 PRT7800.1 ; v1(176.23,57.43) PR7800.2
N153167503: length 32.5
  TOP w0.254: PR7827.2 162.25,45.57 v2(161.88,45.2) 160.45,43.77 v1(160.45,42.88)
  IN1 w0.254: v1(144.85,31.75) 144.85,32.71 145.26,33.12 149.75,33.12 153.74,37.11 158.16,37.11 159.82,38.77 159.82,42.57 160.12,42.88 v1(160.45,42.88)
  BOTTOM w0.254: v1(144.85,31.75) 144.85,31.6 144.55,31.3 144,31.3 143.46,31.83 143.46,33.02 143.69,33.25 PRT7802.1
N153167530: length 0.9
  BOTTOM w0.229: PC7838.1 174.07,43.11 174.11,43.15 PR7851.1
N153167553: length 18.3
  TOP w0.203: PR7828.1 173.6,54.19 173.6,54.83 173.48,54.94 173.48,56.35 172.45,57.38 v2(171.17,57.38) 169.52,57.38 v1(168.88,58.02)
  IN1 w0.254: v1(160.3,60.86) 160.83,60.33 163.96,60.33 166.27,58.02 v1(168.88,58.02)
  BOTTOM w0.254: PR7830.2 v1(160.3,60.86)
N153167897: length 3.1
  TOP w0.102: v2(170.89,51.62) 171.12,51.84 v1(171.86,51.84) PR7850.1
  BOTTOM w0.102: PU7800.1 172.31,51.4 v1(171.86,51.84)
N153242757: length 7.5
  BOTTOM w0.102: R5100.1 90.68,14.48 90.83,14.63 90.83,15.12 90.59,15.36 89.32,15.36 88.01,16.66 v2(87.27,16.66) 87.2,16.66 86.96,16.9 U5100.6
N153309287: length 2.5
  TOP w0.254: D3605.1 60.33,23.98 60.07,23.73 R3612.2 v2(60.07,22.13)
N153331695: length 15.3
  TOP w0.432: R1804.2 69.75,10.39 R1806.1 ; R1806.1 69.67,9.73 69.8,9.6 v1(69.8,9.15) 69.8,8.84 R1805.1 R1803.2 ; R1806.1 v2(69.67,12.3) 70,12.63 R1807.1
  BOTTOM w0.508: D1800.1 63.04,11.28 63.3,11.03 66.37,11.03 67.49,9.91 69.05,9.91 69.8,9.16 v1(69.8,9.15)
N153332052: length 9.7
  TOP w0.432: v2(63.4,8.55) 63.56,8.38 R1801.2 R1800.2 R1802.2 v1(66.83,9.2)
  BOTTOM w0.508: v1(66.83,9.2) 66.83,8.89 66.37,8.44 65.71,8.44 65.27,8 63.58,8 62.9,8.68 D1800.2
N153370228: length 13.1
  TOP w0.102: v1(165.3,83.43) 164.89,83.43 v2(164.69,83.24)
  IN1 w0.102: v1(160.2,75.08) 160.2,76.81 164.82,81.43 164.82,82.96 165.29,83.43 v1(165.3,83.43)
  BOTTOM w0.102: R6006.1 160.53,74.7 160.47,74.7 160.2,74.98 v1(160.2,75.08) ; v1(165.3,83.43) 165.64,83.43 U6000.N10
N153370348: length 12.7
  IN1 w0.102: v1(159.21,93.83) 158.75,94.29 158.75,97.01 158.97,97.22 158.99,97.22 159.22,97.46 159.22,100.83 159.9,101.51 v1(160.52,101.51)
  BOTTOM w0.102: v1(159.21,93.83) 159.43,93.61 U6000.AA22 ; R6007.1 162.18,103.05 v2(162.18,102.54) 161.14,101.51 v1(160.52,101.51)
N153370365: length 14.4
  IN1 w0.102: v1(160.4,96.14) 160.05,96.5 160.05,97.92 159.62,98.34 159.62,100.42 160.09,100.89 v1(160.5,100.89)
  BOTTOM w0.102: v1(160.5,100.89) 160.92,101.3 161.55,101.3 162.84,102.59 R6008.1 163.78,102.39 v2(163.78,101.75) ; U6000.Y22 160.43,96.11 v1(160.4,96.14)
N153375577: length 29.9
  TOP w0.432: v1(153.82,86.21) 153.95,86.34 C6719.1
  IN1 w0.508: v1(155.32,77.83) 154.91,78.23 154.91,85.12 v1(153.82,86.21) ; v1(162.56,77.19) 163.19,77.83 165.28,77.83 166.98,79.53 166.98,81.36 166.6,81.74 v1(166.32,81.74)
  IN3 w0.508: v1(155.32,77.83) 159.92,77.83 160.55,77.19 v1(162.56,77.19)
  BOTTOM w0.102: v1(155.32,77.83) 155.32,76.94 153.64,75.26 v2(153.64,74.78) ; U6000.L8 166.75,81.74 v1(166.32,81.74)
N153377480: length 46.7
  TOP w0.254: L6700.2 149.64,89.78 v2(149.76,89.66) 150.04,89.66 150.34,89.97 151.39,89.97 151.52,89.84 C6720.1 151.52,88.92 150.97,88.38 150.97,87.98 151.25,87.69 152.54,87.69 C6733.1 153.17,86.32 152.03,85.18 149.04,85.18 v1(147.7,83.85)
  IN1 w0.254: v1(162.56,75.77) 163.08,75.25 165.56,75.25 166.54,76.23 166.54,77.3 v1(170.03,80.8)
  IN2 w0.254: v1(147.7,83.85) 147.7,82.86 148.23,82.32 148.23,81.19 150.76,78.67 152.48,78.67 152.83,78.31 155.8,78.31 156.41,77.7 160.63,77.7 v1(162.56,75.77)
  BOTTOM w0.254: U6000.H7 170.03,80.82 v1(170.03,80.8)
N153378830: length 84.4
  TOP w0.432: L6701.2 C6721.1 C6734.1 v2(151.82,107.36) 146.42,107.36 145.6,106.53 134.7,106.53 v1(132.72,104.55)
  IN1 w0.432: v1(169.22,81.59) 169.22,80.68 166.09,77.55 166.09,76.41 165.59,75.91 163.23,75.91 v1(162.56,76.58)
  IN3 w0.432: v1(132.72,104.55) 133.83,103.43 133.83,92.86 136.19,90.5 139.09,90.5 141.44,88.15 141.44,87.15 144.19,84.4 146.08,84.4 147.24,83.24 148.37,83.24 149.34,82.26 149.92,82.26 151.5,80.68 151.5,79.37 154.14,76.72 158.23,76.72 158.5,76.99 158.97,76.99 159.38,76.58 v1(162.56,76.58)
  BOTTOM w0.305: v1(169.22,81.59) 169.63,82 U6000.H8
N153448899: length 18.6
  TOP w0.356: Q2901.6 28.79,68.48 28.19,67.89 v1(28.19,67.8)
  TOP w0.432: v2(22.4,58.57) R2908.1 R2907.1 R2906.1 R2905.1 22.4,63.06 21.59,63.87 R2904.1 R2903.1 21.59,65.41 22.45,66.27 R2910.1 R2909.1 22.45,67.87 22.87,68.28 23.5,68.28 23.72,68.5 24.17,68.5 24.97,69.3 v1(24.97,69.42)
  IN1 w0.508: v1(28.19,67.8) 27.72,68.27 26.67,68.27 26.67,68.28 26.11,68.28 v1(24.97,69.42)
N153451943: length 2.4
  TOP w0.102: R2912.1 16,68.48 16.02,68.5 D2902.1 16.71,69.34 v2(17.01,69.64)
N153451944: length 3.6
  TOP w0.102: v2(16.41,65.08) 16.94,65.61 16.94,66.19 16.71,66.43 D2902.2 16.09,67.2 15.95,67.34 R2911.1
N153459790: length 2.7
  TOP w0.102: v2(30.05,72.57) 29.87,72.75 R2600.2 28.68,72.75 28.3,72.37 Q2601.1
N153474772: length 7.3
  BOTTOM w0.076: U0400.BA8 105.36,37.03 105.13,36.81 104.57,36.81 104.09,36.32 104.09,35.36 102.77,34.04
  BOTTOM w0.102: T1507.1 102.51,32.74 102.51,33.78 102.77,34.04
N153474794: length 7.3
  BOTTOM w0.076: 103.64,34.66 104.67,35.68 U0400.BB7
  BOTTOM w0.102: T1508.1 103.58,29.75 103.58,34.6 103.64,34.66
N153501862: length 50
  TOP w0.102: 26.29,58.7 25.55,58.7 v2(25.45,58.6) 25.45,57.69 25.68,57.46 v1(26.29,57.46)
  IN1 w0.102: v1(31.17,33.77) 31.09,33.85 31.09,39.29 30.05,40.34 30.05,41.86 25.86,46.05 25.86,57.03 v1(26.29,57.46)
  IN2 w0.102: v1(37.16,18.42) 37.16,19.59 36.7,20.04 35.34,20.04 33.66,21.73 33.66,27.54 32.36,28.83 32.36,32.58 v1(31.17,33.77)
  BOTTOM w0.102: U5801.4 37.56,18.81 v1(37.16,18.42)
N153576006: length 18.8
  TOP w0.102: v1(9.8,92.61) 10.27,93.08 11.76,93.08 11.89,92.95 11.89,92.43 R5000.1 12.52,91.8 v2(12.52,91.19)
  IN3 w0.102: v1(9.8,92.61) 10.24,93.04 10.24,93.37 9.92,93.69 9.03,93.69 8.08,94.64 4.7,94.64 4.34,95 4.34,96.19 3.89,96.65 3.89,97.16 2.02,99.02 v1(2.02,99.82)
  BOTTOM w0.102: v1(2.02,99.82) 1.73,99.82 1.25,100.3 LED5000.3
N153576010: length 14.7
  TOP w0.102: v1(9.8,93.22) 9.86,93.28 12.23,93.28 R5001.1
  IN3 w0.102: v1(2.11,98.2) 2.56,98.2 3.66,97.1 3.66,96.59 4.14,96.11 4.14,94.91 4.67,94.39 8.03,94.39 9,93.41 9.61,93.41 v1(9.8,93.22)
  BOTTOM w0.102: LED5000.1 1.77,98.33 1.9,98.2 v1(2.11,98.2)
N153576018: length 26
  TOP w0.102: v1(29.9,93.83) v2(30.53,93.83) 30.89,93.83 30.96,93.75 31.47,93.75
  IN3 w0.102: v1(20.04,84.31) 20.27,84.53 22.33,84.53 25.25,87.45 29.33,87.45 29.74,87.86 29.99,87.86 30.98,88.85 v1(30.98,88.98)
  BOTTOM w0.102: v1(30.98,88.98) 30.35,89.61 v2(30.35,90.15) 30.35,90.68 30.96,91.29 30.96,93.6 30.73,93.83 v1(29.9,93.83) ; Q5000.5 21.23,85.42 21.57,85.08 21.57,84.53 21.35,84.31 v1(20.04,84.31) 20.04,84.76 19.38,85.42 Q5000.2
N153635028: length 2.8
  TOP w0.254: C5800.1 40.61,72.8 40.36,73.05 v2(40.36,73.05) 40.36,73.05 40.13,73.28 39.29,73.28 39.16,73.41 U5800.33
N153741862: length 17.7
  TOP w0.076: v3(103.71,38.69) 103.72,38.67 103.72,35.48 102.77,34.53
  TOP w0.102: 102.77,34.53 101.51,33.27 97.44,33.27 96.61,34.09 95.25,34.09 94.23,33.07 T1105.1
  BOTTOM w0.102: v3(103.71,38.69) 103.79,38.69 104.38,39.28 105.35,39.28 105.48,39.15 105.77,39.15 105.79,39.17 106.13,39.17 106.19,39.16 106.46,38.88 U0400.AW11
N153741882: length 11.2
  TOP w0.102: v3(107.47,39.45) 107.88,39.04 108.11,39.04 108.51,38.64 108.51,38.36 108.71,38.15 109.55,38.15 109.75,37.95 109.75,37.26 109.55,37.06 109.55,36.5 109.68,36.38 109.68,35.46 109.3,35.08 109.3,33.53 108.13,32.36 T1106.1
  BOTTOM w0.102: U0400.AW13 106.9,40.02 107.47,39.46 v3(107.47,39.45)
N153936087: length 3.9
  BOTTOM w0.102: CON5102.4 87.23,12.89 87.63,13.29 87.63,13.52 v2(88.09,13.97) 89.33,13.97 89.69,13.62 R5100.2
N153936404: length 3
  BOTTOM w0.102: U5100.2 83.9,17.55 84.02,17.68 84.02,18.09 83.91,18.2 U5100.3 v2(83.24,19.1)
N154179123: length 35.8
  TOP w0.102: v1(178.36,74.22) 179.27,75.14 v2(179.27,75.34) 180.24,75.34 181.58,76.69 C6305.1 R6300.1 R6302.2
  IN1 w0.102: v1(178.36,74.22) 169.88,74.22 169.48,74.63 163.04,74.63 161.42,76.25 161.42,76.91 162.99,78.49 164.23,78.49 165.84,80.1 165.84,82.79 v1(166.27,83.23)
  BOTTOM w0.102: v1(166.27,83.23) 166.64,83.23 U6000.L10
N154179127: length 4.4
  TOP w0.102: R6301.2 179.88,80.75 179.98,80.65 C6300.1 179.98,79.45 179.91,79.38 R6302.1 179.58,78.92 179.38,78.72 179.38,78.03 v2(178.92,77.57)
N154179258: length 10.9
  TOP w0.102: v1(167.6,95.23) 167.51,95.23 v2(167.08,94.8)
  IN3 w0.254: v1(165.79,103.18) 165.79,101.68 166.98,100.48 166.98,95.85 v1(167.6,95.23)
  BOTTOM w0.254: U6000.K25 167.95,95.62 167.6,95.27 v1(167.6,95.23) ; v1(165.79,103.18) 166.12,103.51 R6303.2
N154184479: length 4.4
  TOP w0.102: v1(116.56,97.16) v2(116.56,96.52)
  BOTTOM w0.432: PC9409.1 118.31,98.48 118.4,98.39 118.4,97.78 118.03,97.41 117.52,97.41 PR9417.2 v1(116.56,97.16)
N154195714: length 6
  BOTTOM w0.222: PU9400.25 112.47,103.51 113.03,104.07 v2(113.03,104.63) 113.03,105.34 PR9423.2 112.49,105.41 112.49,104.09 112.07,103.67 PU9400.24
N154204989:
  vias: v1(135.71,105.9) v1(135.74,105.29) v1(136.35,105.9) v1(136.35,105.29) v2(136.13,104.69)
N154205542: length 1.3
  TOP w0.432: PC9625.1 128.93,111.28 v1(128.85,111.36) v2(128.37,111.84)
N154207336: length 7.6
  BOTTOM w0.102: PR9408.1 113.36,108.56 v2(114.34,109.54)
  BOTTOM w0.222: 113.67,103.66 PU9400.28
  BOTTOM w0.432: 113.67,103.66 113.67,104.79 113.98,105.1 PC9403.2 113.61,105.62 113.36,105.87 113.36,107.98 PR9408.1
N154222504: length 4.8
  BOTTOM w0.102: Q3600.1 145.9,18.55 145.49,18.14 v2(145.26,18.14) 143.96,18.14 R3606.1 C3604.2
N154254785: length 4
  BOTTOM w0.432: PR9410.2 120.08,101.18 v2(119.46,101.81) 118.39,101.81 118.26,101.68 PC9407.1
N154814546: length 4.6
  TOP w0.102: U3901.3 38.18,60.57 38.3,60.44 38.3,59.79 38.53,59.57 38.86,59.57 39.29,59.13 R3914.1 39.29,58.68 39.37,58.6 39.57,58.6 39.78,58.4 v2(39.78,57.28)
N154880295: length 19.8
  TOP w0.102: R6939.2 151.11,105.64 152.55,105.64 152.92,105.28 159.22,98.97 159.22,97.02 v1(158.14,95.94) 158.14,95.56 v2(158.47,95.23)
  BOTTOM w0.102: v1(158.14,95.94) 157.99,95.79 157.99,93.37 U6000.AC22
N154880298: length 20.4
  TOP w0.102: R6940.2 v2(149.87,105.37) 150.34,105.84 152.64,105.84 159.64,98.84 v1(159.64,97.64)
  BOTTOM w0.102: v1(159.64,97.64) 159.64,96.95 158.98,96.29 158.98,96.28 158.95,96.26 158.95,95.89 158.99,95.85 158.99,95.38 158.78,95.17 158.78,95.17 158.48,95.17 158.24,94.93 158.24,93.41 U6000.AB22
N155049432: length 16.1
  TOP w0.102: PQ7612.2 32.17,107.13 v1(31.93,107.37) ; v2(29.9,98.55) 30.3,98.96 PR7644.2 29.21,99.44 v1(28.49,98.72)
  BOTTOM w0.102: v1(31.93,107.37) 31.8,107.5 29.47,107.5 28.14,106.17 28.14,99.06 v1(28.49,98.72)
N155063423: length 9.5
  BOTTOM w0.102: R2425.1 105.11,15.01 105.22,15.13 105.22,15.76 105.35,15.89 106.49,15.89 v2(106.78,16.18)
  BOTTOM w0.432: Q2403.1 100.36,15.36 100.58,15.14 R2416.1 101.54,14.3 101.93,13.92 Q2406.1 103.96,13.92 104.7,14.66 R2425.1
N155063559: length 1.5
  BOTTOM w0.432: Q2403.3 103.32,16.31 R2415.1
N155160901: length 40.7
  IN2 w0.254: v1(80.57,97.03) 80.23,96.69 76.41,96.69 76.1,97.01 61.52,97.01 61.12,97.41 58.98,97.41 58.19,96.62 57.38,96.62 57.34,96.58 53.33,96.58 51.18,98.73 v1(48.01,98.73)
  BOTTOM w0.254: v1(48.01,98.73) 48.12,98.62 U3000.3 ; v2(79.07,99.49) R3005.1 80.47,100.03 81.1,100.03 D3000.3 81.12,97.58 v1(80.57,97.03)
N155161413: length 11.6
  TOP w0.102: v1(46.99,96.7) 47.04,96.75 49.07,96.75 49.73,96.09 v2(50.47,96.09)
  BOTTOM w0.102: v1(46.99,96.7) 46.02,97.67 U3000.4 46.75,98.62 47.32,98.05 49.5,98.05 50.04,98.58 R3003.1
N155370962: length 8.4
  TOP w0.102: v2(42.55,71.25) 42.93,71.25 43.36,70.82 PR9004.2 41.63,70.74 41.4,70.51 41.4,70.28 41.28,70.16 PR9005.1 41,70.23 40.41,70.82 37.64,70.82 37.36,70.53 PU9001.5
N155800180: length 1.6
  TOP w0.076: T1005.1 124.56,57.23 v3(124.26,56.92)
  BOTTOM w0.076: v3(124.26,56.92) 123.92,57.26 U0400.F43
N155800183: length 1.3
  TOP w0.076: v3(124.82,57.74) 124.92,57.84 T1006.1
  BOTTOM w0.076: v3(124.82,57.74) 124.57,57.49 U0400.E43
N155975447: length 8.3
  BOTTOM w0.102: Q3701.2 122.96,18.04 123.28,17.72 123.28,17.15 123.19,17.06 121.83,17.06 120.85,18.04 Q3701.5 120.04,18.04 119.46,17.45 119.23,17.45 119.1,17.33 119.1,17.05 120.04,17.05 120.35,16.74 v2(120.35,16.36)
N156027460: length 13.7
  TOP w0.102: v2(32.9,45.29) U2300.21 32.9,42.16 33.15,41.91 34.18,41.91 37.19,38.9 v1(37.32,38.9)
  BOTTOM w0.102: T2310.1 41.69,38.9 v1(37.32,38.9)
N156094743: length 2.4
  BOTTOM w0.102: v2(113.08,16.46) R5824.2 114.02,16.46 114.39,16.83 Q5801.1
N156159587: length 7.9
  TOP w0.102: v2(166.75,75.77) 167.12,75.4 R6309.1 168.59,75.4 168.91,75.08 169.65,75.08 170.26,75.69 170.26,77.27 169.9,77.62 C6304.2
N156159590: length 1.9
  TOP w0.102: v2(166.32,78.41) 166.32,78.23 166.69,77.87 R6308.1 C6303.2
N156222059: length 21.8
  TOP w0.102: T1512.1 112.78,23.35 113.02,23.1 v1(113.9,23.1)
  IN2 w0.076: v3(117.73,35.33) 117.93,35.33 118.44,34.83 118.44,34.04 119.63,32.84 119.63,30.89
  IN2 w0.102: 119.63,30.89 119.63,29.59 119.25,29.21 119.25,24.26 118.64,23.65 117.7,23.65 116.94,22.89 114.12,22.89 113.91,23.1 v1(113.9,23.1)
  BOTTOM w0.076: v3(117.73,35.33) 118.08,34.98 118.08,34.55 118.48,34.15 U0400.U3
N156222073: length 8.4
  TOP w0.076: v3(118.85,36.2) 119.27,36.62 119.27,38.12 119.43,38.29 119.43,40.31 119.35,40.39 119.35,42.15 T1513.1
  BOTTOM w0.076: v3(118.85,36.2) 118.85,35.03 118.48,34.66 U0400.U4
N157340852: length 4.8
  BOTTOM w0.102: v2(23.24,89.66) R5903.2 21.77,89.56 21.34,89.56 20.21,90.69 U5900.5
N157340858: length 4.9
  TOP w0.102: v1(15.21,89.26) 16.05,89.26 16.1,89.21 R5904.1 C5912.1
  BOTTOM w0.102: U5900.11 15.3,89.34 v1(15.21,89.26) v2(15.21,88.57)
N157340892: length 2
  BOTTOM w0.102: U5900.7 19.2,89.34 19.43,89.11 C5905.1
N157340898: length 7
  TOP w0.102: v2(19.84,90.3) R5906.1 19.25,89.79 16.61,89.79 16.05,90.35 15.35,90.35 v1(15.16,90.54)
  BOTTOM w0.102: U5900.13 15.32,90.69 v1(15.16,90.54)
N157340900: length 4.8
  TOP w0.102: v1(15.16,89.92) 15.8,89.92 v2(16,89.72) 16.13,89.59 18.49,89.59 C5906.1
  BOTTOM w0.102: v1(15.16,89.92) 15.44,90.19 U5900.12
N157341108: length 2.5
  BOTTOM w0.102: U5900.4 20.06,91.19 21.13,90.12 R5902.2
N157462563: length 5.2
  BOTTOM w0.102: R3715.2 132.79,88.75 133.58,88.75 133.83,89 133.83,90.35 133.65,90.54 U3700.6

## Copper pours and planes (outline as drawn)
1.0VO_BST on BOTTOM (solid shape): 172.26,40.24 172.28,40.2 172.37,40.1 172.49,40.05 172.57,40.03 172.64,40.04 172.64,40.03 172.69,40.03 172.8,39.92 172.8,39.71 172.86,39.65 173.18,39.65 173.27,39.56 173.27,37.06 173.39,36.95 174.13,36.95 174.16,36.91 174.16,36.71 173.18,36.71 172.95,36.94 172.95,39.22 172.95,39.35 172.67,39.63 171.53,39.63 171.32,39.83 171.32,40.16 171.4,40.24
1.0VO_BST_R on BOTTOM (solid shape): 172.14,41.71 172.14,41.3 172.1,41.26 170.17,41.26 170.08,41.35 170.08,41.75 170.12,41.79 172.06,41.79
1.0VO_LX on BOTTOM (solid shape): 169.57,42.8 169.57,40.85 169.88,40.54 170.87,40.54 170.97,40.44 170.97,39.86 170.76,39.65 170.76,37.9 170.77,37.89 170.77,37.86 170.8,37.86 170.87,37.8 171.73,37.8 173.06,36.47 175.33,36.47 175.33,36.22 175.3,36.19 174.13,36.19 173.24,35.31 173.24,34.42 173.48,34.18 173.48,31.9 173,31.42 173,30.13 172.92,30.05 172.26,30.05 172.19,30.13 172.19,31.5 172.69,32.01 172.69,35.08 172.34,35.44 172.34,35.66 171.79,36.22 171.44,36.61 171.05,36.96 170.75,37.25 170.62,37.25 170.48,37.33 170.35,37.4 170.03,37.72 169.52,37.72 169.22,38.03 168,38.03 167.46,38.56 167.46,42.88 167.72,43.13 169.24,43.13
1.0VO_RC on BOTTOM (solid shape): 171.87,39.33 172.61,39.33 172.67,39.27 172.67,38.97 172.62,38.92 171.98,38.92 171.83,38.76 171.83,38.08 171.76,38 171.12,38 171.02,38.1 171.02,39.32 171.09,39.4 171.81,39.4
1.8VO_VGA_LX on BOTTOM (solid shape): 167.01,70.61 167.01,69.75 166.83,69.57 165.53,69.57 165.34,69.38 165.32,69.39 164.87,69.25 164.73,68.8 164.73,68.77 163.98,68.02 163.98,67.49 163.91,67.41 163.78,67.41 163.73,67.46 163.73,68.15 163.17,68.71 163.17,70.44 163.27,70.54 164.72,70.54 165.05,70.87 166.75,70.87
1.8VO_VGA_VIN on BOTTOM (solid shape): 163.98,65.43 164,65.42 164,65.29 164.1,64.9 164.49,64.82 164.62,64.82 165.22,64.21 166.55,64.21 166.65,64.11 166.65,61.5 166.37,61.22 163.78,61.22 163.63,61.37 163.63,65.38 163.73,65.48 163.73,66.02 163.75,66.04 163.98,66.04
+0.95V_GPU on TOP (solid shape): outline of 623 points within 160.93,93.6 169.7,105.88
+0.95V_GPU on BOTTOM (solid shape): 163.56,110.56 163.56,109.88 163.41,109.73 163.4,109.73 163.4,109.72 163.36,109.68 163.36,107.94 163.22,107.8 163.22,105.49 163.3,105.41 163.5,105.41 163.68,105.23 163.68,105.06 163.36,104.74 163.3,104.7 163.24,104.65 161.57,104.65 161.09,105.13 161.09,109.27 162.53,110.72 163.4,110.72
+0.95V_GPU on BOTTOM (solid shape): outline of 122 points within 161.04,91.93 167.41,96.93
+0.95V_GPU on IN1 (solid shape): outline of 861 points within 160.55,92.03 166.73,105.77
+1.0VO on BOTTOM (solid shape): 165.1,52.63 166.93,52.63 167.06,52.5 167.06,50.62 166.5,50.07 166.5,47.84 166.46,47.76 166.37,47.74 165.91,47.51 166.09,47.04 166.12,47.02 166.12,46.84 166.34,46.61 166.34,44.83 166.66,44.52 166.66,38.14 164.92,36.4 162.87,36.4 162.38,36.88 162.38,38.76 161.67,39.47 161.06,39.47 161.06,42.95 161.54,43.44 162.79,43.44 164.03,44.68 164.03,46.36 164.21,46.69 164.03,47.01 164.03,47.48 164.19,47.68 164.19,47.94 164.17,47.97 164.24,48.03 164.24,48.99 164.29,49.18 164.24,49.37 164.24,49.89 163.73,50.4 162.76,50.4 162.41,50.75 161.52,50.75 161.44,50.83 161.43,50.85 161.41,50.94 161.37,51.02 161.37,51.59 161.44,51.67 162.04,51.67 162.04,52.16 162.66,52.78 164.95,52.78
+1.8VO_VGA on BOTTOM (solid shape): 162.74,71.53 162.74,68.89 162.36,68.51 161.32,68.51 161.01,68.2 159.97,68.2 159.74,68.43 159.74,70.23 160.07,70.56 160.07,71.55 160.22,71.71 162.56,71.71
+1.8VS_VGA on TOP (solid shape): 158.83,93.5 158.83,93.2 158.78,93.14 158.32,93.14 158.14,92.97 158.14,90.63 157.86,90.35 157.43,90.35 156.72,89.64 156.72,88.88 156.06,88.22 156.06,86.97 155.98,86.9 155.3,86.9 155.17,87.02 155.17,90.76 155.41,91 156.21,91 156.21,90.89 156.31,90.79 156.3,90.76 156.71,90.25 157.07,90.8 157.08,90.89 157.16,90.94 157.49,91.21 157.36,91.62 157.36,91.98 157.53,92.26 157.42,92.57 157.2,92.79 157.2,93.55 157.25,93.6 158.72,93.6
+1.8VS_VGA on BOTTOM (solid shape): 159.1,93.04 159.24,92.89 159.44,92.84 159.46,92.84 159.51,92.79 159.51,92.76 159.56,92.55 159.72,92.4 159.72,92.15 159.58,91.95 159.59,91.71 159.59,91.67 159.6,91.56 159.68,91.47 159.72,91.44 159.72,91.04 159.46,90.78 159.37,90.78 159.35,90.81 159,91.04 158.66,90.81 158.64,90.78 157.92,90.78 157.77,90.92 157.58,90.94 157.55,90.94 157.42,91.07 157.44,91.11 157.5,91.23 157.5,91.37 157.53,91.45 157.61,91.49 157.96,91.79 157.66,92.15 157.43,92.38 157.43,92.69 157.47,92.73 157.5,92.71 157.77,92.72 157.95,92.93 157.96,92.97 158.15,92.97 158.48,92.84 158.76,93.04 158.78,93.07 159.08,93.07
+1VSB on TOP (solid shape): 141.55,29.42 141.55,27.87 141.02,27.33 141.02,25.78 140.87,25.63 137.4,25.63 136.83,26.2 135.27,26.2 135.05,26.42 135.05,27.26 135.33,27.54 137.18,27.54 137.19,27.49 137.25,27.29 137.42,27.15 137.99,26.99 138.02,27.59 138.07,27.64 138.07,28.43 139.5,29.85 141.12,29.85
+1VSB on BOTTOM (solid shape): 167.69,57.03 167.69,55.92 167.15,55.38 167.15,53.81 167.13,53.68 167.15,53.54 167.15,53.32 166.87,53.04 163.41,53.04 163.15,53.29 163.15,55.79 163.58,56.21 163.58,57.2 163.96,57.58 167.13,57.58
+1VSB on BOTTOM (solid shape): outline of 108 points within 132.36,22.33 143.36,32.08
+1VSB on VCC (solid shape): 168.05,56.34 168.05,53.73 166.29,51.97 166.19,51.94 166.14,51.84 166.14,35.66 165.36,33.62 166.14,31.58 166.14,30.03 164.26,28.15 136.93,28.15 136.93,29.67 137.07,29.81 137.1,29.85 137.11,29.9 137.11,31.6 137.1,31.65 137.07,31.69 136.42,32.34 136.42,33.22 136.89,33.69 136.92,33.74 136.93,33.78 136.93,35.33 141.25,35.33 141.3,35.34 141.34,35.37 141.97,36.01 142,36.05 142.01,36.1 142.01,42.7 146.46,42.7 146.51,42.71 146.55,42.74 148.38,44.57 148.4,44.61 148.41,44.66 148.41,56.92 167.46,56.92
+1VSB_VIN on BOTTOM (solid shape): 177.4,36.84 177.42,36.84 177.7,36.55 182.45,36.55 182.58,36.43 182.58,35.64 182.49,35.55 177.79,35.55 176.65,36.69 174.78,36.69 174.78,36.98 174.8,37 177.24,37
+1VSUS_ORG on TOP (solid shape): 135.56,32.82 135.86,32.82 136.47,32.21 136.49,32.19 136.53,32.15 136.55,32.13 137.16,31.52 137.16,30.46 136.51,29.81 136.51,28.82 136.03,28.34 135.04,28.34 133.97,27.27 133.06,27.27 132.97,27.36 132.94,27.45 132.94,28.27 133.22,28.55 133.22,29.59 134.16,29.59 134.16,29.57 134.17,29.51 134.19,29.46 134.21,29.41 134.24,29.36 134.28,29.32 134.32,29.28 134.37,29.25 134.42,29.23 134.47,29.22 134.53,29.21 134.59,29.21 134.64,29.22 134.69,29.24 134.74,29.27 134.79,29.3 134.83,29.34 134.86,29.38 134.89,29.43 134.91,29.48 134.92,29.54 134.93,29.59 134.92,29.65 134.91,29.7 134.89,29.76 134.86,29.8 134.83,29.85 134.79,29.89 134.74,29.92 134.69,29.95 134.64,29.96 134.59,29.97 134.53,29.98 134.47,29.97 134.42,29.96 134.37,29.93 134.32,29.9 134.28,29.87 134.24,29.83 134.21,29.78 134.19,29.73 134.17,29.68 134.16,29.62 134.16,29.59 133.22,29.59 133.22,30.51 133.66,30.94 133.66,32.44 134.04,32.82 135.56,32.82
+1VSUS_ORG on BOTTOM (solid shape): 136.5,32.18 136.62,32.05 137.8,32.05 138.3,31.55 138.3,30.94 138.58,30.66 138.58,29.92 138.48,29.82 137.06,29.82 136.25,30.63 136.25,30.94 134.9,32.29 134.9,33.17 134.95,33.23 135.45,33.23
+1VSUS_ORG on IN1 (solid shape): outline of 627 points within 115.17,41.35 121.79,45.82
+1VSUS_ORG on IN2 (solid shape): 136.32,32.69 136.4,32.65 136.42,32.56 136.74,32.06 137.16,32.48 137.18,32.56 137.25,32.59 137.37,32.62 137.48,32.68 137.72,32.44 137.72,32.41 137.82,32.13 138.1,32.01 138.15,32.01 138.25,31.9 138.25,30.66 137.71,30.11 133.95,30.11 133.78,30.28 133.78,31.9 134.14,32.26 135.28,32.26 135.61,32.59 135.71,32.59 135.81,32.69
+1VSUS_ORG on IN2 (solid shape): outline of 400 points within 119.71,39.75 128.98,42.75
+3V_CCG4_VDDD on TOP (solid shape): 38.28,74.18 38.28,73.61 38.3,73.59 38.51,73.59 38.53,73.61 38.53,74.18 38.56,74.21 38.8,74.21 38.81,74.2 38.81,73.19 39.09,72.9 39.09,72.41 39.19,72.32 39.19,71.78 39.32,71.66 40.67,71.66 40.79,71.53 40.79,71.22 40.58,71.01 38.82,71.01 38.66,71.17 38.66,71.83 38.23,72.27 38.23,72.98 38.02,73.18 38.02,74.13 38.1,74.21 38.25,74.21
+3VS_VGA on TOP (solid shape): 159.3,90.82 159.3,89.61 159.03,89.35 159.03,88.33 158.88,88.33 158.88,87.61 158.67,87.4 157.91,87.4 157.14,86.63 157.03,86.56 156.96,86.45 156.9,86.39 156.9,85.54 156.87,85.4 156.9,85.26 156.9,85.22 155.98,84.31 155.98,84.23 155.22,83.47 154.69,83.47 154.38,83.77 154.38,83.85 156.14,85.61 156.14,86.84 156.57,87.26 156.79,87.43 156.84,87.7 156.84,88.01 157.63,88.8 157.63,88.91 157.64,88.92 157.68,89 157.68,89.18 158.37,89.87 158.37,90.71 158.67,91.01 159.11,91.01
+3VS_VGA_OUT on BOTTOM (solid shape): 186.69,109.25 187.4,109.25 187.55,109.1 187.55,108.64 187.4,108.49 186.46,108.49 186.16,108.79 185.88,108.79 185.8,108.71 185.8,107.77 185.73,107.7 185.27,107.7 185.19,107.77 185.19,108.92 185.32,109.04 185.32,109.53 185.45,109.65 186.28,109.65
+3VSUS_ORG on TOP (solid shape): 121.51,31.47 121.51,30.28 121.95,29.85 121.95,28.65 121.87,28.58 121.21,28.58 121.18,28.55 121.18,28.08 121.16,28.06 120.62,28.06 120.6,28.07 120.6,29.47 120.55,29.52 120.42,29.52 120.19,29.75 120.19,31.73 120.32,31.85 121.13,31.85
+3VSUS_ORG on BOTTOM (solid shape): 177.52,18.44 177.52,17.74 177.46,17.68 176.68,17.68 176.45,17.45 176.23,17.45 176.12,17.55 176.12,17.96 176.71,18.54 177.42,18.54
+3VSUS_ORG on BOTTOM (solid shape): 120.82,31.92 120.82,31.87 120.8,31.85 120.83,31.83 120.83,31.01 121.67,30.17 121.67,28.81 121.59,28.73 120.78,28.73 120.64,28.87 120.64,29.3 120.17,29.77 120.17,29.77 119.89,30.05 119.89,31.83 120.07,32 120.73,32
+3VSUS_ORG on IN1 (solid shape): outline of 1438 points within 111.61,29.62 121.82,45.32
+5V on TOP (solid shape): outline of 320 points within 17.28,12.22 25.27,39.14
+5V on BOTTOM (solid shape): 205,50.78 205,48.66 204.78,48.44 203.84,48.44 203.48,48.8 203.48,50.7 203.71,50.93 204.85,50.93
+5V on BOTTOM (solid shape): 160.53,53.7 160.53,53.14 161.21,52.45 161.21,51.08 160.93,50.8 160.58,50.8 160.53,50.85 160.53,52.35 160.27,52.61 160.27,53.7 160.3,53.73 160.5,53.73
+5V on BOTTOM (solid shape): 106.2,15.55 106.2,13.69 105.03,12.52 103.18,12.52 103.02,12.68 103.02,13.24 103.18,13.39 103.99,13.39 104.42,13.82 105.08,13.82 105.46,14.2 105.46,15.5 105.56,15.6 106.15,15.6
+5V on BOTTOM (solid shape): 19.32,37.14 19.56,37.14 19.84,36.86 19.84,36.2 19.79,36.15 19.23,36.15 19.23,36.25 19.19,36.25 19.19,36.84 19.01,37.01 18.49,37.01 18.47,37 18.42,36.99 18.37,36.98 18.27,36.96 18.19,36.91 18.15,36.91 18.15,36.88 18.11,36.83 18.11,36.53 17.66,36.07 16.05,36.07 15.93,36.2 15.93,36.48 15.98,36.53 15.98,37.8 16.08,37.9 18.55,37.9
+5V on IN1 (solid shape): 19.96,39.01 19.96,38 18.12,36.15 17.9,36.05 17.79,35.84 17.12,35.84 16.8,36.16 16.8,37.76 18.52,39.47 19.5,39.47
+5V on VCC (solid shape): outline of 125 points within 21.23,6.89 208.56,51.08
+5V_ANALOG on BOTTOM (solid shape): 15.27,37.8 15.27,36.22 15.19,36.15 14.69,36.15 14.69,36.1 14.5,36.1 14.38,35.97 14.38,35.46 14.32,35.4 13.19,35.4 13.1,35.49 13.1,37.53 13.55,37.98 15.09,37.98
+5V_HDD on BOTTOM (solid shape): outline of 87 points within 106.91,13.11 112.84,16.16
+5V_PVDD on TOP (solid shape): 20.05,36.67 20.05,36.03 20.1,35.99 20.09,35.96 20.17,35.68 20.43,35.54 20.45,35.54 20.5,35.49 20.5,32.67 20.22,32.39 18.64,32.39 18.47,32.21 17.53,32.21 17.4,32.34 16.59,32.34 15.77,33.15 15.77,33.43 16,33.66 16.28,33.66 16.49,33.45 16.52,33.44 16.61,33.39 16.71,33.37 18.8,33.37 18.93,33.5 19.12,33.64 19.19,33.85 19.19,33.92 19.15,34.03 19.09,34.12 19.09,34.23 19.21,34.36 19.2,34.37 19.2,36.68 19.25,36.73 19.99,36.73
+5V_USB on BOTTOM (solid shape): 206.4,45.85 206.4,45.67 206.38,45.65 205.56,45.65 205.49,45.57 205.49,45.39 205.51,45.37 206.35,45.37 206.4,45.32 206.4,45.19 206.35,45.14 205.49,45.14 204.98,44.63 204.93,44.63 204.29,44 203.68,44 203.53,44.15 203.53,45.27 203.63,45.37 204.78,45.37 205.28,45.87 206.38,45.87
+5VSB on TOP (solid shape): outline of 273 points within 22.97,91.33 33.17,96.09
+5VSB on BOTTOM (solid shape): 203.57,48.17 204.84,48.17 205.31,47.7 205.31,46.13 204.72,45.54 203.15,45.54 202.87,45.82 202.87,48.39 203,48.52 203.23,48.52
+5VSB on BOTTOM (solid shape): 26.24,94.11 26.24,92.59 24.87,91.21 23.98,91.21 23.57,91.62 23.57,92.03 23.37,92.23 20.83,92.23 20.14,91.54 19.14,91.54 19.14,92.9 19.05,92.99 18.34,92.99 18.21,93.12 18.21,93.93 18.29,94.01 19.02,94.01 19.53,94.52 25.83,94.52
+5VSB on BOTTOM (solid shape): 198.86,50.78 198.86,49.74 199.11,49.48 200.38,49.48 200.71,49.15 200.71,47.42 200.46,47.17 196.42,47.17 196.27,47.32 196.27,47.93 195.99,48.21 195.68,48.21 194.87,49.02 194.87,49.43 195.07,49.63 195.38,49.63 195.61,49.41 196.27,49.41 196.57,49.71 196.57,50.27 197.08,50.27 197.21,50.4 197.21,50.75 197.33,50.88 198.76,50.88
+5VSB on BOTTOM (solid shape): 197.21,52.71 197.23,52.69 197.22,52.66 197.32,52.27 197.72,52.16 197.75,52.17 197.99,51.92 197.99,51.74 198.04,51.69 198.18,51.69 198.2,51.68 198.86,51.68 198.86,51.49 198.85,51.48 198.23,51.48 198.22,51.49 197.66,51.49 197.14,52.01 197.14,52.11 197.05,52.2 196.62,52.2 196.55,52.28 196.55,52.83 196.65,52.94 197.21,52.94
+5VSB on VCC (solid shape): outline of 258 points within 15.04,12.47 205.13,94.41
+5VSB&+3P3VSB_IN on TOP (solid shape): 190.48,53.38 190.48,50.41 189.46,49.38 188.19,49.38 188.09,49.48 187.93,49.48 187.86,49.56 187.86,52.71 188.87,53.72 190.14,53.72
