# Allegro board 5n-armani13.a00.0828.brd (continued)
## Nets (continued)
GND: C0400.2 C0500.2 C0600.2 C0601.2 C0602.2 C0603.2 C0604.2 C0605.2 C0606.2 C0607.2 C0608.2 C0609.2 C0610.2 C0611.2 C0612.2 C0613.2 C0614.2 C0615.2 C0616.2 C0617.2 C0618.2 C0619.2 C0620.2 C0621.2 C0622.2 C0623.2 C0700.2 C0701.2 C0702.2 C0703.2 C0704.2 C0705.2 C0706.2 C0707.2 C0708.2 C0709.2 C0710.2 C0711.2 C0712.2 C0713.2 C0714.2 C0715.2 C0716.2 C0717.2 C0718.2 C0719.2 C0720.2 C0721.2 C0722.2 C0723.2 C0724.2 C0725.2 C0726.2 C0727.2 C0728.2 C0729.2 C0730.2 C0731.2 C0732.2 C0733.2 C0734.2 C0735.2 C0736.2 C0737.2 C0738.2 C0739.2 C0740.2 C0741.2 C0742.2 C0743.2 C0744.2 C0745.2 C0746.2 C0747.2 C0748.2 C0749.2 C0900.1 C0901.1 C1000.1 C1001.1 C1002.2 C1003.2 C1004.2 C1005.2 C1006.2 C1100.2 C1101.2 C1102.2 C1103.2 C1104.2 C1105.2 C1200.2 C1201.2 C1202.2 C1203.2 C1204.2 C1205.2 C1206.2 C1207.2 C1600.2 C1601.2 C1602.2 C1603.2 C1604.2 C1605.2 C1606.2 C1607.2 C1608.2 C1609.2 C1610.2 C1611.1 C1612.2 C1613.2 C1614.2 C1615.2 C1616.2 C1617.2 C1618.2 C1619.2 C1620.2 C1621.2 C1622.2 C1623.2 C1624.2 C1625.2 C1626.2 C1627.2 C1628.2 C1629.2 C1630.2 C1631.2 C1632.2 C1633.2 C1634.2 C1800.2 C1900.2 C1901.2 C1902.2 C1903.2 C1904.2 C1905.2 C1906.2 C2000.2 C2001.2 C2002.2 C2003.2 C2004.2 C2005.2 C2006.2 C2007.2 C2009.2 C2010.2 C2011.2 C2012.2 C2100.2 C2101.2 C2102.2 C2103.2 C2104.2 C2105.2 C2106.2 C2107.2 C2108.2 C2110.2 C2111.2 C2200.2 C2201.2 C2202.2 C2203.2 C2204.2 C2205.2 C2206.2 C2207.2 C2208.2 C2209.2 C2210.2 C2211.2 C2212.2 C2213.2 C2214.2 C2215.2 C2216.2 C2217.2 C2218.2 C2219.2 C2220.2 C2221.2 C2222.2 C2223.2 C2224.2 C2225.2 C2226.2 C2227.2 C2228.2 C2229.2 C2230.2 C2231.2 C2232.2 C2233.2 C2234.2 C2235.2 C2236.2 C2237.2 C2238.2 C2239.2 C2240.2 C2241.2 C2242.2 C2243.2 C2300.2 C2301.2 C2302.2 C2303.2 C2304.2 C2305.2 C2306.2 C2307.2 C2308.2 C2309.2 C2310.2 C2311.2 C2312.1 C2313.2 C2314.2 C2315.2 C2316.2 C2318.2 C2319.2 C2400.2 C2401.2 C2500.2 C2501.2 C2502.2 C2503.2 C2504.2 C2505.2 C2506.2 C2600.2 C2601.2 C2908.2 C2909.2 C3000.2 C3001.2 C3002.2 C3003.2 C3010.2 C3011.2 C3100.2 C3101.2 C3102.2 C3103.2 C3108.2 C3109.2 C3110.2 C3115.2 C3116.2 C3117.2 C3118.2 C3119.2 C3124.2 C3125.2 C3127.2 C3600.2 C3601.2 C3602.2 C3603.2 C3605.2 C3700.2 C3701.2 C3702.2 C3703.2 C3704.2 C3705.2 C3707.2 C3800.2 C3801.2 C3802.2 C3803.2 C3804.2 C3805.2 C3806.2 C3807.2 C3814.2 C3816.2 C3817.1 C3827.2 C3828.2 C3832.2 C3833.2 C3835.1 C3836.1 C3837.1 C3838.1 C3839.1 C3840.2 C3841.2 C3842.2 C3843.2 C3901.2 C3902.2 C3903.2 C3904.2 C3905.2 C3906.2 C3907.2 C3908.2 C3909.2 C3910.2 C3911.2 C3913.2 C3914.2 C5100.2 C5101.2 C5102.2 C5103.2 C5104.2 C5105.2 C5106.2 C5107.2 C5108.2 C5109.2 C5110.2 C5111.2 C5112.2 C5113.2 C5114.2 C5115.2 C5116.2 C5117.2 C5118.2 C5119.2 C5120.2 C5121.2 C5122.2 C5123.2 C5124.2 C5125.2 C5126.2 C5127.2 C5128.2 C5129.2 C5130.2 C5132.2 C5300.1 C5301.1 C5700.2 C5701.2 C5702.2 C5703.2 C5704.2 C5723.2 C5724.2 C5800.2 C5801.2 C5802.2 C5803.2 C5804.2 C5805.2 C5806.2 C5807.2 C5808.2 C5809.2 C5810.2 C5811.2 C5812.2 C5813.2 C5814.2 C5900.2 C5903.2 C5905.2 C5906.2 C5907.2 C5908.2 C5909.2 C5910.2 C5911.2 C5912.2 C5913.2 C6016.2 C6200.2 C6201.2 C6202.2 C6203.2 C6300.2 C6301.2 C6302.2 C6305.2 C6600.2 C6601.2 C6602.2 C6603.2 C6604.2 C6605.2 C6606.2 C6607.2 C6608.2 C6609.2 C6610.2 C6611.2 C6612.2 C6613.2 C6614.2 C6615.2 C6616.2 C6617.2 C6618.2 C6619.2 C6620.2 C6621.2 C6622.2 C6623.2 C6624.2 C6625.2 C6626.2 C6627.2 C6628.2 C6629.2 C6630.2 C6631.2 C6632.2 C6633.2 C6634.2 C6635.2 C6636.2 C6637.2 C6700.2 C6701.2 C6702.2 C6703.2 C6704.2 C6705.2 C6706.2 C6707.2 C6708.2 C6709.2 C6710.2 C6711.2 C6712.2 C6713.2 C6714.2 C6715.2 C6716.2 C6717.2 C6718.2 C6719.2 C6720.2 C6721.2 C6722.2 C6723.2 C6724.2 C6725.2 C6726.2 C6727.2 C6728.2 C6729.2 C6730.2 C6731.2 C6732.2 C6733.2 C6734.2 C6735.2 C6736.2 C6737.2 C6738.2 C6739.2 C6740.2 C6741.2 C6742.2 C6743.2 C6744.2 C6745.2 C6746.2 C6747.2 C6748.2 C6749.2 C6750.2 C6751.2 C6752.2 C6753.2 C6754.2 C6800.2 C6801.2 C6802.2 C6803.2 C6900.2 C6901.2 C6907.2 C6908.2 C7001.2 C7005.2 C7006.2 C7007.2 C7008.2 C7100.2 C7101.2 C7102.2 C7103.2 CE2200.2 CE2201.2 CON2000.1(VSS1) CON2000.2(VSS2) CON2000.5(VSS3) CON2000.6(VSS4) CON2000.9(VSS5) CON2000.10(VSS6) CON2000.14(VSS7) CON2000.15(VSS8) CON2000.18(VSS9) CON2000.19(VSS10) CON2000.22(VSS11) CON2000.23(VSS12) CON2000.26(VSS13) CON2000.27(VSS14) CON2000.30(VSS15) CON2000.31(VSS16) CON2000.35(VSS17) CON2000.36(VSS18) CON2000.39(VSS19) CON2000.40(VSS20) CON2000.43(VSS21) CON2000.44(VSS22) CON2000.47(VSS23) CON2000.48(VSS24) CON2000.51(VSS25) CON2000.52(VSS26) CON2000.56(VSS27) CON2000.57(VSS28) CON2000.60(VSS29) CON2000.61(VSS30) CON2000.64(VSS31) CON2000.65(VSS32) CON2000.68(VSS33) CON2000.69(VSS34) CON2000.72(VSS35) CON2000.73(VSS36) CON2000.77(VSS37) CON2000.78(VSS38) CON2000.81(VSS39) CON2000.82(VSS40) CON2000.85(VSS41) CON2000.86(VSS42) CON2000.89(VSS43) CON2000.90(VSS44) CON2000.93(VSS45) CON2000.94(VSS46) CON2000.98(VSS47) CON2000.99(VSS48) CON2000.102(VSS49) CON2000.103(VSS50) CON2000.106(VSS51) CON2000.107(VSS52) CON2000.166(SA2) CON2000.167(VSS53) CON2000.168(VSS54) CON2000.171(VSS55) CON2000.172(VSS56) CON2000.175(VSS57) CON2000.176(VSS58) CON2000.180(VSS59) CON2000.181(VSS60) CON2000.184(VSS61) CON2000.185(VSS62) CON2000.188(VSS63) CON2000.189(VSS64) CON2000.192(VSS65) CON2000.193(VSS66) CON2000.196(VSS67) CON2000.197(VSS68) CON2000.201(VSS69) CON2000.202(VSS70) CON2000.205(VSS71) CON2000.206(VSS72) CON2000.209(VSS73) CON2000.210(VSS74) CON2000.213(VSS75) CON2000.214(VSS76) CON2000.217(VSS77) CON2000.218(VSS78) CON2000.222(VSS79) CON2000.223(VSS80) CON2000.226(VSS81) CON2000.227(VSS82) CON2000.230(VSS83) CON2000.231(VSS84) CON2000.234(VSS85) CON2000.235(VSS86) CON2000.238(VSS87) CON2000.239(VSS88) CON2000.243(VSS89) CON2000.244(VSS90) CON2000.247(VSS91) CON2000.248(VSS92) CON2000.251(VSS93) CON2000.252(VSS94) CON2000.256(SA0) CON2000.260(SA1) CON2000.263(SIDE1) CON2000.264(SIDE2) CON2100.1(VSS1) CON2100.2(VSS2) CON2100.5(VSS3) CON2100.6(VSS4) CON2100.9(VSS5) CON2100.10(VSS6) CON2100.14(VSS7) CON2100.15(VSS8) CON2100.18(VSS9) CON2100.19(VSS10) CON2100.22(VSS11) CON2100.23(VSS12) CON2100.26(VSS13) CON2100.27(VSS14) CON2100.30(VSS15) CON2100.31(VSS16) CON2100.35(VSS17) CON2100.36(VSS18) CON2100.39(VSS19) CON2100.40(VSS20) CON2100.43(VSS21) CON2100.44(VSS22) CON2100.47(VSS23) CON2100.48(VSS24) CON2100.51(VSS25) CON2100.52(VSS26) CON2100.56(VSS27) CON2100.57(VSS28) CON2100.60(VSS29) CON2100.61(VSS30) CON2100.64(VSS31) CON2100.65(VSS32) CON2100.68(VSS33) CON2100.69(VSS34) CON2100.72(VSS35) CON2100.73(VSS36) CON2100.77(VSS37) CON2100.78(VSS38) CON2100.81(VSS39) CON2100.82(VSS40) CON2100.85(VSS41) CON2100.86(VSS42) CON2100.89(VSS43) CON2100.90(VSS44) CON2100.93(VSS45) CON2100.94(VSS46) CON2100.98(VSS47) CON2100.99(VSS48) CON2100.102(VSS49) CON2100.103(VSS50) CON2100.106(VSS51) CON2100.107(VSS52) CON2100.166(SA2) CON2100.167(VSS53) CON2100.168(VSS54) CON2100.171(VSS55) CON2100.172(VSS56) CON2100.175(VSS57) CON2100.176(VSS58) CON2100.180(VSS59) CON2100.181(VSS60) CON2100.184(VSS61) CON2100.185(VSS62) CON2100.188(VSS63) CON2100.189(VSS64) CON2100.192(VSS65) CON2100.193(VSS66) CON2100.196(VSS67) CON2100.197(VSS68) CON2100.201(VSS69) CON2100.202(VSS70) CON2100.205(VSS71) CON2100.206(VSS72) CON2100.209(VSS73) CON2100.210(VSS74) CON2100.213(VSS75) CON2100.214(VSS76) CON2100.217(VSS77) CON2100.218(VSS78) CON2100.222(VSS79) CON2100.223(VSS80) CON2100.226(VSS81) CON2100.227(VSS82) CON2100.230(VSS83) CON2100.231(VSS84) CON2100.234(VSS85) CON2100.235(VSS86) CON2100.238(VSS87) CON2100.239(VSS88) CON2100.243(VSS89) CON2100.244(VSS90) CON2100.247(VSS91) CON2100.248(VSS92) CON2100.251(VSS93) CON2100.252(VSS94) CON2100.256(SA0) CON2100.263(SIDE1) CON2100.264(SIDE2) CON2600.2(TMDS_DATA2_SHIELD) CON2600.5(TMDS_DATA1_SHIELD) CON2600.8(TMDS_DATA0_SHIELD) CON2600.11(TMDS_CLOCK+_SHIELD) CON2600.17(DDC/CEC_GROUND/HEAC_SHIELD) CON2600.20(P_GND1) CON2600.21(P_GND2) CON2600.22(P_GND3) CON2600.23(P_GND4) CON3000.5 CON3000.11 CON3000.17 CON3000.20 CON3000.23 CON3000.26 CON3000.31(SIDE1) CON3000.32(SIDE2) CON3100.1 CON3100.3 CON3100.9 CON3100.15 CON3100.21 CON3100.27 CON3100.33 CON3100.39 CON3100.45 CON3100.51 CON3100.57 CON3100.71 CON3100.73 CON3100.75 CON3100.76(SIDE_1) CON3100.77(SIDE_2) CON3101.1 CON3101.4 CON3101.7 CON3101.13(SIDE1) CON3101.14(SIDE2) CON3600.2 CON3600.5(SIDE1) CON3600.6(SIDE2) CON3601.7 CON3601.8 CON3601.9 CON3601.10 CON3601.11(GND1) CON3601.12(GND2) CON3602.1 CON3602.3(SIDE1) CON3602.4(SIDE2) CON3800.5 CON3800.7(SIDE1) CON3800.8(SIDE2) CON5100.5 CON5100.9(SIDE1) CON5100.10(SIDE2) CON5101.5(SIDE1) CON5101.6(SIDE2) CON5102.1 CON5102.31(SIDE1) CON5102.32(SIDE2) CON5103.1 CON5103.6 CON5103.11 CON5103.16 CON5103.21 CON5103.26 CON5103.51(SIDE1) CON5103.52(SIDE2) CON5103.53(SIDE3) CON5103.54(SIDE4) CON5104.4 CON5104.9 CON5104.12 CON5104.21(SIDE1) CON5104.22(SIDE2) CON5104.23(SIDE3) CON5104.24(SIDE4) CON5700.13(P_GND1) CON5700.14(P_GND2) CON5700.15(P_GND3) CON5700.16(SIDE1) CON5700.17(SIDE2) CON5700.18(SIDE3) CON5700.19(SIDE4) CON5700.20(P_GND4) CON5700.21(P_GND5) CON5700.22(P_GND6) CON5700.A1(GND2) CON5700.A12(GND1) CON5700.B1(GND3) CON5700.B12(GND4) CON7600.1 CON7600.2 CON7600.3 CON7600.8(SIDE1) CON7600.9(SIDE2) D2600.2(CATHODE) D2900.2(CATHODE) D2901.2(CATHODE) D3001.2(CATHODE) D3002.2(CATHODE) D3601.2(CATHODE) D3602.2(CATHODE) D3603.2(CATHODE) D3800.1(ANODE) D3801.1(ANODE) D3802.1(ANODE) D3803.1(ANODE) D3804.2(CATHODE) D3806.2(CATHODE) D5100.2(CATHODE) D5101.2(CATHODE) D5102.2(CATHODE) D5103.2(CATHODE) D5700.2(CATHODE) D5701.2(CATHODE) D5702.2(CATHODE) D5703.2(CATHODE) D5704.2(CATHODE) D5705.2(CATHODE) D5706.2(CATHODE) D5707.2(CATHODE) D5708.1(ANODE) D5709.1(ANODE) H5201.1 H5202.1 H5204.1 H5205.1 H5207.1 H5208.1 H5209.1 H5210.1 H5211.1 H5212.1 H5213.1 H5214.1 H5215.1 H5216.1 J5300.3 J5300.6 J5300.8 J5300.13(SIDE1) J5300.14(SIDE2) J5301.9 J5301.11 J5301.13(SIDE1) J5301.14(SIDE2) PC7600.2 PC7601.2 PC7603.2 PC7605.2 PC7606.2 PC7607.2 PC7608.2 PC7609.2 PC7611.2 PC7612.2 PC7700.2 PC7701.2 PC7702.2 PC7703.2 PC7704.2 PC7705.2 PC7706.2 PC7707.2 PC7709.2 PC7710.2 PC7712.2 PC7713.2 PC7714.2 PC7716.2 PC7717.2 PC7719.2 PC7720.2 PC7721.2 PC7722.2 PC7723.2 PC7801.2 PC7802.2 PC7804.1 PC7806.2 PC7812.1 PC7813.2 PC7814.2 PC7815.2 PC7816.1 PC7820.2 PC7822.2 PC7823.2 PC7824.1 PC7825.1 PC7826.2 PC7829.2 PC7831.2 PC7832.2 PC7835.1 PC7836.2 PC7837.2 PC7838.2 PC7841.2 PC7900.2 PC7901.2 PC7902.2 PC7905.2 PC7906.2 PC7907.2 PC7908.2 PC7909.2 PC7912.2 PC7913.2 PC7914.2 PC7915.2 PC8001.2 PC8002.2 PC8003.2 PC8005.2 PC8006.2 PC8007.2 PC8008.2 PC8009.2 PC8012.2 PC8013.2 PC8100.2 PC8101.2 PC8102.2 PC8103.2 PC8104.2 PC8105.2 PC8106.2 PC8107.2 PC8108.2 PC8109.2 PC8110.2 PC8111.2 PC8112.2 PC8113.2 PC8114.2 PC8115.2 PC8116.2 PC8117.2 PC8118.2 PC8119.2 PC8120.2 PC8121.2 PC8122.2 PC8123.2 PC8124.2 PC8125.2 PC8126.2 PC8127.2 PC8128.2 PC8129.2 PC8130.2 PC8131.2 PC8132.2 PC8133.2 PC8134.2 PC8135.2 PC8136.2 PC8137.2 PC8138.2 PC8139.2 PC8140.2 PC8141.2 PC8142.2 PC8143.2 PC8144.2 PC8145.2 PC8146.2 PC8147.2 PC8148.2 PC8149.2 PC8150.2 PC8151.2 PC8152.2 PC8153.2 PC8154.2 PC8155.2 PC8156.2 PC8157.2 PC8158.2 PC8159.2 PC8160.2 PC8161.2 PC8162.2 PC8163.2 PC8164.2 PC8165.2 PC8166.2 PC8167.2 PC8168.2 PC8169.2 PC8170.2 PC8171.2 PC8172.2 PC8173.2 PC8174.2 PC8175.2 PC8176.2 PC8177.2 PC8178.2 PC8179.2 PC8180.2 PC8181.2 PC8182.2 PC8183.2 PC8184.2 PC8185.2 PC8186.2 PC8187.2 PC8600.2 PC8602.2 PC8603.2 PC8605.2 PC8606.2 PC8607.2 PC8608.2 PC8609.2 PC8610.2 PC8612.2 PC8613.2 PC8614.2 PC8615.2 PC8616.2 PC8617.2 PC8618.2 PC8619.2 PC8620.2 PC8621.2 PC8622.1 PC8700.2 PC8701.2 PC8702.2 PC8703.2 PC8705.2 PC8706.2 PC8707.2 PC8708.2 PC8710.2 PC8711.2 PC8712.2 PC8713.2 PC8714.2 PC8715.1 PC8800.2 PC8801.2 PC8802.2 PC8804.2 PC8805.2 PC8806.2 PC8807.2 PC8808.2 PC8809.2 PC8811.2 PC8812.2 PC8813.2 PC8814.2 PC8901.2 PC8902.2 PC8903.2 PC8905.2 PC8906.2 PC8908.2 PC8909.2 PC8910.2 PC8911.2 PC8913.2 PC8914.2 PC8915.2 PC8917.2 PC8918.2 PC8919.2 PC8920.2 PC8921.2 PC8923.2 PC8924.2 PC8925.2 PC9000.2 PC9001.2 PC9002.2 PC9003.2 PC9004.2 PC9005.2 PC9007.2 PC9100.2 PC9101.2 PC9102.2 PC9103.2 PC9104.2 PC9105.2 PC9107.2 PC9108.2 PC9109.2 PC9110.2 PC9111.2 PC9112.2 PC9113.2 PC9114.2 PC9200.2 PC9201.2 PC9202.2 PC9203.2 PC9204.2 PC9205.2 PC9206.2 PC9402.2 PC9403.1 PC9404.2 PC9405.1 PC9406.1 PC9411.2 PC9413.2 PC9414.2 PC9418.2 PC9419.2 PC9420.2 PC9421.2 PC9422.2 PC9423.2 PC9500.2 PC9501.2 PC9502.2 PC9503.2 PC9504.2 PC9505.2 PC9506.2 PC9507.2 PC9509.2 PC9510.2 PC9511.2 PC9512.2 PC9513.2 PC9514.2 PC9515.2 PC9516.2 PC9518.2 PC9600.2 PC9601.2 PC9603.2 PC9605.2 PC9606.2 PC9607.2 PC9608.2 PC9609.2 PC9610.2 PC9611.2 PC9612.2 PC9613.2 PC9614.2 PC9615.2 PC9616.2 PC9617.2 PC9618.2 PC9619.2 PC9620.2 PC9621.2 PC9622.2 PC9623.2 PC9626.2 PC9627.2 PC9800.2 PC9801.2 PC9802.2 PC9803.2 PC9805.2 PC9806.2 PC9807.2 PC9808.2 PC9809.2 PC9811.2 PCE7900.2 PCE8000.2 PCE8100.2 PCE8600.2 PCE8900.2 PCE8901.2 PCE8902.2 PCE9600.2 PCE9601.2 PCE9602.2 PD7600.1(ANODE) PD7601.1(ANODE1) PD7602.1(ANODE) PQ7602.2(EMITTER) PQ7603.1(SOURCE) PQ7603.4(SOURCE) PQ7605.3(COLLECTOR2) PQ7608.1(SOURCE) PQ7609.1(EMITTER1) PQ7610.3(COLLECTOR2) PQ7612.1(SOURCE) PQ7612.4(SOURCE) PQ7702.1(S_1) PQ7702.2(S_2) PQ7702.3(S_3) PQ7704.1(S_1) PQ7704.2(S_2) PQ7704.3(S_3) PQ7900.9(GND(LSS)) PQ7900.11(GND(LSS)_1) PQ7900.12(GND(LSS)_2) PQ7900.13(GND(LSS)_3) PQ7900.14(GND(LSS)_4) PQ7900.15(GND(LSS)_5) PQ7900.16(GND(LSS)_6) PQ7900.17(GND(LSS)_7) PQ7900.18(GND(LSS)_8) PQ7901.9(GND(LSS)) PQ7901.11(GND(LSS)_1) PQ7901.12(GND(LSS)_2) PQ7901.13(GND(LSS)_3) PQ7901.14(GND(LSS)_4) PQ7901.15(GND(LSS)_5) PQ7901.16(GND(LSS)_6) PQ7901.17(GND(LSS)_7) PQ7901.18(GND(LSS)_8) PQ8000.5(S2_1) PQ8000.6(S2_2) PQ8000.7(S2_3) PQ8001.9(GND(LSS)) PQ8001.11(GND(LSS)_1) PQ8001.12(GND(LSS)_2) PQ8001.13(GND(LSS)_3) PQ8001.14(GND(LSS)_4) PQ8001.15(GND(LSS)_5) PQ8001.16(GND(LSS)_6) PQ8001.17(GND(LSS)_7) PQ8001.18(GND(LSS)_8) PQ8600.5(S2_1) PQ8600.6(S2_2) PQ8600.7(S2_3) PQ8900.5(S2_1) PQ8900.6(S2_2) PQ8900.7(S2_3) PQ8901.5(S2_1) PQ8901.6(S2_2) PQ8901.7(S2_3) PQ9600.9(GND(LSS)) PQ9600.11(GND(LSS)_1) PQ9600.12(GND(LSS)_2) PQ9600.13(GND(LSS)_3) PQ9600.14(GND(LSS)_4) PQ9600.15(GND(LSS)_5) PQ9600.16(GND(LSS)_6) PQ9600.17(GND(LSS)_7) PQ9600.18(GND(LSS)_8) PQ9601.9(GND(LSS)) PQ9601.11(GND(LSS)_1) PQ9601.12(GND(LSS)_2) PQ9601.13(GND(LSS)_3) PQ9601.14(GND(LSS)_4) PQ9601.15(GND(LSS)_5) PQ9601.16(GND(LSS)_6) PQ9601.17(GND(LSS)_7) PQ9601.18(GND(LSS)_8) PR7610.2 PR7612.2 PR7616.2 PR7618.2 PR7621.2 PR7623.2 PR7626.2 PR7637.2 PR7638.2 PR7645.2 PR7646.2 PR7709.2 PR7710.2 PR7716.2 PR7823.2 PR7824.1 PR7825.2 PR7829.2 PR7830.1 PR7832.2 PR7833.2 PR7849.1 PR7850.2 PR7856.1 PR8608.2 PR8610.2 PR8611.1 PR8706.2 PR8708.2 PR8800.2 PR8802.2 PR8809.2 PR8810.2 PR8906.2 PR8909.1 PR8911.2 PR8912.1 PR8919.2 PR8922.2 PR8923.1 PR9001.2 PR9005.2 PR9101.2 PR9104.2 PR9107.2 PR9110.2 PR9201.2 PR9207.2 PR9436.2 PR9437.1 PR9443.1 PR9457.1 PR9458.2 PR9459.2 PR9460.2 PR9502.2 PR9507.2 PR9606.2 PR9610.2 PR9805.1 PR9806.1 PR9807.1 PR9808.1 PR9812.1 PT9505.1 PT9506.1 PT9507.1 PT9513.1 PT9514.1 PT9515.1 PU7600.2(GND) PU7700.33(GND_1) PU7700.34(GND_2) PU7700.35(GND_3) PU7700.36(GND_4) PU7700.37(GND_5) PU7700.38(GND_6) PU7800.41(GND) PU7800.42(GND1) PU7800.43(GND2) PU7800.44(GND3) PU7800.45(GND4) PU7800.46(GND5) PU7800.47(GND6) PU7800.48(GND7) PU7800.49(GND8) PU7900.4(GND1) PU7900.9(GND2) PU7900.10(GND3) PU7901.4(GND1) PU7901.9(GND2) PU7901.10(GND3) PU8000.4(GND1) PU8000.9(GND2) PU8000.10(GND3) PU8001.4(GND1) PU8001.9(GND2) PU8001.10(GND3) PU8600.1(VTTGND) PU8600.3(GND1) PU8600.11(VID) PU8600.14(PGND) PU8600.21(GND2) PU8600.22(GND3) PU8600.23(GND4) PU8600.24(GND5) PU8600.25(GND6) PU8700.2(PGND) PU8700.4(AGND) PU8700.16(EN1) PU8800.11(GND) PU8800.12(GND1) PU8800.13(GND2) PU8800.14(GND3) PU8800.15(GND4) PU8801.11(GND) PU8801.12(GND1) PU8801.13(GND2) PU8801.14(GND3) PU8801.15(GND4) PU8900.21(GND) PU8900.22(GND1) PU8900.23(GND2) PU8900.24(GND3) PU8900.25(GND4) PU9000.3(GND) PU9001.11(GND1) PU9001.15(GND2) PU9100.11(GND1) PU9100.15(GND2) PU9101.11(GND1) PU9101.15(GND2) PU9200.11(GND1) PU9200.15(GND2) PU9400.41(GND) PU9400.42(GND1) PU9400.43(GND2) PU9400.44(GND3) PU9400.45(GND4) PU9500.4(PGND1) PU9500.8(SGND) PU9500.9(PGND2) PU9500.10(GND3) PU9501.11(GND) PU9501.12(GND1) PU9501.13(GND2) PU9501.14(GND3) PU9501.15(GND4) PU9800.2(PGND) PU9800.11(AGND) Q0400.2(SOURCE) Q1000.2(SOURCE) Q2400.1(SOURCE) Q2400.4(SOURCE) Q2401.4(SOURCE) Q2403.2(SOURCE) Q2601.2(SOURCE) Q2901.1(SOURCE) Q3100.2(SOURCE) Q3101.1(SOURCE) Q3101.4(SOURCE) Q3600.2(SOURCE) Q3601.2(SOURCE) Q5002.1(SOURCE) Q5002.4(SOURCE) Q5100.2(SOURCE) Q5102.1(SOURCE) Q5800.2(SOURCE) Q6901.2(SOURCE) Q7200.2(SOURCE) Q7201.2(SOURCE) Q7202.2(SOURCE) Q7203.2(SOURCE) Q7204.2(SOURCE) R0404.1 R0405.1 R0406.1 R0407.1 R0411.1 R0415.1 R0420.1 R0500.2 R0501.2 R0502.2 R0504.2 R0607.2 R0609.2 R0702.2 R0900.2 R0901.2 R1006.2 R1018.2 R1019.2 R1023.2 R1027.2 R1028.2 R1029.2 R1030.2 R1207.2 R1212.2 R1213.2 R1218.2 R1225.1 R1226.2 R1300.1 R1301.2 R1400.2 R1410.2 R1411.2 R1505.2 R1508.2 R1511.2 R1512.2 R1517.2 R1520.2 R1607.2 R1608.2 R1807.2 R2005.2 R2006.2 R2103.2 R2104.2 R2313.2 R2315.2 R2322.2 R2325.2 R2328.1 R2332.2 R2341.1 R2344.2 R2405.2 R2408.2 R2413.2 R2414.2 R2416.2 R2423.2 R2509.2 R2512.1 R2602.1 R3005.2 R3009.2 R3102.2 R3107.2 R3606.2 R3609.2 R3614.2 R3703.2 R3815.1 R3816.1 R3817.1 R3818.1 R3819.1 R3822.2 R3904.2 R3911.2 R5110.2 R5700.2 R5701.2 R5704.2 R5706.2 R5710.2 R5716.2 R5720.2 R5804.1 R5820.2 R5821.1 R5822.2 R5826.2 R5827.2 R5900.2 R5903.1 R5904.2 R5906.2 R5907.2 R6006.2 R6201.2 R6202.2 R6204.2 R6206.2 R6300.2 R6303.1 R6305.2 R6307.2 R6308.2 R6309.2 R6800.1 R6801.1 R6802.1 R6803.1 R6805.2 R6807.2 R6809.2 R6811.2 R6816.1 R6817.1 R6818.1 R6819.1 R6907.1 R6914.2 R6936.1 R6937.1 R6939.1 R6940.1 R6941.1 R7003.2 TR3700.2 U0400.A5(VSS_4) U0400.A65(SKTOCC#) U0400.A67(VSS_5) U0400.A70(VSS_6) U0400.AA2(VSS_7) U0400.AA4(VSS_8) U0400.AA65(VSS_9) U0400.AA68(VSS_10) U0400.AB8(VSS_15) U0400.AB15(VSS_11) U0400.AB16(VSS_12) U0400.AB18(VSS_13) U0400.AB21(VSS_14) U0400.AD8(VSS_22) U0400.AD13(VSS_16) U0400.AD16(VSS_17) U0400.AD19(VSS_18) U0400.AD20(VSS_19) U0400.AD21(VSS_20) U0400.AD62(VSS_21) U0400.AE64(VSS_23) U0400.AE65(VSS_24) U0400.AE66(VSS_25) U0400.AE67(VSS_26) U0400.AE68(VSS_27) U0400.AE69(VSS_28) U0400.AF1(VSS_29) U0400.AF2(VSS_33) U0400.AF4(VSS_34) U0400.AF10(VSS_30) U0400.AF15(VSS_31) U0400.AF17(VSS_32) U0400.AF63(VSS_35) U0400.AG16(VSS_36) U0400.AG17(VSS_37) U0400.AG18(VSS_38) U0400.AG19(VSS_39) U0400.AG20(VSS_40) U0400.AG21(VSS_41) U0400.AG71(VSS_42) U0400.AH6(VSS_44) U0400.AH13(VSS_43) U0400.AH63(VSS_45) U0400.AH64(VSS_46) U0400.AH67(VSS_47) U0400.AJ4(VSS_51) U0400.AJ15(VSS_48) U0400.AJ18(VSS_49) U0400.AJ20(VSS_50) U0400.AK8(VSS_61) U0400.AK11(VSS_52) U0400.AK16(VSS_53) U0400.AK18(VSS_54) U0400.AK21(VSS_55) U0400.AK22(VSS_56) U0400.AK27(VSS_57) U0400.AK63(VSS_58) U0400.AK68(VSS_59) U0400.AK69(VSS_60) U0400.AL2(VSS_62) U0400.AL4(VSS_67) U0400.AL28(VSS_63) U0400.AL32(VSS_64) U0400.AL35(VSS_65) U0400.AL38(VSS_66) U0400.AL45(VSS_68) U0400.AL48(VSS_69) U0400.AL52(VSS_70) U0400.AL55(VSS_71) U0400.AL58(VSS_72) U0400.AL64(VSS_73) U0400.AL65(VSS_74) U0400.AL66(VSS_75) U0400.AM8(VSS_88) U0400.AM13(VSS_76) U0400.AM21(VSS_77) U0400.AM25(VSS_78) U0400.AM27(VSS_79) U0400.AM43(VSS_80) U0400.AM45(VSS_81) U0400.AM46(VSS_82) U0400.AM55(VSS_83) U0400.AM60(VSS_84) U0400.AM61(VSS_85) U0400.AM68(VSS_86) U0400.AM71(VSS_87) U0400.AN20(VSS_89) U0400.AN23(VSS_90) U0400.AN28(VSS_91) U0400.AN30(VSS_92) U0400.AN32(VSS_93) U0400.AN33(VSS_94) U0400.AN35(VSS_95) U0400.AN37(VSS_96) U0400.AN38(VSS_97) U0400.AN40(VSS_98) U0400.AN42(VSS_99) U0400.AN58(VSS_100) U0400.AN63(VSS_101) U0400.AP10(VSS_102) U0400.AP18(VSS_103) U0400.AP20(VSS_104) U0400.AP23(VSS_105) U0400.AP28(VSS_106) U0400.AP32(VSS_107) U0400.AP35(VSS_108) U0400.AP38(VSS_109) U0400.AP42(VSS_110) U0400.AP58(VSS_111) U0400.AP63(VSS_112) U0400.AP68(VSS_113) U0400.AP70(VSS_114) U0400.AR5(VSS_127) U0400.AR8(VSS_134) U0400.AR11(VSS_115) U0400.AR15(VSS_116) U0400.AR16(VSS_117) U0400.AR20(VSS_118) U0400.AR23(VSS_119) U0400.AR28(VSS_120) U0400.AR35(VSS_121) U0400.AR42(VSS_122) U0400.AR43(VSS_123) U0400.AR45(VSS_124) U0400.AR46(VSS_125) U0400.AR48(VSS_126) U0400.AR50(VSS_128) U0400.AR52(VSS_129) U0400.AR53(VSS_130) U0400.AR55(VSS_131) U0400.AR58(VSS_132) U0400.AR63(VSS_133) U0400.AT2(VSS_135) U0400.AT4(VSS_140) U0400.AT20(VSS_136) U0400.AT23(VSS_137) U0400.AT28(VSS_138) U0400.AT35(VSS_139) U0400.AT42(VSS_141) U0400.AT56(VSS_142) U0400.AT58(VSS_143) U0400.AT63(VSS_144) U0400.AT68(VSS_145) U0400.AT71(VSS_146) U0400.AU10(VSS_147) U0400.AU15(VSS_148) U0400.AU20(VSS_149) U0400.AU32(VSS_150) U0400.AU38(VSS_151) U0400.AV1(VSS_152) U0400.AV68(VSS_153) U0400.AV69(VSS_154) U0400.AV70(VSS_155) U0400.AV71(VSS_156) U0400.AW6(VSS_180) U0400.AW8(VSS_185) U0400.AW10(VSS_157) U0400.AW12(VSS_158) U0400.AW14(VSS_159) U0400.AW16(VSS_160) U0400.AW18(VSS_161) U0400.AW21(VSS_162) U0400.AW23(VSS_163) U0400.AW26(VSS_164) U0400.AW28(VSS_165) U0400.AW30(VSS_166) U0400.AW32(VSS_167) U0400.AW34(VSS_168) U0400.AW36(VSS_169) U0400.AW38(VSS_170) U0400.AW41(VSS_171) U0400.AW43(VSS_172) U0400.AW45(VSS_173) U0400.AW47(VSS_174) U0400.AW49(VSS_175) U0400.AW51(VSS_176) U0400.AW53(VSS_177) U0400.AW55(VSS_178) U0400.AW57(VSS_179) U0400.AW60(VSS_181) U0400.AW62(VSS_182) U0400.AW64(VSS_183) U0400.AW66(VSS_184) U0400.AY66(VSS_186) U0400.B10(VSS_187) U0400.B14(VSS_188) U0400.B18(VSS_189) U0400.B22(VSS_190) U0400.B30(VSS_191) U0400.B34(VSS_192) U0400.B39(VSS_193) U0400.B44(VSS_194) U0400.B48(VSS_195) U0400.B53(VSS_196) U0400.B58(VSS_197) U0400.B62(VSS_198) U0400.B66(VSS_199) U0400.B71(VSS_200) U0400.BA1(VSS_201) U0400.BA2(VSS_205) U0400.BA6(VSS_215) U0400.BA10(VSS_202) U0400.BA14(VSS_203) U0400.BA18(VSS_204) U0400.BA23(VSS_206) U0400.BA28(VSS_207) U0400.BA32(VSS_208) U0400.BA36(VSS_209) U0400.BA41(VSS_210) U0400.BA45(VSS_211) U0400.BA49(VSS_212) U0400.BA53(VSS_213) U0400.BA57(VSS_214) U0400.BA62(VSS_216) U0400.BA66(VSS_217) U0400.BA71(VSS_218) U0400.BB6(VSS_226) U0400.BB18(VSS_219) U0400.BB26(VSS_220) U0400.BB30(VSS_221) U0400.BB34(VSS_222) U0400.BB38(VSS_223) U0400.BB43(VSS_224) U0400.BB55(VSS_225) U0400.BB60(VSS_227) U0400.BB64(VSS_228) U0400.BB67(VSS_229) U0400.BB70(VSS_230) U0400.C1(VSS_231) U0400.C5(VSS_233) U0400.C25(VSS_232) U0400.D6(VSS_250) U0400.D10(VSS_234) U0400.D11(VSS_235) U0400.D14(VSS_236) U0400.D18(VSS_237) U0400.D22(VSS_238) U0400.D25(VSS_239) U0400.D26(VSS_240) U0400.D30(VSS_241) U0400.D34(VSS_242) U0400.D39(VSS_243) U0400.D44(VSS_244) U0400.D45(VSS_245) U0400.D47(VSS_246) U0400.D48(VSS_247) U0400.D53(VSS_248) U0400.D58(VSS_249) U0400.D62(VSS_251) U0400.D66(VSS_252) U0400.D69(VSS_253) U0400.E6(VSS_262) U0400.E11(VSS_254) U0400.E15(VSS_255) U0400.E18(VSS_256) U0400.E21(VSS_257) U0400.E46(VSS_258) U0400.E50(VSS_259) U0400.E53(VSS_260) U0400.E56(VSS_261) U0400.E65(VSS_263) U0400.E71(VSS_264) U0400.F1(VSS_265) U0400.F2(VSS_267) U0400.F4(VSS_277) U0400.F8(VSS_281) U0400.F13(VSS_266) U0400.F22(VSS_268) U0400.F23(VSS_269) U0400.F27(VSS_270) U0400.F28(VSS_271) U0400.F32(VSS_272) U0400.F33(VSS_273) U0400.F35(VSS_274) U0400.F37(VSS_275) U0400.F38(VSS_276) U0400.F40(VSS_278) U0400.F42(VSS_279) U0400.F68(VSS_280) U0400.G5(VSS_287) U0400.G6(VSS_291) U0400.G10(VSS_282) U0400.G22(VSS_283) U0400.G43(VSS_284) U0400.G45(VSS_285) U0400.G48(VSS_286) U0400.G52(VSS_288) U0400.G55(VSS_289) U0400.G58(VSS_290) U0400.G60(VSS_292) U0400.G63(VSS_293) U0400.G66(VSS_294) U0400.H15(VSS_295) U0400.H18(VSS_296) U0400.H71(VSS_297) U0400.J8(VSS_306) U0400.J11(VSS_298) U0400.J13(VSS_299) U0400.J25(VSS_300) U0400.J28(VSS_301) U0400.J32(VSS_302) U0400.J35(VSS_303) U0400.J38(VSS_304) U0400.J42(VSS_305) U0400.K16(VSS_307) U0400.K18(VSS_308) U0400.K22(VSS_309) U0400.K61(VSS_310) U0400.K63(VSS_311) U0400.K64(VSS_312) U0400.K65(VSS_313) U0400.K66(VSS_314) U0400.K67(VSS_315) U0400.K68(VSS_316) U0400.K70(VSS_317) U0400.K71(VSS_318) U0400.L2(VSS_323) U0400.L4(VSS_325) U0400.L8(VSS_326) U0400.L11(VSS_319) U0400.L16(VSS_320) U0400.L17(VSS_321) U0400.L18(VSS_322) U0400.L20(VSS_324) U0400.N6(VSS_331) U0400.N10(VSS_327) U0400.N13(VSS_328) U0400.N19(VSS_329) U0400.N21(VSS_330) U0400.N65(VSS_332) U0400.N68(VSS_333) U0400.P17(VSS_334) U0400.P19(VSS_335) U0400.P20(VSS_336) U0400.P21(VSS_337) U0400.R6(VSS_339) U0400.R13(VSS_338) U0400.T2(VSS_343) U0400.T4(VSS_345) U0400.T15(VSS_340) U0400.T17(VSS_341) U0400.T18(VSS_342) U0400.T21(VSS_344) U0400.U10(VSS_346) U0400.U63(VSS_347) U0400.U64(VSS_348) U0400.U66(VSS_349) U0400.U67(VSS_350) U0400.U69(VSS_351) U0400.U70(VSS_352) U0400.V16(VSS_353) U0400.V17(VSS_354) U0400.V18(VSS_355) U0400.W6(VSS_357) U0400.W9(VSS_358) U0400.W13(VSS_356) U0400.Y17(VSS_359) U0400.Y19(VSS_360) U0400.Y20(VSS_361) U0400.Y21(VSS_362) U0500.3(GND) U1200.3(GND) U1201.3(GND) U1202.3(GND) U1203.3(GND) U1204.3(GND) U1800.3(GND) U1900.4(GND) U2300.17(VSS_1) U2300.51(VSS_2) U2300.64(VSS_3) U2300.84(VSS_4) U2300.100(VSS_5) U2300.124(VSS_VBAT) U2500.A6(VSS_1) U2500.C4(VSSQ_1) U2500.E7(VSS_2) U2500.G5(VSS_3) U2500.H10(VSS_4) U2500.J5(VSS_5) U2500.K8(VSS_6) U2500.N2(VSSQ_2) U2500.N5(VSSQ_3) U2500.P4(VSSQ_4) U2500.P6(VSSQ_5) U2600.3(GND1) U2601.3(GND1) U3000.2(GND) U3100.2(GND) U3700.5(GND) U3701.5(RES) U3701.6(GND1) U3701.7(GND2) U3701.8(GND3) U3702.2(GND_1) U3702.5(GND_2) U3702.6(GND_3) U3800.49(PVSS_1) U3800.50(PVSS_2) U3800.51(PVSS_3) U3800.52(PVSS_4) U3800.53(PVSS_5) U3800.54(PVSS_6) U3800.55(PVSS_7) U3800.56(PVSS_8) U3800.57(PVSS_9) U3800.58(PVSS_10) U3901.9(GND1) U3901.16(GND2) U3901.23(GND3) U3901.32(GND4) U3901.33(GND5) U5101.2(GND) U5700.3(GND1) U5701.3(GND1) U5702.5(GND_1) U5702.11(SBO) U5702.15(SAO) U5702.21(GND_2) U5702.22(GND_3) U5702.23(GND_4) U5702.24(GND_5) U5702.25(GND_6) U5702.26(GND_7) U5703.41(GND) U5703.42(GND1) U5703.43(GND2) U5703.44(GND3) U5703.45(GND4) U5703.46(GND5) U5703.47(GND6) U5703.48(GND7) U5703.49(GND8) U5800.41(GND) U5800.42(GND_2) U5800.43(GND_3) U5800.44(GND_4) U5800.45(GND_5) U5801.2(GND) U5802.2(GND) U5900.6(GND) U6000.A3(GND_1) U6000.A30(GND_2) U6000.AA11(GND_3) U6000.AA13(GND_4) U6000.AA16(GND_5) U6000.AA27(GND_6) U6000.AB6(GND_11) U6000.AB10(GND_7) U6000.AB15(GND_8) U6000.AB24(GND_9) U6000.AB32(GND_10) U6000.AC9(GND_15) U6000.AC17(TSVSS) U6000.AC24(GND_12) U6000.AC26(GND_13) U6000.AC27(GND_14) U6000.AD6(GND_18) U6000.AD8(GND_19) U6000.AD25(GND_16) U6000.AD32(GND_17) U6000.AE7(GND_21) U6000.AE14(VSS) U6000.AE27(GND_20) U6000.AF32(GND_22) U6000.AG12(GND_23) U6000.AG27(GND_24) U6000.AH10(GND_25) U6000.AH28(GND_26) U6000.AH32(GND_27) U6000.B6(GND_37) U6000.B8(GND_38) U6000.B10(GND_28) U6000.B12(GND_29) U6000.B14(GND_30) U6000.B16(GND_31) U6000.B18(GND_32) U6000.B20(GND_33) U6000.B22(GND_34) U6000.B24(GND_35) U6000.B26(GND_36) U6000.C1(GND_39) U6000.C32(GND_40) U6000.E28(GND_41) U6000.F2(GND_47) U6000.F6(GND_52) U6000.F8(GND_53) U6000.F10(GND_42) U6000.F12(GND_43) U6000.F14(GND_44) U6000.F16(GND_45) U6000.F18(GND_46) U6000.F20(GND_48) U6000.F22(GND_49) U6000.F24(GND_50) U6000.F26(GND_51) U6000.G8(GND_57) U6000.G10(GND_54) U6000.G27(GND_55) U6000.G31(GND_56) U6000.H2(GND_60) U6000.H6(GND_62) U6000.H14(GND_58) U6000.H17(GND_59) U6000.H20(GND_61) U6000.J7(SPLL_PVSS) U6000.J27(GND_63) U6000.J31(GND_64) U6000.K2(GND_66) U6000.K6(GND_70) U6000.K11(GND_65) U6000.K22(GND_67) U6000.K28(GND_68) U6000.K32(GND_69) U6000.L27(GND_71) U6000.M6(GND_74) U6000.M12(GND_72) U6000.M32(GND_73) U6000.N11(GND_75) U6000.N13(GND_76) U6000.N16(GND_77) U6000.N18(GND_78) U6000.N21(GND_79) U6000.N25(GND_80) U6000.N27(GND_81) U6000.P6(GND_84) U6000.P9(GND_85) U6000.P25(GND_82) U6000.P32(GND_83) U6000.R11(GND_86) U6000.R12(GND_87) U6000.R15(GND_88) U6000.R17(GND_89) U6000.R20(GND_90) U6000.R27(GND_91) U6000.T6(GND_99) U6000.T11(GND_92) U6000.T13(GND_93) U6000.T16(GND_94) U6000.T18(GND_95) U6000.T21(GND_96) U6000.T25(GND_97) U6000.T32(GND_98) U6000.U9(GND_105) U6000.U15(GND_100) U6000.U17(GND_101) U6000.U20(GND_102) U6000.U25(GND_103) U6000.U27(GND_104) U6000.V11(GND_106) U6000.V13(GND_107) U6000.V16(GND_108) U6000.V18(GND_109) U6000.V32(GND_110) U6000.W25(GND_111) U6000.W26(GND_112) U6000.W27(GND_113) U6000.Y10(GND_114) U6000.Y15(GND_115) U6000.Y17(GND_116) U6000.Y20(GND_117) U6000.Y25(GND_118) U6000.Y32(GND_119) U6001.3(GND) U6800.A1(VSSQ_1) U6800.A3(VSSQ_25) U6800.A12(VSSQ_31) U6800.A14(VSSQ_18) U6800.B5(VSS_14) U6800.B10(VSS_3) U6800.C1(VSSQ_2) U6800.C3(VSSQ_26) U6800.C4(VSSQ_24) U6800.C11(VSSQ_11) U6800.C12(VSSQ_32) U6800.C13(EDC1/EDC2) U6800.C14(VSSQ_19) U6800.D10(VSS_4) U6800.E1(VSSQ_3) U6800.E3(VSSQ_27) U6800.E12(VSSQ_33) U6800.E14(VSSQ_20) U6800.F5(VSSQ_16) U6800.F10(VSSQ_7) U6800.G5(VSS_9) U6800.G10(VSS_5) U6800.H1(VSS_1) U6800.H2(VSSQ_9) U6800.H13(VSSQ_14) U6800.H14(VSS_12) U6800.J1(MF) U6800.K1(VSS_2) U6800.K2(VSSQ_10) U6800.K13(VSSQ_15) U6800.K14(VSS_13) U6800.L5(VSS_10) U6800.L10(VSS_6) U6800.M5(VSSQ_17) U6800.M10(VSSQ_8) U6800.N1(VSSQ_4) U6800.N3(VSSQ_28) U6800.N12(VSSQ_34) U6800.N14(VSSQ_21) U6800.P10(VSS_7) U6800.R1(VSSQ_5) U6800.R3(VSSQ_29) U6800.R4(VSSQ_13) U6800.R11(VSSQ_12) U6800.R12(VSSQ_35) U6800.R14(VSSQ_22) U6800.T5(VSS_11) U6800.T10(VSS_8) U6800.U1(VSSQ_6) U6800.U3(VSSQ_30) U6800.U12(VSSQ_36) U6800.U14(VSSQ_23) U6801.A1(VSSQ_1) U6801.A3(VSSQ_25) U6801.A12(VSSQ_31) U6801.A14(VSSQ_18) U6801.B5(VSS_14) U6801.B10(VSS_3) U6801.C1(VSSQ_2) U6801.C3(VSSQ_26) U6801.C4(VSSQ_24) U6801.C11(VSSQ_11) U6801.C12(VSSQ_32) U6801.C13(EDC1/EDC2) U6801.C14(VSSQ_19) U6801.D10(VSS_4) U6801.E1(VSSQ_3) U6801.E3(VSSQ_27) U6801.E12(VSSQ_33) U6801.E14(VSSQ_20) U6801.F5(VSSQ_16) U6801.F10(VSSQ_7) U6801.G5(VSS_9) U6801.G10(VSS_5) U6801.H1(VSS_1) U6801.H2(VSSQ_9) U6801.H13(VSSQ_14) U6801.H14(VSS_12) U6801.K1(VSS_2) U6801.K2(VSSQ_10) U6801.K13(VSSQ_15) U6801.K14(VSS_13) U6801.L5(VSS_10) U6801.L10(VSS_6) U6801.M5(VSSQ_17) U6801.M10(VSSQ_8) U6801.N1(VSSQ_4) U6801.N3(VSSQ_28) U6801.N12(VSSQ_34) U6801.N14(VSSQ_21) U6801.P10(VSS_7) U6801.R1(VSSQ_5) U6801.R3(VSSQ_29) U6801.R4(VSSQ_13) U6801.R11(VSSQ_12) U6801.R12(VSSQ_35) U6801.R14(VSSQ_22) U6801.T5(VSS_11) U6801.T10(VSS_8) U6801.U1(VSSQ_6) U6801.U3(VSSQ_30) U6801.U12(VSSQ_36) U6801.U14(VSSQ_23) U6802.A1(VSSQ_1) U6802.A3(VSSQ_25) U6802.A12(VSSQ_31) U6802.A14(VSSQ_18) U6802.B5(VSS_14) U6802.B10(VSS_3) U6802.C1(VSSQ_2) U6802.C3(VSSQ_26) U6802.C4(VSSQ_24) U6802.C11(VSSQ_11) U6802.C12(VSSQ_32) U6802.C13(EDC1/EDC2) U6802.C14(VSSQ_19) U6802.D10(VSS_4) U6802.E1(VSSQ_3) U6802.E3(VSSQ_27) U6802.E12(VSSQ_33) U6802.E14(VSSQ_20) U6802.F5(VSSQ_16) U6802.F10(VSSQ_7) U6802.G5(VSS_9) U6802.G10(VSS_5) U6802.H1(VSS_1) U6802.H2(VSSQ_9) U6802.H13(VSSQ_14) U6802.H14(VSS_12) U6802.K1(VSS_2) U6802.K2(VSSQ_10) U6802.K13(VSSQ_15) U6802.K14(VSS_13) U6802.L5(VSS_10) U6802.L10(VSS_6) U6802.M5(VSSQ_17) U6802.M10(VSSQ_8) U6802.N1(VSSQ_4) U6802.N3(VSSQ_28) U6802.N12(VSSQ_34) U6802.N14(VSSQ_21) U6802.P10(VSS_7) U6802.R1(VSSQ_5) U6802.R3(VSSQ_29) U6802.R4(VSSQ_13) U6802.R11(VSSQ_12) U6802.R12(VSSQ_35) U6802.R14(VSSQ_22) U6802.T5(VSS_11) U6802.T10(VSS_8) U6802.U1(VSSQ_6) U6802.U3(VSSQ_30) U6802.U12(VSSQ_36) U6802.U14(VSSQ_23) U6803.A1(VSSQ_1) U6803.A3(VSSQ_25) U6803.A12(VSSQ_31) U6803.A14(VSSQ_18) U6803.B5(VSS_14) U6803.B10(VSS_3) U6803.C1(VSSQ_2) U6803.C3(VSSQ_26) U6803.C4(VSSQ_24) U6803.C11(VSSQ_11) U6803.C12(VSSQ_32) U6803.C13(EDC1/EDC2) U6803.C14(VSSQ_19) U6803.D10(VSS_4) U6803.E1(VSSQ_3) U6803.E3(VSSQ_27) U6803.E12(VSSQ_33) U6803.E14(VSSQ_20) U6803.F5(VSSQ_16) U6803.F10(VSSQ_7) U6803.G5(VSS_9) U6803.G10(VSS_5) U6803.H1(VSS_1) U6803.H2(VSSQ_9) U6803.H13(VSSQ_14) U6803.H14(VSS_12) U6803.J1(MF) U6803.K1(VSS_2) U6803.K2(VSSQ_10) U6803.K13(VSSQ_15) U6803.K14(VSS_13) U6803.L5(VSS_10) U6803.L10(VSS_6) U6803.M5(VSSQ_17) U6803.M10(VSSQ_8) U6803.N1(VSSQ_4) U6803.N3(VSSQ_28) U6803.N12(VSSQ_34) U6803.N14(VSSQ_21) U6803.P10(VSS_7) U6803.R1(VSSQ_5) U6803.R3(VSSQ_29) U6803.R4(VSSQ_13) U6803.R11(VSSQ_12) U6803.R12(VSSQ_35) U6803.R14(VSSQ_22) U6803.T5(VSS_11) U6803.T10(VSS_8) U6803.U1(VSSQ_6) U6803.U3(VSSQ_30) U6803.U12(VSSQ_36) U6803.U14(VSSQ_23) U6903.3(GND) U7000.11(GND1) U7000.15(GND2) X0900.2(GND1) X0900.4(GND2) X1000.2(GND1) X1000.4(GND2) X6900.2(GND1) X6900.4(GND2)
V0.85A_VID0: R1607.1 U0400.AN11(GPP_B0/CORE_VID0)
V0.85A_VID1: R1608.1 U0400.AN13(GPP_B1/CORE_VID1)
VBUS_C_CTRL_P1: PQ7608.5(GATE) R5827.1 U5800.12(VBUS_C_CTRL_P1)
VBUS_DISCHARGE_P1: R5900.1 R5905.1 U5800.20(VBUS_DISCHARGE_P1) U5900.9(DISC2)
VBUS_P_CTRL_P1: PQ7608.2(GATE) R5826.1 R5902.1 U5800.11(VBUS_P_CTRL_P1)
VCC_SENSE: PC7819.1 PR7819.1 R0606.1 U0400.E32(VCC_SENSE)
VCC_SENSE_R: PC7817.2 PR7819.2 PR7820.1 PR7855.1
VCC_SENSE_RR: PC7817.1 PR7814.1
VCC_VCPU: PC7801.1 PC7802.1 PR7801.1 PU7800.34(VCC)
VCCAMPHYPLL_1P0: C1609.1 C1610.1 R1601.2 U0400.K15(VCCAMPHYPLL_1P0_1) U0400.L15(VCCAMPHYPLL_1P0_2)
VCCAPLL_1P0: C1615.1 C1616.1 R1602.2 U0400.V15(VCCAPLL_1P0)
VCCAPLLEBB: C1625.1 R1612.2 U0400.N18(VCCAPLLEBB_1P0)
VCCCLK1_CLK6_R: C1626.1 R1606.2 R1610.2 R1611.2 R1621.1 U0400.A10(VCCCLK6) U0400.A14(VCCCLK1) U0400.L21(VCCCLK3)
VCCCLK2_R: C1621.1 R1606.1 U0400.K19(VCCCLK2)
VCCCLK4_R: C1623.1 R1610.1 U0400.N20(VCCCLK4)
VCCCLK5_R: C1624.1 R1005.1 R1611.1 U0400.L19(VCCCLK5)
VCCDSW_EN: PR8712.1 PR9103.1 U2300.88(GPIO127/PS2_DAT1B)
VCCGT_SENSE: PC7821.1 PR7817.2 R0703.1 U0400.J70(VCCGT_SENSE)
VCCGTSENSE_VCPU: PR7816.2 PR7817.1 PR7821.2
VCCGTSENSE_VCPU_R: PC7818.1 PR7821.1
VCCGTSENSE_VCPU_RR: PC7822.1 PR7822.2
VCCHDA: C1620.1 C1629.1 R1604.2 U0400.AJ19(VCCHDA)
VCCMPHYGT_1P0: C1606.1 C1607.1 R1600.2 R1620.2 U0400.N15(VCCMPHYGT_1P0_1) U0400.N16(VCCMPHYGT_1P0_2) U0400.N17(VCCMPHYGT_1P0_3) U0400.P15(VCCMPHYGT_1P0_4) U0400.P16(VCCMPHYGT_1P0_5)
VCCPRIM: C1600.1 R1625.2 U0400.AB17(VCCPRIM_1P0_2) U0400.AB19(VCCPRIM_1P0_5) U0400.AB20(VCCPRIM_1P0_6) U0400.AK20(VCCPRIM_1P0_4) U0400.P18(VCCPRIM_1P0_7) U0400.T1(VCCPRIM_1P0_1) U0400.Y18(VCCPRIM_1P0_3)
VCCRTC: C1618.1 C1619.1 R1623.1 U0400.AK19(VCCRTC_1) U0400.BB14(VCCRTC_2)
VCCSA_SENSE: PC7833.1 PR7844.1 R0608.1 U0400.H20(VCCSA_SENSE)
VCCSA_SENSE_VCPU: PR7844.2 PR7845.1 PR7848.1
VCCSA_SENSE_VCPU_R: PC7834.2 PR7848.2
VCCSRAM_1P0: C1622.1 R1609.2 U0400.AF20(VCCSRAM_1P0_1) U0400.AF21(VCCSRAM_1P0_2) U0400.T19(VCCSRAM_1P0_3) U0400.T20(VCCSRAM_1P0_4)
VCCST_PWRGD: C1206.1 R1202.1 R1224.2 U1204.4(Y)
VCCST_PWRGD_R: R1202.2 U0400.B65(VCCST_PWRGD)
VDD1: C3904.1 C3906.1 C3908.1 C3911.1 R3917.2 R3918.2 U3901.8(VDD1)
VDDC_BOOT1: PR9410.1 PU9400.38(BOOT1)
VDDC_BOOT2: PR9417.1 PU9400.2(BOOT2)
VDDC_EN: PC9413.1 PD9400.1(ANODE) PR9427.2 PU9400.29(EN)
VDDC_LG1: PR9605.1 PU9400.35(LGATE1)
VDDC_LG2: PR9609.1 PU9400.39(LGATE2)
VDDC_PH1: PC9407.2 PC9602.2 PQ9600.2(GR) PR9604.2 PU9400.36(PHASE1)
VDDC_PH2: PC9409.2 PC9624.2 PQ9601.2(GR) PR9608.2 PU9400.40(PHASE2)
VDDC_PVCC: PC9406.2 PR9414.2 PU9400.34(PVCC)
VDDC_RTN: PC9417.2 PC9419.1 PR9436.1 PR9453.1 PU9400.4(RGND)
VDDC_SVC: PC9423.1 PR9402.2 PR9451.1 PR9460.1 PT9402.1 PU9400.19(SVC)
VDDC_SVD: PC9421.1 PR9403.2 PR9449.1 PR9458.1 PT9400.1 PU9400.20(SVD)
VDDC_SVT: PR9450.1 PT9401.1 PU9400.21(SVT)
VDDC_UG1: PR9603.1 PU9400.37(UGATE1)
VDDC_UG2: PR9607.1 PU9400.1(UGATE2)
VDDC_VCC: PC9405.2 PR9413.1 PR9423.1 PU9400.17(VCC)
VDDC_VCCSENSE: PR9452.2 U6000.AC20(FB_VDDC)
VDDC_VDDIO: PC9404.1 PR9409.2 PU9400.22(VDDIO)
VDDC_VRHOT: PR9416.2 PT9403.1 PU9400.11(VRHOT_L)
VDDC_VSEN: PR9455.1 PU9400.8(VSEN)
VDDC_VSEN_R: PC9416.1 PC9417.1 PC9418.1 PR9430.1 PR9433.2 PR9452.1 PR9455.2
VDDC_VSSSENSE: PR9453.2 U6000.AD20(FB_GND_1)
VDDQC: C0612.1 R0600.1 U0400.AM40(VDDQC)
VIN_VCPU: PC7804.2 PR7802.1 PU7800.33(VIN)
VSS_SENSE: PC7819.2 PC7823.1 PR7823.1 PU7800.6(RTN_B) R0607.1 U0400.E33(VSS_SENSE)
VSSGT_SENSE: PC7821.2 PC7826.1 PU7800.18(RTN_A) R0702.1 U0400.J69(VSSGT_SENSE)
VSSSA_SENSE: PC7833.2 PC7837.1 PU7800.26(RTN_C) R0609.1 U0400.H21(VSSSA_SENSE)
3P3VSB_EN2: PC8921.1 PU8900.6(EN2) R2409.1
+0P95VGA_EN: PC9515.1 PR9508.2 PU9501.5(EN)
+0P95VGA_FB: PC9517.1 PR9507.1 PR9509.1 PU9501.6(FB)
+0P95VGA_FB_R: PC9517.2 PJP9505.2 PR9509.2
+0P95VGA_LX: PL9501.1 PR9506.2 PT9509.1 PU9501.1(LX1) PU9501.2(LX2) PU9501.3(LX3)
+0P95VGA_RC: PC9516.1 PR9506.1
+0P95VGA_VIN: PC9509.1 PC9510.1 PC9511.1 PJP9503.2 PU9501.8(SVIN) PU9501.9(PVIN1) PU9501.10(PVIN2)
+0P95VO: PC9512.1 PC9513.1 PC9514.1 PC9518.1 PJP9504.1 PJP9505.1 PL9501.2 PT9510.1 PT9511.1 PT9512.1
+1P2V_DUAL: C0500.1 C0600.1 C0601.1 C0602.1 C0603.1 C0604.1 C0605.1 C0606.1 C2200.1 C2201.1 C2202.1 C2203.1 C2204.1 C2205.1 C2206.1 C2207.1 C2210.1 C2211.1 C2212.1 C2213.1 C2214.1 C2215.1 C2216.1 C2217.1 C2218.1 C2219.1 C2224.1 C2225.1 C2226.1 C2227.1 C2228.1 C2229.1 C2230.1 C2231.1 C2234.1 C2235.1 C2236.1 C2237.1 C2238.1 C2239.1 C2240.1 C2241.1 CE2200.1 CE2201.1 CON2000.12(DM0_N/DBI0_N) CON2000.33(DM1_N/DBI_N) CON2000.54(DM2_N/DBI2_N) CON2000.75(DM3_N/DBI3_N) CON2000.96(DM8_N/DBI_N/NC) CON2000.111(VDD1) CON2000.112(VDD2) CON2000.117(VDD3) CON2000.118(VDD4) CON2000.123(VDD5) CON2000.124(VDD6) CON2000.129(VDD7) CON2000.130(VDD8) CON2000.135(VDD9) CON2000.136(VDD10) CON2000.141(VDD11) CON2000.142(VDD12) CON2000.147(VDD13) CON2000.148(VDD14) CON2000.153(VDD15) CON2000.154(VDD16) CON2000.159(VDD17) CON2000.160(VDD18) CON2000.163(VDD19) CON2000.178(DM4_N/DBI4_N) CON2000.199(DM5_N/DBI5_N) CON2000.220(DM6_N/DBI6_N) CON2000.241(DM7_N/DBI7_N) CON2100.12(DM0_N/DBI0_N) CON2100.33(DM1_N/DBI_N) CON2100.54(DM2_N/DBI2_N) CON2100.75(DM3_N/DBI3_N) CON2100.96(DM8_N/DBI_N/NC) CON2100.111(VDD1) CON2100.112(VDD2) CON2100.117(VDD3) CON2100.118(VDD4) CON2100.123(VDD5) CON2100.124(VDD6) CON2100.129(VDD7) CON2100.130(VDD8) CON2100.135(VDD9) CON2100.136(VDD10) CON2100.141(VDD11) CON2100.142(VDD12) CON2100.147(VDD13) CON2100.148(VDD14) CON2100.153(VDD15) CON2100.154(VDD16) CON2100.159(VDD17) CON2100.160(VDD18) CON2100.163(VDD19) CON2100.178(DM4_N/DBI4_N) CON2100.199(DM5_N/DBI5_N) CON2100.220(DM6_N/DBI6_N) CON2100.241(DM7_N/DBI7_N) PC9004.1 PJP8601.2 PU9001.1(VIN1) R0600.2 R2000.1 R2002.1 R2003.1 R2100.1 R2101.1 U0400.AU23(VDDQ_1) U0400.AU28(VDDQ_2) U0400.AU35(VDDQ_3) U0400.AU42(VDDQ_4) U0400.BB23(VDDQ_5) U0400.BB32(VDDQ_6) U0400.BB41(VDDQ_7) U0400.BB47(VDDQ_8) U0400.BB51(VDDQ_9) U0500.5(VCC)
+1P2V_DUAL_A_CS: PR8611.2 PU8600.13(CS)
+1P2V_DUAL_A_FB_A: PC8611.2 PR8609.1 PR8610.1 PU8600.6(FB)
+1P2V_DUAL_A_S3: PC8605.1 PR8603.2 PR8604.2 PU8600.7(S3)
+1P2V_DUAL_A_TON: PR8602.2 PU8600.9(TON)
+1P2V_DUAL_A_V5IN: PC8600.1 PR8600.2 PU8600.12(VDD)
+1P2V_DUAL_A_VOUT_R_A: PC8611.1 PC8612.1 PJP8600.1 PR8609.2 PU8600.5(VDDQ)
+1P2V_DUAL_BST: PR8601.1 PU8600.18(BOOT)
+1P2V_DUAL_BST_RC: PC8601.2 PR8601.2
+1P2V_DUAL_FB_VOUT_R_A: PC8608.1 PC8613.1 PC8617.1 PC8618.1 PC8619.1 PC8620.1 PCE8600.1 PJP8600.2 PJP8601.1 PL8600.2 PU8600.19(VLDOIN)
+1P2V_DUAL_HG: PR8617.1 PU8600.17(UGATE)
+1P2V_DUAL_HGR: PC8604.1 PQ8600.1(G1) PR8605.1 PR8617.2
+1P2V_DUAL_LG: PR8618.1 PU8600.15(LGATE)
+1P2V_DUAL_LGR: PC8610.1 PQ8600.8(G2) PR8608.1 PR8618.2
+1P2V_DUAL_PHASE: PC8601.1 PC8604.2 PC8607.1 PL8600.1 PQ8600.9(S1/D2) PR8605.2 PR8607.1 PU8600.16(PHASE)
+1P2V_DUAL_SUR: PC8606.1 PR8607.2
+1P2V_DUAL_VIN: PC8602.1 PC8603.1 PC8622.2 PQ8600.2(D1_1) PQ8600.3(D1_2) PQ8600.4(D1_3) PQ8600.10(D1_4) PR8602.1 PR8613.1
+1P8V: PR9003.1 R2511.1 R3821.1
+1P8V_CPVDD: C3825.1 C3826.1 R3821.2 U3800.20(CPVDD/AVDD2)
+1P8V_EMMC: C2502.1 C2505.1 C2506.1 R2501.1 R2502.1 R2503.1 R2504.1 R2505.1 R2506.1 R2507.1 R2508.1 R2511.2 R2513.1 R2514.2 U2500.C6(VCCQ_1) U2500.M4(VCCQ_2) U2500.N4(VCCQ_3) U2500.P3(VCCQ_4) U2500.P5(VCCQ_5)
+1P8VSB: PC9000.1 PR8806.2 PU9001.7(VIN2) R1022.1 R1024.1 R1025.1 R1026.1 R1614.1 R2336.1
+1P8VSB_COMP_A: PC8811.1 PR8805.2
+1P8VSB_EN_A: PC8808.1 PR8811.2 PU8801.5(EN)
+1P8VSB_FB1_A: PC8810.2 PJP8801.1 PR8807.2
+1P8VSB_FB_A: PC8810.1 PR8805.1 PR8807.1 PR8810.1 PU8801.6(FB)
+1P8VSB_OUT: PC8807.1 PC8809.1 PJP8801.2 PL8801.2 PR8806.1 PR8809.1
+1P8VSB_PWRGD: PU8801.4(PGOOD) R1801.1 R2346.1
+1P8VSB_SW: PL8801.1 PU8801.1(LX1) PU8801.2(LX2) PU8801.3(LX3)
+1P8VSB_VIN: PC8812.1 PC8813.1 PR8808.2 PU8801.8(SVIN) PU8801.9(PVIN1) PU8801.10(PVIN2)
+1P8VSUS_ORG: C1612.1 C1628.1 R1107.1 R1208.1 R1614.2 U0400.AA1(VCCATS_1P8) U0400.AF16(VCCPGPPF) U0400.AK15(VCCPGPPA)
+2P5_VPP_COMP_A: PC8802.1 PR8804.2
+2P5_VPP_FB1_A: PC8803.2 PJP8800.1 PR8803.2
+2P5_VPP_FB_A: PC8803.1 PR8802.1 PR8803.1 PR8804.1 PU8800.6(FB)
+2P5_VPP_SW: PL8800.1 PU8800.1(LX1) PU8800.2(LX2) PU8800.3(LX3)
+2P5_VPP_VIN: PC8800.1 PC8801.1 PR8801.2 PU8800.8(SVIN) PU8800.9(PVIN1) PU8800.10(PVIN2)
+2P5V_VPP: C2001.1 C2101.1 C2232.1 C2233.1 C2242.1 C2243.1 CON2000.257(VPP1) CON2000.259(VPP2) CON2100.257(VPP1) CON2100.259(VPP2) PJP8802.1
+2P5V_VPP_EN_A: PC8814.1 PR8812.2 PR8813.2 PU8800.5(EN)
+2P5V_VPP_PWRGD: PR8616.1 PR8814.1 PU8800.4(PGOOD) R1806.2
+3P3V: C1200.1 C1207.1 C2003.1 C2004.1 C2012.1 C2103.1 C2104.1 C2105.1 C5300.2 CON2000.255(VDDSPD) CON2100.255(VDDSPD) CON2100.260(SA1) CON5103.42 CON5103.43 J5300.1 L3800.1 PR9102.1 PR9415.1 PR9802.2 PR9803.2 PR9804.2 PR9809.1 Q2900.2(GATE) Q2900.5(GATE) Q2901.2(GATE) Q2901.5(GATE) Q3602.1(GATE) R0414.1 R0503.2 R1002.1 R1003.1 R1004.1 R1010.1 R1205.1 R1222.1 R1409.1 R1500.1 R1518.1 R1804.1 R1919.1 R1921.1 R2510.1 R2600.1 R2900.1 R2901.1 R2913.2 R3004.1 R3109.1 R3110.1 R3601.1 R3602.1 R3702.1 R3706.1 R3901.1 R5725.1 SR3100.1 U1200.1(INB) U1200.5(VCC) U1203.5(VCC) U5100.5
+3P3V_CAM: C3003.1 CON3000.8 R3004.2
+3P3V_CCG4: R5805.2 R5806.2 R5807.1 R5808.1 R5809.1 R5810.1 R5811.1 R5812.1 R5817.1 R5818.1
+3P3V_DONGLE: C5724.1 R5712.2 U5702.13(VCC)
+3P3V_DVDD: C3800.1 C3801.1 C3802.1 C3803.1 C3839.2 L3800.2 R3809.1 R3811.1 R3824.1 R3826.1 U3800.3(DVDD) U3800.18(DVDD_IO)
+3P3V_EMMC: C2500.1 C2501.1 C2504.1 R2510.2 U2500.E6(VCC_1) U2500.F5(VCC_2) U2500.J10(VCC_3) U2500.K9(VCC_4)
+3P3V_LAN: CON5104.1 PR9108.1
+3P3V_PAD: C5126.1 CON5100.8 Q5102.5(GATE) Q5103.2(GATE) Q5103.5(GATE) Q5104.2(GATE) Q5104.5(GATE) R5102.1 R5103.1 R5104.1 R5105.1 R5106.1 R5107.1 R5108.1 R5109.2
+3P3V_PANEL: CON3000.28 CON3000.29 CON3000.30 R3006.2 R3007.2
+3P3V_PANEL_O: C3000.1 R3003.2 R3006.1 R3007.1 U3000.1(OUT)
+3P3V_SENSOR: C3704.1 C3705.1 R3700.1 R3701.1 R3702.2 R3710.1 R3712.1 U3701.9(VDD) U3701.10(VDD_IO)
+3P3V_SSD: C3100.1 C3101.1 C3102.1 C3103.1 C3108.1 C3109.1 C3110.1 C3116.1 C3117.1 C3118.1 C3119.1 CON3100.2 CON3100.4 CON3100.12 CON3100.14 CON3100.16 CON3100.18 CON3100.70 CON3100.72 CON3100.74 Q3102.1(GATE) R3105.1 R3113.1 R3114.1 SR3100.2
+3P3V_THERM: C3700.1 R1911.1 R1912.1 R3706.2 R3708.1 R3715.1 U3700.1(VDD)
+3P3V_TPM: R3901.2 R3915.1 R3917.1
+3P3V_TUSB546: C5700.1 C5701.1 C5702.1 C5703.1 C5704.1 R5702.1 R5703.1 R5705.1 R5707.1 R5709.1 R5711.1 R5714.2 R5717.1 R5718.1 U5703.1(VCC_1) U5703.6(VCC_2) U5703.20(VCC_3) U5703.28(VCC_4)
+3P3VA: PC8903.1 PR7702.1 PU8900.3(LDO3) R2306.2 R3613.1 R3827.1 R7204.1
+3P3VA_CS2_A: PR8912.2 PU8900.5(CS2)
+3P3VSB: C1201.1 C1202.1 C1205.1 C1800.1 C3010.1 C3701.1 C5131.1 C5301.2 C7005.1 C7006.1 CON5103.41 D5800.1(ANODE1) J5301.1 J5301.3 PC9005.1 PC9100.1 PC9104.1 PC9107.1 PJP8903.2 PJP9500.1 PJP9503.1 PR7613.1 PR7617.1 PR7619.1 PR8606.2 PR8705.2 PR8711.1 PR8801.1 PR8808.1 PR8814.2 PR9500.1 PR9505.1 PU7600.4(VDD) PU9000.5(VCC) PU9100.7(VIN2) PU9101.1(VIN1) PU9101.7(VIN2) Q5101.2(SOURCE) R1017.1 R1021.1 R1100.1 R1101.1 R1102.1 R1103.1 R1104.1 R1105.1 R1106.1 R1109.1 R1114.1 R1210.1 R1220.1 R1504.1 R1507.1 R1509.1 R1510.1 R1515.1 R1516.1 R1615.2 R1802.1 R1901.1 R2301.1 R2424.1 R3608.1 R3707.1 R3711.1 R3713.1 R3902.1 R5004.1 R5712.1 R5714.1 R5805.1 R5813.2 RN5100.2(4) RN5100.4 RN5100.6(4) RN5100.8(4) RN5101.2(4) RN5101.4 RN5101.6(4) RN5101.8(4) U1201.5(VCC) U1202.5(VCC) U1204.5(VCC) U1800.5(VCC) U3000.5(IN) U3702.4(VDD) U7000.7(IN2)
+3P3VSB_BST1_C: PC8900.1 PR8914.2
+3P3VSB_BST_C: PR8914.1 PU8900.9(BOOT2)
+3P3VSB_FB_A: PC8922.2 PR8921.1 PR8922.1 PU8900.4(FB2)
+3P3VSB_FBR_A: PC8922.1 PC8923.1 PJP8901.2 PR8921.2
+3P3VSB_HG_D: PR8915.1 PU8900.10(UGATE2)
+3P3VSB_HGR_D: PC8916.1 PQ8901.1(G1) PR8915.2 PR8917.1
+3P3VSB_LG_D: PR8918.1 PU8900.11(LGATE2)
+3P3VSB_LGR_D: PC8920.1 PQ8901.8(G2) PR8918.2 PR8919.1
+3P3VSB_PHASE2_S: PC8900.2 PC8916.2 PL8901.1 PQ8901.9(S1/D2) PR8917.2 PR8920.1 PU8900.8(PHASE2)
+3P3VSB_SN_S: PC8918.1 PR8920.2
+3P3VSB_TPM: C3901.1 C3902.1 C3909.1 C3910.1 R3902.2 R3912.1 R3913.2 R3916.1 R3918.1 U3901.1(VSB)
+AC_BAT_SYS: F3000.1 PC7704.1 PC7705.1 PC7706.1 PC7707.1 PC7901.1 PC7902.1 PC7906.1 PC7907.1 PC7908.1 PC7913.1 PC8001.1 PC8003.1 PC8007.1 PC8008.1 PC8009.1 PC9800.1 PCE7900.1 PCE8000.1 PCE8900.1 PD7700.1(ANODE) PJP7702.2 PJP7900.2 PQ7703.5(D) PQ7900.3(V+1) PQ7900.4(V+2) PQ7900.10(V+(HSD)) PQ7901.3(V+1) PQ7901.4(V+2) PQ7901.10(V+(HSD)) PQ8000.2(D1_1) PQ8000.3(D1_2) PQ8000.4(D1_3) PQ8000.10(D1_4) PQ8001.3(V+1) PQ8001.4(V+2) PQ8001.10(V+(HSD)) PR7711.2 PR7712.1 PR8613.2 PR8700.1 PR8901.2 PR8913.2 PR8916.2 PR9600.2 PR9601.2 PR9602.2 PR9800.1
+BL_PWR: CON3000.1 CON3000.2 R3008.2
+BL_PWR_O: C3001.1 C3002.1 F3000.2 R3008.1
+CPU_VIN1_A: PJP7900.1 PR7802.2
+DCIN_IN: PD7701.1(ANODE) PJP7701.1 PQ7600.1(SOURCE1) PQ7600.2(SOURCE2) PQ7600.3(SOURCE3) PQ7605.6(COLLECTOR1) PQ7606.4(EMITTER2) PQ7610.6(COLLECTOR1) PQ7611.4(EMITTER2) PQ7614.1(SOURCE1) PQ7614.2(SOURCE2) PQ7614.3(SOURCE3) PR7700.1 PR7707.1 PU7700.16(ADP)
+FBVDDQ: C6600.1 C6601.1 C6602.1 C6603.1 C6604.1 C6605.1 C6606.1 C6607.1 C6608.1 C6609.1 C6610.1 C6611.1 C6612.1 C6613.1 C6614.1 C6615.1 C6616.1 C6617.1 C6618.1 C6619.1 C6620.1 C6621.1 C6622.1 C6623.1 C6624.1 C6625.1 C6626.1 C6627.1 C6628.1 C6629.1 C6630.1 C6631.1 C6632.1 C6633.1 C6634.1 C6635.1 C6636.1 C6637.1 C6746.1 C6747.1 C6748.1 C6749.1 C6750.1 C6751.1 C6752.1 C6753.1 PJP9800.2 R6304.1 R6306.1 R6804.1 R6806.1 R6808.1 R6810.1 R6812.1 R6813.1 R6814.1 R6815.1 R7200.2 U6000.H13(VMEMIO_1) U6000.H16(VMEMIO_2) U6000.H19(VMEMIO_3) U6000.J9(VMEMIO_7) U6000.J10(VMEMIO_4) U6000.J23(VMEMIO_5) U6000.J24(VMEMIO_6) U6000.K9(VMEMIO_11) U6000.K10(VMEMIO_8) U6000.K23(VMEMIO_9) U6000.K24(VMEMIO_10) U6000.L11(VMEMIO_12) U6000.L12(VMEMIO_13) U6000.L13(VMEMIO_14) U6000.L20(VMEMIO_15) U6000.L21(VMEMIO_16) U6000.L22(VMEMIO_17) U6800.B1(VDDQ_1) U6800.B3(VDDQ_21) U6800.B12(VDDQ_29) U6800.B14(VDDQ_15) U6800.C5(VDD_14) U6800.C10(VDD_3) U6800.D1(VDDQ_2) U6800.D3(VDDQ_22) U6800.D11(VDD_5) U6800.D12(VDDQ_30) U6800.D13(DBI1#/DBI2#) U6800.D14(VDDQ_16) U6800.E5(VDDQ_13) U6800.E10(VDDQ_7) U6800.F1(VDDQ_3) U6800.F3(VDDQ_23) U6800.F12(VDDQ_31) U6800.F14(VDDQ_17) U6800.G1(VDD_1) U6800.G2(VDDQ_9) U6800.G4(VDD_9) U6800.G11(VDD_6) U6800.G13(VDDQ_11) U6800.G14(VDD_12) U6800.H3(VDDQ_24) U6800.H12(VDDQ_32) U6800.K3(VDDQ_25) U6800.K12(VDDQ_33) U6800.L1(VDD_2) U6800.L2(VDDQ_10) U6800.L4(VDD_10) U6800.L11(VDD_7) U6800.L13(VDDQ_12) U6800.L14(VDD_13) U6800.M1(VDDQ_4) U6800.M3(VDDQ_26) U6800.M12(VDDQ_34) U6800.M14(VDDQ_18) U6800.N5(VDDQ_14) U6800.N10(VDDQ_8) U6800.P1(VDDQ_5) U6800.P2(DBI3#/DBI0#) U6800.P3(VDDQ_27) U6800.P11(VDD_8) U6800.P12(VDDQ_35) U6800.P14(VDDQ_19) U6800.R5(VDD_11) U6800.R10(VDD_4) U6800.T1(VDDQ_6) U6800.T3(VDDQ_28) U6800.T12(VDDQ_36) U6800.T14(VDDQ_20) U6801.B1(VDDQ_1) U6801.B3(VDDQ_21) U6801.B12(VDDQ_29) U6801.B14(VDDQ_15) U6801.C5(VDD_14) U6801.C10(VDD_3) U6801.D1(VDDQ_2) U6801.D3(VDDQ_22) U6801.D11(VDD_5) U6801.D12(VDDQ_30) U6801.D13(DBI1#/DBI2#) U6801.D14(VDDQ_16) U6801.E5(VDDQ_13) U6801.E10(VDDQ_7) U6801.F1(VDDQ_3) U6801.F3(VDDQ_23) U6801.F12(VDDQ_31) U6801.F14(VDDQ_17) U6801.G1(VDD_1) U6801.G2(VDDQ_9) U6801.G4(VDD_9) U6801.G11(VDD_6) U6801.G13(VDDQ_11) U6801.G14(VDD_12) U6801.H3(VDDQ_24) U6801.H12(VDDQ_32) U6801.J1(MF) U6801.K3(VDDQ_25) U6801.K12(VDDQ_33) U6801.L1(VDD_2) U6801.L2(VDDQ_10) U6801.L4(VDD_10) U6801.L11(VDD_7) U6801.L13(VDDQ_12) U6801.L14(VDD_13) U6801.M1(VDDQ_4) U6801.M3(VDDQ_26) U6801.M12(VDDQ_34) U6801.M14(VDDQ_18) U6801.N5(VDDQ_14) U6801.N10(VDDQ_8) U6801.P1(VDDQ_5) U6801.P2(DBI3#/DBI0#) U6801.P3(VDDQ_27) U6801.P11(VDD_8) U6801.P12(VDDQ_35) U6801.P14(VDDQ_19) U6801.R5(VDD_11) U6801.R10(VDD_4) U6801.T1(VDDQ_6) U6801.T3(VDDQ_28) U6801.T12(VDDQ_36) U6801.T14(VDDQ_20) U6802.B1(VDDQ_1) U6802.B3(VDDQ_21) U6802.B12(VDDQ_29) U6802.B14(VDDQ_15) U6802.C5(VDD_14) U6802.C10(VDD_3) U6802.D1(VDDQ_2) U6802.D3(VDDQ_22) U6802.D11(VDD_5) U6802.D12(VDDQ_30) U6802.D13(DBI1#/DBI2#) U6802.D14(VDDQ_16) U6802.E5(VDDQ_13) U6802.E10(VDDQ_7) U6802.F1(VDDQ_3) U6802.F3(VDDQ_23) U6802.F12(VDDQ_31) U6802.F14(VDDQ_17) U6802.G1(VDD_1) U6802.G2(VDDQ_9) U6802.G4(VDD_9) U6802.G11(VDD_6) U6802.G13(VDDQ_11) U6802.G14(VDD_12) U6802.H3(VDDQ_24) U6802.H12(VDDQ_32) U6802.J1(MF) U6802.K3(VDDQ_25) U6802.K12(VDDQ_33) U6802.L1(VDD_2) U6802.L2(VDDQ_10) U6802.L4(VDD_10) U6802.L11(VDD_7) U6802.L13(VDDQ_12) U6802.L14(VDD_13) U6802.M1(VDDQ_4) U6802.M3(VDDQ_26) U6802.M12(VDDQ_34) U6802.M14(VDDQ_18) U6802.N5(VDDQ_14) U6802.N10(VDDQ_8) U6802.P1(VDDQ_5) U6802.P2(DBI3#/DBI0#) U6802.P3(VDDQ_27) U6802.P11(VDD_8) U6802.P12(VDDQ_35) U6802.P14(VDDQ_19) U6802.R5(VDD_11) U6802.R10(VDD_4) U6802.T1(VDDQ_6) U6802.T3(VDDQ_28) U6802.T12(VDDQ_36) U6802.T14(VDDQ_20) U6803.B1(VDDQ_1) U6803.B3(VDDQ_21) U6803.B12(VDDQ_29) U6803.B14(VDDQ_15) U6803.C5(VDD_14) U6803.C10(VDD_3) U6803.D1(VDDQ_2) U6803.D3(VDDQ_22) U6803.D11(VDD_5) U6803.D12(VDDQ_30) U6803.D13(DBI1#/DBI2#) U6803.D14(VDDQ_16) U6803.E5(VDDQ_13) U6803.E10(VDDQ_7) U6803.F1(VDDQ_3) U6803.F3(VDDQ_23) U6803.F12(VDDQ_31) U6803.F14(VDDQ_17) U6803.G1(VDD_1) U6803.G2(VDDQ_9) U6803.G4(VDD_9) U6803.G11(VDD_6) U6803.G13(VDDQ_11) U6803.G14(VDD_12) U6803.H3(VDDQ_24) U6803.H12(VDDQ_32) U6803.K3(VDDQ_25) U6803.K12(VDDQ_33) U6803.L1(VDD_2) U6803.L2(VDDQ_10) U6803.L4(VDD_10) U6803.L11(VDD_7) U6803.L13(VDDQ_12) U6803.L14(VDD_13) U6803.M1(VDDQ_4) U6803.M3(VDDQ_26) U6803.M12(VDDQ_34) U6803.M14(VDDQ_18) U6803.N5(VDDQ_14) U6803.N10(VDDQ_8) U6803.P1(VDDQ_5) U6803.P2(DBI3#/DBI0#) U6803.P3(VDDQ_27) U6803.P11(VDD_8) U6803.P12(VDDQ_35) U6803.P14(VDDQ_19) U6803.R5(VDD_11) U6803.R10(VDD_4) U6803.T1(VDDQ_6) U6803.T3(VDDQ_28) U6803.T12(VDDQ_36) U6803.T14(VDDQ_20)
+FBVDDQ_BOOT1_D: PC9804.1 PR9801.2
+FBVDDQ_BOOT_D: PR9801.1 PU9800.9(BST)
+FBVDDQ_DISCH_A: Q7200.3(DRAIN) R7200.1
+FBVDDQ_MODE: PR9805.2 PU9800.7(MODE)
+FBVDDQ_PHASE: PC9804.2 PL9800.1 PU9800.8(SW)
+FBVDDQ_SENSE_R: PR9810.2 PR9811.1
+FBVDDQ_VCC: PC9808.1 PR9809.2 PU9800.10(3V3)
+FBVDDQ_VIN: PC9801.1 PC9802.1 PC9803.1 PR9800.2 PU9800.1(VIN)
+FBVDDQ_VOUT: PR9810.1 PR9812.2 PU9800.12(VOUT)
+FBVDDQ_VOUT_R: PJP9801.2 PR9811.2
+RTC_CELL_VBAT: C2308.1 R2308.2 U2300.122(VBAT)
+USB_TYPEC: C5723.1 C5900.1 C5903.1 CON5700.A4(VBUS2) CON5700.A9(VBUS1) CON5700.B4(VBUS3) CON5700.B9(VBUS4) D5708.2(CATHODE) D5709.2(CATHODE) PC7611.1 PL7603.1 PL7604.1 PL7606.1 R5803.1 R5814.1 U5900.17(OUT)
+USB_TYPEC_LDO: C5808.1 R5814.2 R5815.1 U5802.1(VIN)
