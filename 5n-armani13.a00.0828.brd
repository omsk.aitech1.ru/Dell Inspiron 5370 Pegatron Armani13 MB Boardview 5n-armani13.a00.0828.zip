# Allegro board 5n-armani13.a00.0828.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MDA1_16: length 18.6
  BOTTOM w0.102: 175.13,79.4 174.47,79.4 173.89,79.99 173.19,79.99 172.9,80.28 172.9,80.41 172.47,80.84 172.41,80.84 U6000.E7
  BOTTOM w0.127: U6802.E2 187.94,76.17 187.93,76.17 187.76,76 186.52,76 186.27,76.24 186.27,76.39 185.78,76.89 185.29,76.89 184.96,77.22 v2(184.79,77.22) 184.15,77.22 183.54,77.83 183.13,77.83 182.35,78.6 175.93,78.6 175.13,79.4
MDA1_17: length 18
  BOTTOM w0.102: U6000.A7 174,80.85 174.65,80.85 175.02,80.48 175.02,80.48 175.15,80.36 175.15,80.05 175.31,79.88
  BOTTOM w0.127: 175.31,79.88 175.72,79.47 180.33,79.47 180.49,79.63 180.49,80.39 180.62,80.52 180.87,80.52 181.08,80.32 181.08,79.81 181.28,79.61 v2(182.27,79.61) 183.31,79.61 184.56,78.36 185.84,78.36 186.37,77.83 186.37,77.81 186.63,77.55 187.82,77.55 188.17,77.2 U6802.F2
MDA1_18: length 19.1
  BOTTOM w0.102: 174.93,80.27 174.55,80.65 173.47,80.65 173.37,80.75 173.3,80.75 U6000.C7
  BOTTOM w0.127: U6802.E4 189.74,76.4 189.69,76.46 189.48,76.46 189.08,76.86 186.14,76.86 185.67,77.32 185.55,77.32 184.96,77.9 184.24,77.9 v2(183.62,78.52) 183.1,79.04 175.82,79.04 174.93,79.93 174.93,80.27
MDA1_19: length 22
  BOTTOM w0.102: U6000.F7 171.56,81.55 173.87,81.55 174.36,81.05 174.83,81.05 175.4,80.48 175.4,80.16 175.54,80.03
  BOTTOM w0.127: 175.54,80.03 175.67,79.9 179.62,79.9 180.01,80.29 180.01,80.55 180.47,81 v2(180.65,81) 181,81 181.94,80.06 183.46,80.06 184.73,78.79 186.23,78.79 186.61,78.41 188.34,78.41 188.41,78.34 189.11,78.34 189.31,78.14 189.31,77.66 U6802.F4
MDA1_20: length 20.3
  BOTTOM w0.102: 175.36,78.84 175,79.2 174.39,79.2 173.97,79.62 U6000.A5
  BOTTOM w0.127: 175.36,78.84 176.03,78.17 178.37,78.17 178.56,77.98 v2(180.44,77.98) 182.35,77.98 183.12,77.2 183.12,76.18 183.42,75.89 185.59,75.89 186.21,75.26 187.51,75.26 187.73,75.48 187.73,75.65 188.03,75.94 188.31,75.94 188.54,75.71 188.54,74.74 188.93,74.35 189.41,74.35 189.76,74 U6802.B4
MDA1_21: length 23.2
  BOTTOM w0.102: 174.17,77.65 173.91,77.9 173.46,77.9 172.92,78.44 172.71,78.44 172.47,78.68 172.47,79.18 U6000.E5
  BOTTOM w0.127: U6802.B2 188.62,73.55 188.62,72.29 188.13,71.8 v2(185.22,71.8) 182.39,71.8 180.88,73.31 177.14,73.31 175.54,74.91 175.54,76.61 174.68,77.47 174.35,77.47 174.17,77.65
MDA1_22: length 19.5
  BOTTOM w0.102: U6000.C3 173.54,78.11 174.09,78.11 174.32,77.88
  BOTTOM w0.127: U6802.A2 188.17,73 188.27,72.9 188.27,72.54 187.96,72.24 183.24,72.24 v2(182.92,72.56) 181.74,73.74 178.16,73.74 175.97,75.92 175.97,76.74 174.83,77.88 174.32,77.88
MDA1_23: length 23.2
  BOTTOM w0.102: 175.03,76.51 174.47,77.07 172.81,77.07 172.03,77.85 U6000.E1
  BOTTOM w0.127: 175.03,76.51 v2(175.03,73.97) 175.03,73.93 176.08,72.88 180.7,72.88 182.22,71.35 188.49,71.35 189.77,72.63 U6802.A4
MDA1_24: length 31.5
  TOP w0.127: U6803.M11 195.35,77.2 v1(194.94,77.61)
  IN3 w0.122: v1(172.39,76.3) 172.39,77.04 173.28,77.93 174.83,77.93 175.92,76.83 188.19,76.83 188.49,76.53 190.6,76.53 190.91,76.84 192.62,76.84 193.39,77.61 v1(194.94,77.61)
  BOTTOM w0.102: v1(172.39,76.3) 171.96,76.73 171.26,76.73 170.97,77.02 170.97,78.21 170.9,78.34 170.9,78.56 170.96,78.7 170.96,79.01 170.9,79.13 170.9,79.3 170.96,79.42 170.96,80.22 170.9,80.28 170.9,80.75 U6000.G7
MDA1_25: length 30
  TOP w0.127: v1(194.94,76) 195,76 195.37,76.37 U6803.N11
  IN3 w0.122: v1(194.94,76) 194.69,75.75 193.03,75.75 192.84,75.56 190.41,75.56 190.35,75.63 188.92,75.63 188.7,75.42 188.21,75.42 188,75.63 187.41,75.63 187.2,75.42 176.89,75.42 176.55,75.08 172.68,75.08 172.51,75.25 172.24,75.25 171.88,75.61 171.88,75.84 v1(171.4,76.32)
  BOTTOM w0.102: U6000.G6 170.76,80.09 170.76,79.47 170.7,79.36 170.7,79.08 170.76,78.96 170.76,78.74 170.7,78.61 170.7,78.25 170.73,78.19 170.76,78.15 170.76,76.94 171.38,76.32 v1(171.4,76.32)
MDA1_26: length 31.5
  TOP w0.127: U6803.M13 196.6,76.83 v1(196.6,76.81)
  IN3 w0.122: v1(172.42,75.67) 173.05,76.3 173.05,76.86 173.25,77.07 174.55,77.07 175.75,75.87 186.99,75.87 187.18,76.06 190.53,76.06 190.59,75.99 191.85,75.99 192.08,76.22 193.18,76.22 193.56,76.6 195.42,76.6 195.6,76.42 196.2,76.42 v1(196.6,76.81)
  BOTTOM w0.102: U6000.G1 170.43,77.7 170.56,77.57 170.56,76.86 170.94,76.47 170.94,76.21 171.23,75.92 172.17,75.92 v1(172.42,75.67)
  BOTTOM w0.127: v1(172.42,75.67) 172.42,75.34 v2(172.95,74.81)
MDA1_27: length 32
  TOP w0.127: v1(196.6,76) 196.6,76.02 196.97,76.4 U6803.N13
  IN3 w0.122: v1(171.68,75.21) 171.98,74.91 171.98,74.83 172.31,74.5 172.77,74.5 172.92,74.65 176.78,74.65 177.12,74.99 183.36,74.99 183.93,74.41 186.88,74.41 187.13,74.67 192.55,74.67 193.17,75.29 195.31,75.29 195.6,75.58 196.18,75.58 v1(196.6,76)
  BOTTOM w0.102: v1(171.68,75.21) 171.4,75.49 171.37,75.49 170.71,76.15 170.71,76.41 170.35,76.77 170.35,77.47 170.1,77.73 170.1,78.09 U6000.G3
  BOTTOM w0.127: v1(171.68,75.21) 171.68,75.16 v2(171.2,74.68)
MDA1_28: length 36.6
  TOP w0.127: v1(195.77,73.58) 195.77,73.6 195.37,74 U6803.T11
  IN3 w0.122: v1(169.77,75.85) 169.77,75.54 169.45,75.22 169.45,73.19 170.84,71.79 179.16,71.79 179.96,72.6 182.22,72.6 182.4,72.42 182.4,72.19 182.54,72.04 193.6,72.04 194.38,72.82 194.39,72.82 195.15,73.58 v1(195.77,73.58)
  BOTTOM w0.102: 169.11,77.45 169.16,77.49 169.16,78.1 169.1,78.23 169.1,78.52 169.16,78.75 169.16,78.76 169.16,80.09 U6000.J6
  BOTTOM w0.127: 169.11,77.45 169.11,76.79 169.32,76.58 169.32,76.3 v1(169.77,75.85)
MDA1_29: length 36.3
  TOP w0.127: v1(197.36,72.83) 197.36,72.85 197,73.21 196.99,73.2 U6803.U13
  IN3 w0.122: v1(169.19,75.64) 168.68,75.14 168.68,74.23 168.86,74.05 168.86,73.17 170.66,71.37 179.49,71.37 180.29,72.16 181.53,72.16 181.74,71.96 181.74,71.76 181.88,71.62 193.79,71.62 194.5,72.33 196.86,72.33 v1(197.36,72.83)
  BOTTOM w0.102: U6000.J1 168.83,77.58 168.9,77.51 168.9,76.63 169.1,76.43 169.1,76.21 169.19,76.13 v1(169.19,75.64)
MDA1_30: length 40.3
  TOP w0.127: v1(197.4,73.61) 197.36,73.61 196.97,74 U6803.T13
  IN3 w0.122: v1(197.4,73.61) 197.84,73.17 197.84,72.71 197.04,71.9 195.7,71.9 194.73,70.94 191.19,70.94 190.94,71.19 181.93,71.19 181.68,70.94 169.11,70.94 167.84,72.21 167.84,75.2 v1(168.69,76.05)
  BOTTOM w0.102: U6000.J3 168.5,78.09 168.5,77.78 168.63,77.65 168.63,77.49 168.69,77.43 v1(168.69,76.05)
MDA1_31: length 40.3
  TOP w0.127: v1(195.96,71.33) 194.97,72.32 194.97,72.82 195.35,73.2 U6803.U11
  IN3 w0.122: v1(195.96,71.33) 195.15,70.51 190.94,70.51 190.69,70.76 182.11,70.76 181.86,70.51 168.94,70.51 167.42,72.03 167.42,75.65 v1(168.25,76.48)
  BOTTOM w0.102: v1(168.25,76.48) 168.4,76.63 168.4,77.59 168.3,77.69 168.3,78.14 168.4,78.37 168.44,78.89 168.45,78.93 U6000.J5
ME_FWP: length 99.2
  TOP w0.102: v1(82.74,19.62) 82.91,19.8 82.91,21.09 83.34,21.52 83.34,22.05 82.96,22.43 82.96,23.47 v2(84.94,25.45) 84.94,26.05 v1(85.46,26.57) ; v1(34.17,29.63) 34.5,29.31 U2300.80
  IN1 w0.097: v1(34.17,29.63) 35.38,28.42 37.82,28.42 41.82,24.43 41.82,22.2 44.05,19.97 45.65,19.97 49.11,16.5 57.5,16.5 59.88,14.12 60.07,14.12 60.71,13.49 63.7,13.49 64.26,14.05 71.78,14.05 72.22,14.48 72.78,14.48 74.07,15.78 76.51,15.78 77.03,16.3 79.41,16.3 v1(82.74,19.62)
  BOTTOM w0.102: v1(85.46,26.57) 85.46,27.56 83.87,29.15 83.87,35.63 92.21,43.97 92.71,43.97 93.55,44.81 94,44.81 95.58,46.38 99.29,46.38 99.44,46.23 R1012.1
ME_SUS_PWR_ACK: length 29.8
  TOP w0.102: v1(92.74,31.5) 92.74,31.63 92.46,31.9 91.67,31.9 91.47,32.11 90.93,32.11 90.6,31.78 R1229.2 90.04,30.84 89.84,30.63 89.84,29.91 90.2,29.55 90.2,29.22 90.43,28.98 90.61,28.98 R1208.2
  IN2 w0.102: v1(92.74,31.5) 93.22,31.5 94.41,32.69 101.67,32.69 107.06,38.09 107.06,39.6 107.32,39.86 109.17,39.86 v3(109.56,39.47)
  BOTTOM w0.076: v3(109.56,39.47) 109.55,39.47 109.3,39.73 U0400.AR13
  BOTTOM w0.102: v2(92.55,32.55) 92.74,32.36 v1(92.74,31.5)
MEC_XTAL1_R: length 10.9
  TOP w0.102: v2(47.16,47.87) 46.58,47.3 46.58,46.69 47.18,46.09 X2300.2 47.18,44.36 46.67,43.85 C2319.1 46.67,43.72 46.16,43.22 46.16,42.51 45.47,41.81 44.49,41.81 43.69,41.01 43.69,40.75 43.24,40.3 U2300.123
MEC_XTAL2: length 6.6
  TOP w0.102: U2300.125 43.47,41.1 44.17,41.79 v2(44.17,42.37) 44.17,42.47 43.97,42.67 43.97,43.16 C2312.2 44.22,43.41 44.45,43.41 44.55,43.31 44.55,43 44.68,42.88 R2329.1 44.93,43.31 45.03,43.41 45.72,43.41 45.85,43.54 R2330.2
MEC_XTAL2_R: length 5.2
  TOP w0.102: C2318.1 43.31,45.06 44.45,43.92 R2330.1 ; C2318.1 43.31,45.24 43.52,45.46 X2300.1 ; C2318.1 43,45.14 42.85,44.99 42.85,44.5 v2(42.57,44.22)
MEM_SMBCLK: length 72.5
  TOP w0.102: v3(119.88,35.74) 119.98,35.63 119.98,34.79 121.47,33.3 122.3,33.3 124.1,31.49 124.1,29.92 124.79,29.24 124.87,29.24 R1100.2 124.84,28.98 124.77,28.98 124.46,28.68 124.46,27.93 124.14,27.61 124.14,26.63 v1(123.27,25.76) ; v1(77.95,15.5) 77.95,15.12 78.66,14.4 v2(78.66,14.28) 78.66,13.29 v1(78.78,13.17)
  IN3 w0.127: v1(78.78,13.17) 81.2,10.75 84.38,10.75 84.65,10.48 89.62,10.48 90.42,11.28 95.12,11.28 96.32,12.47 97.47,12.47 97.83,12.83 101.22,12.83 102.06,13.67 102.41,13.67 103.15,14.4 108.05,14.4 109.09,15.43 109.92,15.43 110.19,15.17 116.96,15.17 121.23,19.44 121.23,20.23 121.7,20.7 121.7,21.83 123.48,23.61 123.48,25.54 v1(123.27,25.76)
  BOTTOM w0.089: v3(119.88,35.74) 119.66,35.74 U0400.R7
  BOTTOM w0.102: v1(77.95,15.5) 77.87,15.41 Q1902.6
MEM_SMBCLK_D: length 55.8
  TOP w0.102: C2106.1 56.25,28.3 56.15,28.2 v1(55.68,28.2) 55.12,27.64 v2(55.12,26.29) ; C2005.1 69.29,28.17 69.05,27.93 69.05,27.28 v1(69.05,27.28) 69.01,27.28 67.11,25.38 67.11,24.59 67.83,23.87 67.83,23.72 67.4,23.29 67.4,23.15 67.55,23.01 67.69,23.01 68.12,23.43 68.26,23.43 68.41,23.29 68.41,23.15 67.98,22.72 67.98,22.58 68.12,22.43 68.27,22.43 68.69,22.86 68.84,22.86 68.98,22.72 68.98,22.57 68.55,22.14 68.55,22 68.7,21.86 68.84,21.86 69.09,22.1 69.27,22.28 69.41,22.28 69.56,22.14 69.56,22 69.13,21.57 69.13,21.43 69.27,21.28 69.42,21.28 69.84,21.71 69.99,21.71 70.13,21.57 70.13,21.42 69.7,20.99 69.7,20.85 69.85,20.71 69.99,20.71 70.22,20.93 71.45,20.93 71.78,20.6 71.78,18.65 71.46,18.33 71.46,17.44 71.92,16.99 72.78,16.99 73.36,16.41 73.36,15.67 73.48,15.55 R1919.2 74.02,15.62 74.45,16.06 75.82,16.06 76.1,15.78 76.1,15.39 v1(76.12,15.37)
  IN1 w0.097: v1(55.68,28.2) 60.1,28.2 62.92,25.38 v1(63.78,25.38)
  IN3 w0.127: v1(76.12,15.37) 76.3,15.19 76.89,15.19 77.65,15.95 78.22,15.95 78.58,15.59 v1(78.58,15.5)
  BOTTOM w0.102: CON2100.253 56.18,28.32 56.05,28.2 v1(55.68,28.2) ; R1907.2 79.94,15.41 Q1902.1 78.67,15.41 v1(78.58,15.5) ; CON2000.253 69.09,27.32 v1(69.05,27.28) 68.67,26.9 66.95,26.9 65.05,25 64.16,25 v1(63.78,25.38)
MEM_SMBDATA: length 68.3
  TOP w0.102: v3(119.88,36.4) 119.49,36.02 119.49,34.59 121.27,32.82 122.1,32.82 123.62,31.29 123.62,30.13 123.52,30.03 R1101.2 123.98,28.86 123.98,28.15 123.66,27.83 123.66,26.89 v1(122.62,25.85) ; v1(79.93,13.34) 79.93,13.01 v2(79.64,12.72)
  IN3 w0.127: v1(122.62,25.85) 122.62,25.67 122.97,25.32 122.97,23.82 121.2,22.04 121.2,21.53 120.69,21.03 120.69,19.63 116.73,15.67 110.48,15.67 110.21,15.94 108.88,15.94 107.84,14.91 102.19,14.91 101.41,14.12 100.03,14.12 99.33,13.43 96.53,13.43 94.89,11.79 83.97,11.79 83.56,12.19 81.08,12.19 v1(79.93,13.34)
  BOTTOM w0.089: U0400.R8 119.65,36.4 v3(119.88,36.4)
  BOTTOM w0.102: Q1902.3 79.42,13.85 v1(79.93,13.34)
MEM_SMBDATA_D: length 69.5
  TOP w0.102: v1(51.51,28.15) 52.2,27.46 52.5,27.46 C2107.1 ; R1921.2 77.83,13.36 v1(77.63,13.16) ; C2006.1 63.2,27.59 63.2,27.21 v1(63.46,26.94) ; v1(59.87,16.66) 59.87,18.14 v2(60.05,18.32) 60.05,19.46 59.51,19.99 59.51,23.4 59.74,23.62 59.74,24.39 59.28,24.84 58.52,24.84 58.29,25.07 v1(58.29,25.91)
  IN1 w0.097: v1(77.63,13.16) 78.53,12.26 80.04,12.26 82.18,14.4 82.37,14.4 86.87,14.4 87.55,15.09 87.55,15.12 87.93,15.49 89.62,15.49 89.75,15.35 91.03,15.35 91.24,15.15 v1(91.24,15.13)
  IN2 w0.109: v1(77.63,13.16) 77.37,12.91 74.98,12.91 74.98,12.9 69.47,12.9 67.14,15.24 64.41,15.24 63.39,16.26 60.28,16.26 v1(59.87,16.66)
  BOTTOM w0.102: CON2100.254 50.2,28.07 50.7,28.58 51.08,28.58 v1(51.51,28.15) 52.4,27.26 54.27,27.26 55.69,25.83 58.22,25.83 v1(58.29,25.91) 58.8,25.91 60.35,27.46 60.88,27.46 61.27,27.07 CON2000.254 63.33,27.07 v1(63.46,26.94) ; Q1902.4 77.31,14.11 77.63,13.79 v1(77.63,13.16) ; R1908.2 91.21,14.48 91.24,14.51 v1(91.24,15.13)
MIC2_CAP: length 2.9
  BOTTOM w0.229: U3800.32 13.63,29.84 13.15,30.31 12.77,30.31
  BOTTOM w0.254: C3815.1 11.77,30.11 11.97,30.31 12.77,30.31
MIC2_L: length 5.5
  IN1 w1.016: 10.08,53.7 6.5,53.7 5.49,52.68 5.49,52.17
  vias: v1(9.78,54.56) v1(10.26,54.18)
MIC2_VREFO_L: length 2.7
  TOP w0.432: R3801.1 13.91,27.29 14.38,26.82 v2(14.38,26.57)
  BOTTOM w0.203: v1(13.23,28.09) 13.38,28.24 U3800.28
MIC2_VREFO_R: length 35.5
  TOP w0.102: v1(12.67,28.33) 12.67,27.39 v2(12.73,27.33)
  IN1 w0.381: v1(12.67,28.33) 12.36,28.33 11.86,28.83 11.86,31.19 12.4,31.73 14.43,31.73 14.82,32.12 14.82,32.61 14.24,33.19 14.24,38.98 13.67,39.55 13.67,51.69 12.62,52.73 9.55,52.73 v1(9.22,52.4)
  BOTTOM w0.229: U3800.29 13.75,28.64 13.68,28.57 13.04,28.57 12.8,28.33 v1(12.67,28.33)
  BOTTOM w0.381: v1(9.22,52.4) 9.42,52.6 R3800.1
MISO_TPM: length 4.1
  TOP w0.102: v1(32.69,58.3) R3910.1 32.23,58.09 32.23,59.24 32.56,59.57 U3901.24
  BOTTOM w0.102: v1(32.69,58.3) v2(32.69,57.66)
MODEL_ID: length 11
  TOP w0.102: U2300.109 43.33,34.7 43.46,34.57 43.46,32.84 43.78,32.53 44.32,32.53 44.43,32.41 45.2,32.41 R2312.1 R2313.1 47.03,31.92 47.12,32.01 C2313.1 47.63,32.01 48.18,31.45 48.18,30.53 v2(47.43,29.78) 47.43,29.53 47.35,29.44 R2351.1
MOSI_TPM: length 4.3
  TOP w0.102: U3901.21 32.05,61.07 31.78,61.34 31.78,61.6 31.7,61.67 R3909.1 31.09,61.67 30.96,61.55 30.96,61.34 30.84,61.22 29.87,61.22 v2(29.62,61.47)
MQ1500_G: length 10.6
  TOP w0.102: R2601.2 22.45,72.42 23.16,71.71 Q2600.1 24.7,71.71 25.07,72.09 25.07,72.83 25.28,73.03 26.52,73.03 26.92,72.63 26.92,70.89 26.64,70.61 Q2601.3 v2(26.64,68.61)
MSM#: length 2.3
  TOP w0.102: v3(109.42,64.19) 109.42,65.53 T0902.1
  BOTTOM w0.076: U0400.AP56 109.73,64.32 109.6,64.19 v3(109.42,64.19)
MVREFDA: length 13.4
  IN1 w0.254: v1(167.6,95.98) 167.89,96.28 167.89,97.06 168.1,97.27 168.1,99.92 167.74,100.28 167.74,102.34 v1(168.1,102.69)
  BOTTOM w0.254: v1(167.6,95.98) U6000.K26 ; C6302.1 R6307.1 165,102.92 165.35,102.57 v2(166.5,102.57) R6306.2 168.1,102.85 v1(168.1,102.69)
MVREFSA: length 11.1
  IN1 w0.254: v1(169.44,102.64) 169.6,102.48 169.6,99.98 168.71,99.09 168.71,97.11 v1(168.4,96.8)
  BOTTOM w0.102: R6304.2 170,105.26 170.54,104.73 v2(170.87,104.73)
  BOTTOM w0.254: v1(169.44,102.64) 169.7,102.9 R6305.1 C6301.1 R6304.2 ; U6000.J26 168.45,96.8 v1(168.4,96.8)
NB_MUTE#: length 2.2
  TOP w0.152: 44.6,39.12 44,39.12 v2(43.85,38.97) 43.58,38.7 U2300.119
Net_2018: length 0.3
  BOTTOM w0.203: 104.99,35.29 104.83,35.26 104.67,35.23
Net_2019: length 0.3
  BOTTOM w0.203: 104.67,33.82 104.35,33.82
Net_2049: length 0.3
  BOTTOM w0.203: 104.67,34.47 104.36,34.47
Net_2050: length 0.3
  BOTTOM w0.203: 104.67,33.17 104.34,33.17
Net_2064: length 0.3
  BOTTOM w0.203: 127.3,34.32 126.98,34.32
Net_2065: length 0.3
  BOTTOM w0.203: 127.3,33.67 127.3,33.34
Net_2084: length 0.3
  BOTTOM w0.203: 127.04,49.54 127.1,49.59 127.3,49.75
Net_2092: length 0.3
  BOTTOM w0.203: 127.3,48.62 127.3,48.29
Net_2095: length 0.3
  BOTTOM w0.203: 126.97,47.94 126.97,48.27
Net_2304: length 0.3
  BOTTOM w0.203: 167.23,99.22 167.23,98.89
NRB_BIT: length 13.3
  TOP w0.102: v3(108.65,36.74) 106.54,36.74 103.15,33.35 v3(103.15,32.41) 103.15,32.34 102.67,31.85 v2(101.24,31.85)
  BOTTOM w0.076: v3(108.65,36.74) 109.08,36.31 U0400.AR7
  BOTTOM w0.102: v3(103.15,32.41) 103.15,31.7 102.31,30.86 R1500.2
NTC_A_VCPU: length 3.6
  TOP w0.102: v2(178.64,48.41) 178.64,48.81 v1(178.26,49.19)
  TOP w0.254: PR7826.1 177.67,48.44 177.67,48.6 v1(178.26,49.19)
  BOTTOM w0.229: v1(178.26,49.19) 178.2,49.25 PU7800.15
NTC_A_VCPU_R: length 29.2
  TOP w0.254: v1(171.16,45.54) 171.64,46.03 173.51,46.03 174.96,47.48 v2(175.16,47.48) 175.74,46.89 176.48,46.89 176.73,47.14 PR7826.2
  IN2 w0.254: v1(171.16,45.54) 171.16,45.65 170.61,46.21 165.48,46.21 163.12,48.57 160.17,48.57 159.23,49.51 155.55,49.51 155.32,49.28 155.32,47.53 155.7,47.14 v1(157,47.14)
  BOTTOM w0.254: PR7829.1 156.87,47.02 v1(157,47.14)
NTC_B_VCPU: length 3.2
  TOP w0.102: PR7828.2 173.89,52.48 v2(173.63,52.22) 173.58,52.17 173.01,52.17 v1(172.92,52.26)
  BOTTOM w0.102: v1(172.92,52.26) 173.3,52.26 173.9,51.65 PU7800.3
OPC_RCOMP: length 3.8
  TOP w0.254: R0407.2 122.17,68.49 v3(122.55,68.87)
  BOTTOM w0.254: U0400.H65 122.55,69.21 v3(122.55,68.87)
OPCE_RCOMP: length 9.9
  TOP w0.102: R0406.2 128.09,76.02 126.95,74.88 126.95,73.99 126.54,73.58 126.54,73 123.99,70.45 122.97,70.45 v3(122.56,70.87)
  BOTTOM w0.076: U0400.H66 122.69,70.74 v3(122.56,70.87)
OUT1_DP_AUXN_C: length 9.1
  TOP w0.102: U5703.25 26.51,85.93 26.62,86.03 26.62,86.49 26.31,86.79 25.82,86.79 25.53,87.09 25.53,87.33 R5711.2 ; R5711.2 25.48,88.04 25.48,88.19 25.35,88.32 24.55,88.32 24.22,88.65 22.91,88.65 ; R5711.2 24.87,87.43 R5725.2 ; 22.91,88.65 v2(22.91,88.42) ; 22.91,88.65 22.75,88.65 22.45,88.95 22.45,89.08 22.07,89.46 C5718.2
OUT1_DP_AUXP_C: length 8
  TOP w0.102: 25.04,88.52 v2(25.04,88.75) ; 25.04,88.52 24.64,88.52 24.31,88.85 22.83,88.85 22.66,89.03 22.66,89.26 22.86,89.46 C5717.2 ; 25.04,88.52 25.43,88.52 25.68,88.28 25.68,88.17 26.09,87.76 R5710.1 26.09,87.61 25.73,87.25 25.73,87.18 25.91,87 26.4,87 26.82,86.57 26.82,86.07 26.91,85.98 U5703.24
OUT1_DP_D0N_C: length 2.2
  TOP w0.102: U5703.10 28.96,80.9 29.57,80.29 30.02,80.29 30.33,80.6 C5710.2
OUT1_DP_D0P_C: length 2.1
  TOP w0.102: C5709.2 30.33,79.76 30,80.09 29.48,80.09 29.07,80.5 U5703.9
OUT1_DP_D1N_C: length 4
  TOP w0.102: C5712.2 32.08,82.07 31.81,81.8 31.49,81.8 31.34,81.94 29.1,81.94 28.95,82.1 U5703.13
OUT1_DP_D1P_C: length 4.1
  TOP w0.102: U5703.12 29.06,81.7 29.11,81.74 31.26,81.74 31.41,81.59 31.59,81.59 32.06,81.13 C5711.2
OUT1_DP_D2N_C: length 2.2
  TOP w0.102: C5714.2 30.48,83.42 30.2,83.14 29.18,83.14 29.03,83.3 U5703.16
OUT1_DP_D2P_C: length 2.2
  TOP w0.102: C5713.2 30.48,82.63 30.18,82.93 28.98,82.93 28.94,82.9 U5703.15
OUT1_DP_D3N_C: length 4.9
  TOP w0.102: C5716.2 32.87,85.14 32.41,84.69 31.17,84.69 31.02,84.84 30.29,84.84 29.86,84.41 29.03,84.41 28.94,84.5 U5703.19
OUT1_DP_D3P_C: length 4.7
  TOP w0.102: U5703.18 29,84.1 29.11,84.2 29.95,84.2 30.38,84.64 30.94,84.64 31.09,84.48 32.3,84.48 32.53,84.25 C5715.2
PANEL_BKEN_EC: length 156.3
  TOP w0.102: v1(82.55,22.96) 82.55,22.2 v2(82.91,21.85) ; v1(39.01,37.98) 39.13,38.09 41.49,38.09 41.68,37.9 U2300.117
  IN3 w0.102: v1(39.01,37.98) 39.01,37.82 38.18,36.98 38.18,30.95 41.72,27.41 41.83,27.41 43.96,25.28 48.67,25.28 53.82,20.12 53.82,19.74 55.25,18.32 64.14,18.32 64.39,18.57 71.48,18.57 71.58,18.67 72.09,18.67 72.62,19.21 72.62,19.7 76.29,23.37 82.14,23.37 v1(82.55,22.96)
  BOTTOM w0.102: v1(82.55,22.96) 82.04,23.47 81.16,23.47 80.73,23.04 74.19,23.04 73.18,24.06 73.18,27.51 73.71,28.04 v2(73.71,61.62) 73.71,63.78 73.43,64.06 73.43,86.7 71.88,88.25 71.88,92.54 69.77,94.66 64.78,94.66 63.58,95.86 63.58,96.85 63.3,97.13 63.3,97.45 R3001.1
PANEL_BKEN_EC_R: length 2.6
  BOTTOM w0.102: R3001.2 62.92,99.04 62.79,99.16 62.48,99.16 v2(62.15,99.49) 62.08,99.57 CON3000.13
PBAT_PRES#: length 312.7
  TOP w0.102: v1(170.76,13.79) 169.5,12.52 165.4,12.52 164.16,13.77 155.25,13.77 v1(153.72,12.25) ; v1(201.73,28.88) 202.13,28.48 202.13,25.55 v1(202.01,25.43) ; v1(29.69,45.22) 29.69,45.09 29.7,45.08 U2300.29
  IN2 w0.102: v1(201.73,28.88) 200.83,27.99 200.83,23.35 201.2,22.99 202.63,22.99 203.45,22.17 203.45,21.18 198.71,16.44 156.38,16.44 155.44,17.38 154,17.38 152.81,18.57 151.71,18.57 150.75,17.6 143.55,17.6 142.64,16.7 134.8,16.7 131.91,13.82 127.18,13.82 126.7,14.3 124.41,14.3 124.28,14.18 118.36,14.18 117.78,14.76 110.12,14.76 109.81,15.06 102.39,15.06 101.73,14.4 101.48,14.4 100.94,13.86 100.94,13.28 100.42,12.76 100.29,12.63 97.01,12.63 96.42,12.04 96.41,12.04 90.96,12.04 89.69,10.77 85.58,10.77 84.46,11.89 82.88,11.89 82.52,11.53 65.85,11.53 64.08,13.29 64.08,14.25 63.7,14.63 57.84,14.63 57.19,13.99 52.51,13.99 49.63,16.87 46.56,16.87 46.3,17.12 42.76,17.12 42.18,16.54 41.1,16.54 34.11,23.53 34.11,29.12 33.02,30.21 33.02,36.25 29.69,39.58 v1(29.69,45.22)
  IN3 w0.102: v1(202.01,25.43) 201.65,25.07 200.42,25.07 198.31,22.97 198.31,22.36 196.75,20.8 196.75,20.07 194.51,17.83 180.23,17.83 179.42,18.65 175.91,18.65 v1(175.6,18.34)
  IN3 w0.127: v1(153.72,12.25) 153.72,12.19 153.32,11.8 152.9,11.8 152.34,12.36 151.04,12.36 149.48,10.8 140.37,10.8 v1(140.11,10.54)
  BOTTOM w0.102: v1(170.76,13.79) 170.76,15.24 171.45,15.93 173.19,15.93 v1(175.6,18.34) ; v1(29.69,45.22) v2(29.69,44.59) ; R3608.2 141.63,17.89 C3604.1 141.63,18.93 141.43,19.13 140.27,19.13 D3603.1 139.11,19.07 R3607.1 138.34,19.07 137.82,18.54 137.82,17.99 137.36,17.53 137.11,17.53 136.3,16.72 136.3,14.36 v1(140.11,10.54) ; v1(201.73,28.88) 201.73,29.52 201.14,30.1 PR7726.1
PBAT_SMBCLK: length 166.6
  TOP w0.102: R2317.1 37.21,47.09 36.7,47.6 v1(36.7,48.01)
  IN1 w0.097: v1(27.49,46.07) 27.2,45.79 27.2,45.46 30.53,42.13 30.53,40.54 31.57,39.49 31.57,27.97 33.56,25.98 33.56,16.2 36.71,13.06 40.74,13.06 41.81,11.98 50.03,11.98 50.83,12.79 54.12,12.79 56.26,10.65 58.9,10.65 59.23,10.31 66.45,10.31 67.23,9.53 67.23,8.78 69.21,6.81 84.29,6.81 85.52,8.04 85.52,11.36 86.68,12.52 90.57,12.52 91.32,11.77 104.12,11.77 104.81,12.45 109.51,12.45 110.27,13.21 112.9,13.21 116.18,9.93 117.7,9.93 118.26,9.38 123.78,9.38 126.09,11.69 v1(126.09,13.21)
  BOTTOM w0.102: v1(36.7,48.01) 36.7,47.92 36.49,47.7 32.49,47.7 v2(32.21,47.43) 31.58,46.8 28.22,46.8 v1(27.49,46.07) ; v1(126.09,13.21) 126.62,13.21 126.9,12.93 130.94,12.93 132.64,14.63 134.19,14.63 134.38,14.83 134.38,17.95 D3601.1 133.81,18 133.81,17.2 133.03,16.42 CON3601.4
PBAT_SMBDAT: length 169.3
  TOP w0.102: R2316.1 38.51,48.16 v1(38.52,48.17)
  IN1 w0.097: v1(125.43,13.21) 125.43,11.71 123.57,9.86 118.45,9.86 117.9,10.41 117.51,10.41 116.67,11.25 116.67,12.16 114.1,14.73 106.41,14.73 103.93,12.25 91.52,12.25 90.77,13 86.49,13 85.04,11.56 85.04,8.24 84.1,7.29 75.95,7.29 75.4,7.85 69.05,7.85 67.72,9.18 67.72,9.76 66.68,10.8 59.46,10.8 59.11,11.15 56.49,11.15 54.38,13.27 50.64,13.27 49.83,12.46 42.01,12.46 40.94,13.53 36.9,13.53 34.04,16.4 34.04,26.17 32.05,28.16 32.05,39.69 31.01,40.73 31.01,42.33 27.87,45.47 v1(27.77,45.47)
  BOTTOM w0.102: CON3601.5 135.03,16.95 136.34,18.26 ; 136.34,18.26 136.34,17.33 135.97,16.95 135.97,14.81 135.26,14.1 132.79,14.1 131.14,12.45 126.19,12.45 v1(125.43,13.21) ; 136.34,18.26 D3602.1 ; v1(38.52,48.17) v2(37.65,47.3) 36.66,46.31 28.61,46.31 v1(27.77,45.47)
PC_BEEP: length 44.6
  IN3 w0.254: v1(14.28,19.31) v1(14.28,22.63)
  BOTTOM w0.254: D3805.3 47.57,13.69 42.6,13.69 38.48,17.81 v2(35.89,17.81) 34.07,17.81 30.31,14.05 17.81,14.05 14.28,17.59 v1(14.28,19.31) ; R3823.2 14.71,22.2 v1(14.28,22.63)
PCBEEP: length 10.8
  TOP w0.254: v1(13.08,31.14) 12.62,31.6 v2(12.62,31.75)
  IN1 w0.254: v1(13.08,31.14) 13.08,30.43 13.72,29.8 13.72,27.88 12.85,27.02 12.85,25.48 v1(11.74,24.36)
  BOTTOM w0.254: C3834.2 11.74,23.95 v1(11.74,24.36) ; U3800.34 13.78,30.64 13.27,31.14 v1(13.08,31.14)
PCBEEP_R: length 4.3
  BOTTOM w0.254: v2(14.88,21.06) 14.43,21.06 13.84,21.64 R3823.1 R3822.1 C3843.1 C3834.1
PCH_BATLOW#: length 23.9
  TOP w0.102: v1(93.95,31.51) 93.94,31.51 93.35,30.91 T1204.1 92.53,30.91 92.2,30.58 92.2,29.73 92.28,29.65 92.28,29.65 92.3,29.63 92.3,29.09 92.61,28.78 R1204.2
  IN2 w0.102: v3(108.08,39.42) 108.46,39.04 108.46,38.13 108.36,38.03 108.36,37.47 106.88,35.99 106.88,35.99 106.26,35.36 104.67,35.36 101.78,32.46 94.71,32.46 94.61,32.36 94.6,32.36 93.95,31.72 v1(93.95,31.51)
  BOTTOM w0.089: U0400.AU13 108.08,39.64 v3(108.08,39.42)
PCH_DPWROK_R: length 10.3
  BOTTOM w0.076: 102.77,42.7 102.95,42.88 102.95,42.97 103.17,43.18 103.77,43.18 104.26,43.67 U0400.BB20
  BOTTOM w0.102: v2(96.06,40.72) R1216.2 96.83,41.43 97.08,41.68 98.37,41.68 98.81,42.12 T1200.1 101.07,42.6 102.67,42.6 102.77,42.7
PCH_ESPI_CLK: length 8.9
  BOTTOM w0.076: U0400.AW9 106.35,37.87 105.16,37.87 105.01,37.71 105.01,37.48 103.81,36.28
  BOTTOM w0.102: R1108.1 101.68,32.95 102.21,33.48 102.21,33.75 103.81,35.35 103.81,36.28
PCH_ESPI_CS#: length 19.1
  BOTTOM w0.076: U0400.BA12 104.3,39.45 103.9,39.06 103.56,39.06 103.48,38.98 103.44,38.98 102.97,38.51
  BOTTOM w0.102: R1115.1 C1105.1 98.86,30.86 99.24,31.24 99.24,33.28 98.91,33.61 98.1,33.61 97.97,33.48 97.32,33.48 97.08,33.72 97.08,34.05 97.32,34.29 98.62,34.29 98.82,34.09 99.36,34.09 v2(99.59,33.86) 99.83,34.09 101.16,34.09 102.97,35.91 102.97,38.51
PCH_ESPI_IO0: length 19.3
  TOP w0.102: v2(95.5,34.55) 95.5,34.78 ; 95.5,34.78 95.78,34.78 96.01,35 96.01,37.67 96.19,37.85 96.19,38.71 98.12,40.64 98.61,40.64 98.74,40.69 98.92,40.87 101.75,40.87 v1(102.37,40.25) ; 95.5,34.78 95.28,34.78 95.05,35 95.05,37.34 94.92,37.47 R1110.1
  BOTTOM w0.076: 103.05,40.31 104.3,40.31 104.45,40.47 104.78,40.47 105.09,40.33 105.66,40.33 U0400.AY13
  BOTTOM w0.102: v1(102.37,40.25) 102.44,40.31 103.05,40.31
PCH_ESPI_IO1: length 20.5
  TOP w0.102: R1111.1 93.62,37.47 94.46,38.31 v2(94.82,38.31) 95.33,37.8 95.33,35.13 95.45,35 95.66,35 95.76,35.11 95.76,38.6 98.03,40.87 98.57,40.87 98.61,40.89 98.83,41.1 102.1,41.1 102.82,40.39 102.82,40.06 v3(102.95,39.93)
  BOTTOM w0.076: U0400.BA13 104.92,40.22 104.75,40.3 104.52,40.3 104.37,40.15 104.23,40.15 103.61,40.15 103.4,39.93 v3(102.95,39.93)
PCH_ESPI_IO2: length 16.1
  TOP w0.102: v3(103.33,39.35) 103.33,40.09 103.14,40.28 103.14,40.39 102.18,41.35 99.42,41.35 99.09,41.68 98.24,41.68 95.44,38.89 93.45,38.89 v2(93.08,38.52) 92.61,38.05 R1112.1
  BOTTOM w0.076: U0400.BB13 104.62,39.98 104.44,39.98 104.44,39.98 104.16,39.98 104.16,39.98 103.68,39.98 103.33,39.63 v3(103.33,39.35)
PCH_ESPI_IO3: length 19.6
  TOP w0.102: v3(103.84,39.6) 103.84,39.91 103.37,40.38 103.37,40.5 101.95,41.91 101.65,41.91 101.4,41.66 101.07,41.66 100.81,41.91 100.43,41.91 100.15,41.63 99.85,41.63 99.57,41.91 98.14,41.91 95.37,39.14 93.07,39.14 92.05,38.13 92.05,37.59 91.92,37.47 R1113.1 91.57,38.05 v2(91.34,38.28)
  BOTTOM w0.076: v3(103.84,39.6) 103.86,39.63 105.21,39.63 105.33,39.75 106,39.75 106.18,39.56 U0400.AY12
PCH_JTAG_TCK: length 5.8
  BOTTOM w0.076: U0400.B56 126.89,64.86 127.09,64.86 127.23,64.88 127.45,64.88 127.79,64.54 129.16,64.54 129.18,64.52
  BOTTOM w0.102: T0404.1 130.38,63.96 130.38,63.99 129.85,64.52 129.18,64.52
PCH_JTAG_TDI: length 17.7
  TOP w0.102: R0401.1 129.64,76.14 129.36,75.86 129.36,75.18 129.36,75.18 129.36,73.23 127.2,71.07 T0400.1 127.47,65.53 v3(128.75,65.53)
  BOTTOM w0.076: v3(128.75,65.53) 128.64,65.42 128.27,65.42 128.16,65.53 127.15,65.53 127.1,65.56 126.84,65.56 126.79,65.53 126.49,65.53 126.29,65.63 125.68,65.63 U0400.D59 125.34,66.2 U0400.D60
PCH_JTAG_TDO: length 23
  TOP w0.102: v1(129.71,64.09) 131.56,62.23 135.81,62.23 136.2,62.61 138.3,62.61 T0401.1
  IN3 w0.102: v3(128.78,67.31) 128.78,66.26 129.9,65.14 129.9,64.28 v1(129.71,64.09)
  BOTTOM w0.076: 129.18,64.24 128.88,64.24 128.74,64.38 127.53,64.38 U0400.A56 ; v3(128.78,67.31) 128.6,67.13 127.34,67.13 U0400.A61
  BOTTOM w0.102: 129.18,64.24 129.55,64.24 v1(129.71,64.09) 130.56,63.24 130.56,63.05 131.34,62.26 131.78,62.26 132.18,61.85 R0403.1
PCH_JTAG_TMS: length 28.4
  TOP w0.076: 129.13,66.25 128.63,66.25 v3(128.32,65.94)
  TOP w0.102: T0402.1 135.37,65.15 134.08,63.86 132.61,63.86 130.53,65.94 v3(128.32,65.94) ; 129.13,66.25 129.38,66.25 129.66,66.53 129.66,67.57 128.52,68.71 128.52,72.1 129.56,73.14 129.56,74.9 130.56,75.9 R0402.1
  BOTTOM w0.076: U0400.C60 126,66.2 U0400.C59 126.17,65.79 126.17,65.79 126.33,65.79 126.53,65.7 126.75,65.7 126.8,65.72 127.14,65.72 127.19,65.7 128.19,65.7 128.32,65.83 v3(128.32,65.94)
PCH_JTAGX: length 13
  TOP w0.102: v3(127.79,66.12) 128.37,66.7 v1(129.26,66.7)
  BOTTOM w0.076: 129.18,66.77 127.71,66.77 127.6,66.66 126.92,66.66 126.65,66.94 U0400.B61 ; v3(127.79,66.12) 127.64,65.97 U0400.A59
  BOTTOM w0.102: 129.18,66.77 129.19,66.77 v1(129.26,66.7) 129.61,66.35 129.61,65.42 131.09,63.93 131.42,63.93 132.48,62.88 R0420.2 132.48,62.75 132.92,62.31 133.17,62.31 133.32,62.16 133.32,61.5 133.43,61.39 v2(133.43,60.94)
PCH_OPIRCOMP: length 2.8
  TOP w0.254: v3(107.26,42.29) v2(106.6,42.29) 106.33,42.29 105.84,42.78 R0405.2
  BOTTOM w0.254: U0400.AU16 v3(107.26,42.29)
PCH_PLTRST#: length 169.9
  TOP w0.102: R3905.2 v1(34.01,66.36) ; v2(33.25,50.22) 33.38,50.35 v1(35.12,50.35) ; D2500.2 83.46,20.35 83.87,20.75 v1(83.87,20.93)
  IN1 w0.102: v1(35.12,50.35) 34.2,50.35 29.87,54.67 29.87,58.82 29.06,59.63 29.06,63.98 31.46,66.37 32.11,66.37 32.5,66.77 33.6,66.77 v1(34.01,66.36)
  IN2 w0.102: v3(110.15,38.56) 110.51,38.2 110.69,38.2 111.09,37.8 111.09,35.14 109.56,33.62 104.88,33.62 103.94,32.68 103.94,31.52 102.99,30.57 94.75,30.57 92.79,28.61 92.79,27.64 93.02,27.41 93.68,27.41 93.83,27.56 93.83,28.15 94.03,28.35 95.12,28.35 v1(96.14,27.33) 95.48,26.67 94.83,26.67 94.7,26.55 94.11,26.55 93.62,27.03 92.61,27.03 91.16,28.48 89.61,28.48 86.06,24.92 85.7,24.92 85.19,24.41 81.6,24.41 78.16,20.97 75.49,20.97 75.12,20.6 70.83,20.6 70.7,20.73 63.99,20.73 63.74,20.98 57.79,20.98 56.85,20.04 55.98,20.04 54.25,21.77 51.8,21.77 50.89,22.68 48.39,22.68 47.85,22.15 44.9,22.15 43.18,23.88 43.18,23.88 43.03,24.03 43.03,24.37 40.03,27.36 40.03,34.79 39.7,35.11 39.7,37.86 38.28,39.29 37.97,39.59 37.97,40.2 35.64,42.54 35.64,44.06 36.3,44.73 36.3,47.08 35.84,47.54 35.84,49.63 v1(35.12,50.35)
  IN3 w0.102: v1(83.87,20.93) 84.3,21.36 89.26,21.36 90.6,22.71 90.6,23.48 90.85,23.73 91.2,23.73 94.52,23.73 95.17,24.37 95.17,25.15 95.96,25.94 95.96,27.16 v1(96.14,27.33)
  BOTTOM w0.076: v3(110.15,38.56) 110.15,38.35 U0400.AN10
  BOTTOM w0.102: v1(96.14,27.33) 96.58,27.78 U1200.2 97.52,27.78 97.84,28.09 100.05,28.09 100.36,27.79 R1201.1
PCH_RSMRST#: length 6.7
  TOP w0.102: v2(29.11,49.02) 29.31,49.02 29.59,48.75 R2322.1 30.23,48.29 30.59,47.92 30.59,46.73 30.51,46.64 R2323.2 30.12,46.22 30.5,45.85 U2300.27
PCH_RSMRST#_EC: length 106.9
  TOP w0.102: v1(21.34,47.63) 25.52,47.63 27.14,49.25 28.02,49.25 28.98,48.29 29.86,48.29 30.12,48.02 R2323.1 ; v1(62.19,5.75) 62.19,5.75 v2(63.12,6.68) 63.59,7.15 67.22,7.15 67.69,6.68 69.6,6.68 70.31,7.39 R1217.2 70.66,7.39 71.2,6.86 71.67,6.86 71.98,7.17 v1(71.98,7.42)
  IN1 w0.102: v1(21.34,47.63) 20.9,47.2 20.9,44 21.1,43.8 21.1,40.36 21.51,39.95 21.51,36.54 22.87,35.18 22.91,35.18 23.47,34.63 23.47,27.21 23.42,27.16 23.42,18.96 38.01,4.37 60.81,4.37 v1(62.19,5.75)
  BOTTOM w0.102: v1(71.98,7.42) 73.1,8.54 73.1,12.89 72.66,13.33 72.54,13.33 72.04,13.83 72.04,14.89 72.47,15.32 U1202.2
PCH_TRST: length 18.1
  TOP w0.102: v1(129.24,65.18) 130.76,63.65 134.16,63.65 135.46,64.95 138.66,64.95 138.94,64.67 139.75,64.67 T0403.1
  BOTTOM w0.076: 129.18,65.82 128.42,66.59 127.76,66.59 127.67,66.49 127.39,66.49 126.86,65.97 U0400.B59 126.65,66.65 126.21,67.09 U0400.C61
  BOTTOM w0.102: v1(129.24,65.18) 129.24,65.77 129.18,65.82
PCIE1_GPU_RXN: length 56.7
  TOP w0.102: v5(139.6,81.66) 139.63,81.66 C6003.2
  IN1 w0.109: v5(139.6,81.66) 139.6,81.35 139.41,81.17 139.41,76.59 138.78,75.96 138.78,66.89 138.07,66.19 138.07,56.6 138.64,56.04 138.64,52.15 137.11,50.62 137.11,45.29 136.17,44.35 136.17,42.95 134.53,41.32 126.13,41.32 124.87,40.06 123.58,40.06 v3(122.97,39.44)
  BOTTOM w0.089: U0400.H13 122.62,39.79
  BOTTOM w0.102: 122.62,39.79 v3(122.97,39.44)
PCIE1_GPU_RXN_C: length 30
  TOP w0.102: C6003.1 140.84,82.78 141.17,82.78 141.55,83.16 141.55,83.67 147.8,89.92 147.8,90.54 148.21,90.95 148.21,92.37 151.33,95.48 155.4,95.48 156.21,96.29 156.21,98.51 155.11,99.61 154.8,99.61 154.64,99.44 154,99.44 153.87,99.57 153.87,99.93 154,100.05 154.38,100.05 v1(154.51,99.93)
  BOTTOM w0.102: U6000.AG31 154.33,99.22 154.21,99.34 154.21,99.92 154.28,99.99 154.44,99.99 v1(154.51,99.93)
PCIE1_GPU_RXP: length 56.8
  TOP w0.102: C6002.2 140.64,81.76 140.46,81.76 140.21,81.51 v1(140.21,81.28)
  IN1 w0.109: v1(140.21,81.28) 139.83,81.28 139.62,81.08 139.62,76.5 138.99,75.87 138.99,66.81 138.29,66.1 138.29,56.69 138.85,56.12 138.85,52.06 137.32,50.53 137.32,45.2 136.38,44.26 136.38,42.87 134.62,41.1 126.22,41.1 124.96,39.85 123.69,39.85 123.62,39.78 v3(123.62,39.44)
  BOTTOM w0.089: U0400.G13 123.62,39.59 v3(123.62,39.44)
PCIE1_GPU_RXP_C: length 30.1
  TOP w0.102: v1(154.33,100.51) 154.51,100.33 154.68,100.33 156.41,98.6 156.41,96.21 155.48,95.28 151.41,95.28 148.41,92.28 148.41,91.39 ; C6002.1 141.4,82.22 141.4,82.72 141.76,83.08 141.76,83.59 148.01,89.84 148.01,90.45 148.41,90.86 148.41,91.39 ; 148.41,91.39 v2(148.64,91.39)
  BOTTOM w0.102: v1(154.33,100.51) 154.33,100.33 154,100 154,99.6 153.94,99.41 153.63,99.1 U6000.AH30
PCIE1_GPU_TXN: length 88
  IN1 w0.109: v1(155.12,104.79) 155.12,102.8 152.76,100.43 152.76,97.94 149.46,94.65 143.63,94.65 142.35,93.38 142.35,92.45 138.95,89.05 137.02,89.05 136.75,88.78 136.75,88.62 136.33,88.19 134.01,88.19 133,87.19 133,77.97 133.82,77.15 133.82,75.86 132.61,74.65 132.39,74.65 130.33,72.6 130.33,69.08 131.57,67.84 131.57,67.18 133.48,65.27 133.48,62.26 134.44,61.29 134.44,53.96 132.33,51.86 132.33,50.89 131.88,50.43 131.88,44.43 131.4,43.95 131.4,43.45 v1(131.72,43.13)
  BOTTOM w0.076: U0400.B17 126.86,42.31 127.13,42.04 127.47,42.04
  BOTTOM w0.102: v1(131.72,43.13) 131.72,43.08 130.99,42.34 129.17,42.34 128.87,42.04 127.47,42.04 ; v1(155.12,104.79) 155.27,104.64 C6009.2
PCIE1_GPU_TXN_C: length 5.2
  BOTTOM w0.102: U6000.AE31 155.78,99.47 155.78,101.03 154.53,102.27 154.53,102.82 154.7,102.99 154.9,102.99 C6009.1
PCIE1_GPU_TXP: length 88
  IN1 w0.109: v1(130.96,43.13) 131.06,43.13 131.19,43.26 131.19,44.04 131.67,44.51 131.67,50.52 132.12,50.97 132.12,51.94 134.23,54.05 134.23,61.21 133.27,62.17 133.27,65.19 131.36,67.09 131.36,67.75 130.12,69 130.12,72.68 132.3,74.86 132.52,74.86 133.6,75.95 133.6,77.07 132.79,77.88 132.79,87.27 133.92,88.41 136.24,88.41 136.54,88.71 136.54,88.87 136.93,89.26 138.86,89.26 142.14,92.54 142.14,93.46 143.54,94.86 149.38,94.86 152.55,98.03 152.55,100.52 154.91,102.88 154.91,104.22 154.78,104.35 154.15,104.35 154.05,104.45 154.05,104.68 154.17,104.79 v1(154.51,104.79)
  BOTTOM w0.102: C6008.2 154.33,104.61 v1(154.51,104.79) ; U0400.A17 127.36,42.25 128.79,42.25 129.08,42.55 130.91,42.55 131.14,42.78 131.14,42.96 v1(130.96,43.13)
PCIE1_GPU_TXP_C: length 5.2
  BOTTOM w0.102: C6008.1 154.33,102.19 155.57,100.94 155.57,99.16 U6000.AF30
PCIE2_GPU_RXN: length 64.9
  TOP w0.102: C6005.2 136.93,84.25 v5(136.93,84.13)
  IN1 w0.109: v3(123.55,38.6) 123.99,39.05 124.95,39.05 126.59,40.69 130.51,40.69 131.38,39.81 131.59,39.81 132.44,40.67 134.85,40.67 136.8,42.62 136.8,43.64 137.73,44.57 137.73,50.35 139.27,51.89 139.27,56.29 138.7,56.86 138.7,65.67 139.42,66.39 139.42,75.64 140.73,76.95 140.73,81.63 140.15,82.21 139.57,82.21 138.79,81.43 137.83,81.43 136.77,82.49 136.77,83.66 136.93,83.82 v5(136.93,84.13)
  BOTTOM w0.089: v3(123.55,38.6) 123.27,38.88 U0400.G11
PCIE2_GPU_RXN_C: length 24.6
  TOP w0.102: C6005.1 138.76,86.08 142.24,86.08 146.58,90.43 146.58,91.05 146.99,91.45 146.99,92.87 150.92,96.8 152.2,96.8 153.98,98.58 154.32,98.58 154.32,98.58 154.49,98.58 154.76,98.31 154.76,98.14 154.76,97.69 v1(154.84,97.61)
  BOTTOM w0.102: v1(154.84,97.61) 154.84,97.63 U6000.AF28
PCIE2_GPU_RXP: length 64.6
  TOP w0.102: C6004.2 138.17,84.23 137.82,84.23 137.63,84.04 v1(137.63,83.91)
  IN1 w0.109: v1(137.63,83.91) 137.58,83.96 137.38,83.96 136.98,83.57 136.98,82.58 137.91,81.65 138.7,81.65 139.48,82.43 140.23,82.43 140.94,81.71 140.94,76.86 139.63,75.55 139.63,66.3 138.91,65.59 138.91,56.95 139.48,56.38 139.48,51.81 137.94,50.27 137.94,44.48 137.02,43.55 137.02,42.53 134.94,40.46 132.53,40.46 131.68,39.6 131.3,39.6 130.42,40.48 126.68,40.48 125.04,38.84 124.43,38.84 v3(124.2,38.6)
  BOTTOM w0.089: v3(124.2,38.6) 123.92,38.88 U0400.F11
PCIE2_GPU_RXP_C: length 25
  TOP w0.102: C6004.1 138.74,84.89 138.74,85.71 138.9,85.88 142.32,85.88 146.79,90.34 146.79,90.96 147.19,91.37 147.19,92.79 151.01,96.6 152.28,96.6 154.06,98.38 154.41,98.38 154.56,98.22 154.56,98.02 154.38,97.84 v1(154.23,97.84)
  BOTTOM w0.102: v1(154.23,97.84) 154.49,97.84 154.72,98.07 154.72,98.29 154.6,98.42 U6000.AG29
PCIE2_GPU_TXN: length 93.5
  IN1 w0.109: v1(156.95,104.79) 156.95,101.2 149.78,94.03 143.89,94.03 142.98,93.12 142.98,92.2 139.83,89.04 139.83,88.29 138.95,87.41 134.14,87.41 133.62,86.9 133.62,79.22 134.47,78.38 134.47,75.62 132.51,73.66 132.28,73.66 130.96,72.34 130.96,69.67 132.82,67.82 134.31,67.82 135.19,66.94 135.19,53.81 132.99,51.62 132.99,50.63 132.52,50.16 132.52,45.15 132.89,44.78 133.07,44.78 133.6,44.24 133.6,43.41 v1(133.82,43.2)
  BOTTOM w0.076: U0400.D16 125.91,41.75 125.94,41.72 125.98,41.68 126.2,41.46 126.84,41.46 127.06,41.67 129.51,41.67 129.57,41.73 129.59,41.73
  BOTTOM w0.102: C6011.2 157.2,104.54 v1(156.95,104.79) ; v1(133.82,43.2) 133.43,42.8 132.31,42.8 131.24,41.73 129.59,41.73
PCIE2_GPU_TXN_C: length 6.2
  BOTTOM w0.102: U6000.AD28 156.83,98.14 156.46,98.5 156.46,98.9 156.57,99.05 156.57,99.32 156.39,99.91 156.39,102.82 156.52,102.95 157.07,102.95 157.2,103.08 C6011.1
PCIE2_GPU_TXP: length 93.5
  IN1 w0.109: v1(133.15,43.36) 133.39,43.61 133.39,44.16 132.98,44.57 132.8,44.57 132.31,45.06 132.31,50.24 132.78,50.72 132.78,51.71 134.98,53.9 134.98,66.86 134.22,67.61 132.73,67.61 130.75,69.59 130.75,72.43 132.2,73.87 132.42,73.87 134.26,75.71 134.26,78.29 133.41,79.14 133.41,86.98 134.05,87.62 138.86,87.62 139.62,88.38 139.62,89.13 142.77,92.28 142.77,93.21 143.8,94.24 149.69,94.24 156.74,101.28 156.74,104.02 156.61,104.14 156.15,104.14 156.02,104.27 156.02,104.47 v1(156.34,104.79)
  BOTTOM w0.076: 129.59,41.93 129.54,41.93 129.44,41.84 126.99,41.84 126.77,41.62 126.68,41.62 126.62,41.68 126.62,41.92 126.42,42.12 126.31,42.12 126.18,41.99 126.18,41.88 U0400.C16
  BOTTOM w0.102: C6010.2 156.24,104.69 v1(156.34,104.79) ; v1(133.15,43.36) 133.15,43.13 133.02,43 132.23,43 131.16,41.93 129.59,41.93
PCIE2_GPU_TXP_C: length 6.2
  BOTTOM w0.102: C6010.1 156.24,102.96 156.18,102.91 156.18,99.88 156.36,99.29 156.36,99.11 156.26,98.96 156.16,98.86 155.85,98.86 155.65,98.66 155.65,98.3 155.78,98.17 155.93,98.17 156.03,98.28 U6000.AE29
PCIE3_GPU_RXN: length 67.8
  TOP w0.102: v1(138.91,82.48) 139.01,82.58 139.22,82.58 C6001.2
  IN1 w0.109: v3(122.46,41.31) 122.67,41.52 122.67,41.69 122.92,41.94 124.39,41.94 125.13,42.68 133.96,42.68 134.84,43.56 134.84,45.74 133.58,47 133.58,49.63 134.2,50.26 134.2,50.42 134.67,50.89 134.67,51.69 136.95,53.97 136.95,55.77 136.32,56.4 136.32,59.72 136.78,60.18 136.78,67.13 137.53,67.88 137.53,77.41 134.66,80.27 134.66,85.48 135.47,86.29 136.64,86.29 139.17,83.76 139.17,83.03 138.89,82.75 138.89,82.5 v1(138.91,82.48)
  BOTTOM w0.089: v3(122.46,41.31) 122.62,41.47 U0400.H16
PCIE3_GPU_RXN_C: length 23.2
  TOP w0.102: v1(155.62,96.81) 155.5,96.81 155.36,96.67 155.36,96.44 154.87,95.94 151.21,95.94 147.8,92.53 147.8,91.11 147.4,90.71 147.4,90.09 142.12,84.81 141,84.81 140.08,83.9 140.08,83.54 C6001.1
  BOTTOM w0.102: U6000.AF26 v1(155.62,96.81)
PCIE3_GPU_RXP: length 67.7
  TOP w0.102: v5(138.35,82.88) 138.46,82.98 138.84,82.98 138.91,83.06 138.91,83.49 C6000.2
  IN1 w0.109: v3(123.02,41.31) 122.89,41.44 122.89,41.6 123.01,41.73 124.48,41.73 125.22,42.46 134.04,42.46 135.05,43.47 135.05,45.82 133.79,47.09 133.79,49.55 134.41,50.17 134.41,50.33 134.88,50.8 134.88,51.6 137.16,53.88 137.16,55.86 136.53,56.48 136.53,59.63 136.99,60.09 136.99,67.04 137.74,67.79 137.74,77.49 134.87,80.36 134.87,85.4 135.56,86.08 136.55,86.08 138.96,83.68 138.96,83.12 138.83,82.99 138.46,82.99 v5(138.35,82.88)
  BOTTOM w0.089: v3(123.02,41.31) 122.91,41.41 122.91,41.68 123,41.77 U0400.G16
PCIE3_GPU_RXP_C: length 23.3
  TOP w0.102: C6000.1 139.55,84.08 139.97,84.08 140.91,85.02 142.04,85.02 147.19,90.17 147.19,90.79 147.6,91.2 147.6,92.62 151.12,96.14 154.78,96.14 155.16,96.52 155.16,96.7 155.03,96.83 v1(154.84,96.83)
  BOTTOM w0.102: v1(154.84,96.83) 155.1,96.83 155.23,96.95 U6000.AF27
PCIE3_GPU_TXN: length 94.3
  IN1 w0.109: v3(128.58,43.16) 128.77,43.35 128.77,43.6 129.02,43.85 130.11,43.85 131.03,44.76 131.03,50.81 131.48,51.26 131.48,52.21 133.61,54.34 133.61,60.74 132.58,61.76 132.58,64.98 130.68,66.88 130.68,67.41 129.49,68.61 129.49,72.94 131.32,74.77 131.32,76.76 132.16,77.61 132.16,87.53 134.55,89.92 138.63,89.92 140.85,92.13 140.85,93.19 143.99,96.33 149.9,96.33 151.78,98.21 151.78,100.16 151.48,100.47 151.48,102.6 153.23,104.36 153.23,105.29 153.88,105.94 155.53,105.94 155.86,105.61 156.45,105.61 156.95,106.11 158.41,106.11 158.78,105.74 v1(158.78,104.79)
  BOTTOM w0.076: v3(128.58,43.16) 128.63,43.11 128.63,42.84 128.5,42.71 127.57,42.71 127.53,42.75 127.16,42.75 127.08,42.71 126.86,42.71 126.79,42.74 126.52,42.74 126.39,42.7 126.35,42.68 125.93,42.68 125.56,42.31 U0400.D17
  BOTTOM w0.102: v1(158.78,104.79) 158.78,104.52 C6013.2
PCIE3_GPU_TXN_C: length 5.7
  BOTTOM w0.102: C6013.1 159.08,103.02 158.98,102.92 158.47,102.92 158.34,102.79 158.34,102.25 157.4,101.32 157.4,99.56 157.28,99.29 157.28,99.16 157.38,99.06 157.48,99.06 U6000.AC31
PCIE3_GPU_TXP: length 94.3
  IN1 w0.109: v3(129.19,43.09) 128.98,43.3 128.98,43.51 129.11,43.64 130.2,43.64 131.24,44.68 131.24,50.72 131.69,51.17 131.69,52.12 133.82,54.25 133.82,60.83 132.79,61.85 132.79,65.07 130.89,66.97 130.89,67.5 129.7,68.7 129.7,72.86 131.53,74.69 131.53,76.67 132.37,77.52 132.37,87.45 134.63,89.71 138.72,89.71 141.06,92.05 141.06,93.11 144.07,96.12 149.99,96.12 151.99,98.12 151.99,100.25 151.69,100.55 151.69,102.52 153.44,104.27 153.44,105.21 153.96,105.73 155.44,105.73 155.77,105.4 156.53,105.4 157.04,105.9 158.32,105.9 158.56,105.66 158.56,105.38 158.47,105.29 158.27,105.29 158.17,105.39 157.94,105.39 157.83,105.28 157.83,105.13 v1(158.17,104.79)
  BOTTOM w0.076: U0400.C17 126.2,42.52 126.38,42.52 126.52,42.57 126.55,42.58 126.75,42.58 126.82,42.55 127.12,42.55 127.21,42.59 127.46,42.59 127.5,42.55 128.65,42.55 v3(129.19,43.09)
  BOTTOM w0.102: v1(158.17,104.79) 158.35,104.61 158.35,104.43 C6012.2
PCIE3_GPU_TXP_C: length 5.7
  BOTTOM w0.102: U6000.AD30 156.99,98.66 157.2,98.66 157.28,98.73 157.28,98.88 157.07,99.08 157.07,99.34 157.2,99.61 157.2,101.4 158.14,102.34 C6012.1
PCIE4_GPU_RXN: length 60.1
  TOP w0.102: v5(135.53,85.47) 135.53,85.76 C6007.2
  IN1 w0.109: v5(135.53,85.47) 135.53,85.24 135.3,85 135.3,82.77 138.79,79.28 138.79,77.23 138.16,76.6 138.16,67.54 137.41,66.8 137.41,56.37 138,55.78 138,52.4 136.47,50.87 136.47,45.7 135.53,44.76 135.53,43.26 134.3,42.03 125.96,42.03 124.8,40.87 124.08,40.87 123.68,40.47 v3(123.61,40.47)
  BOTTOM w0.102: v3(123.61,40.47) 123.61,40.52 U0400.G15
PCIE4_GPU_RXN_C: length 33.4
  TOP w0.102: C6007.1 136.65,86.79 137,86.79 137.13,86.92 142.21,86.92 145.97,90.68 145.97,91.88 146.38,92.29 146.38,93.12 152.96,99.7 152.96,101.08 153.23,101.35 155.32,101.35 155.68,100.99 155.68,100.57 157.94,98.31 157.94,97.3 157.67,97.03 157.45,97.03 v1(157.25,96.83)
  BOTTOM w0.102: v1(157.25,96.83) 156.84,96.42 U6000.AD26
PCIE4_GPU_RXP: length 60.1
  TOP w0.102: v1(136.17,85.14) 136.17,85.54 136.26,85.63 136.6,85.63 C6006.2
  IN1 w0.109: v1(136.17,85.14) 136.08,85.23 135.9,85.23 135.51,84.84 135.51,82.86 139,79.37 139,77.14 138.37,76.51 138.37,67.45 137.63,66.71 137.63,56.46 138.21,55.87 138.21,52.31 136.69,50.79 136.69,45.61 135.75,44.67 135.75,43.17 134.39,41.82 126.04,41.82 124.89,40.66 124.35,40.66 124.24,40.55 v3(124.24,40.47)
  BOTTOM w0.102: v3(124.24,40.47) 124.24,40.75 124.14,40.85 U0400.F15
PCIE4_GPU_RXP_C: length 33.3
  TOP w0.102: C6006.1 137.16,86.29 137.16,86.57 137.31,86.72 142.3,86.72 146.18,90.6 146.18,91.8 146.58,92.2 146.58,93.04 153.16,99.62 153.16,100.99 153.31,101.15 155.24,101.15 155.47,100.91 155.47,100.48 157.73,98.22 157.73,97.39 157.58,97.23 157.31,97.23 157.2,97.34 157.2,97.58 v1(157.26,97.64)
  BOTTOM w0.102: v1(157.26,97.64) 157.03,97.64 157,97.61 156.74,97.61 156.64,97.51 156.64,97.41 U6000.AD27
PCIE4_GPU_TXN: length 90.3
  IN1 w0.109: v1(133.71,45.62) 133.71,46.28 133.15,46.83 133.15,49.9 133.63,50.38 133.63,51.34 135.89,53.6 135.89,67.44 137.12,68.67 137.12,76.98 134.25,79.84 134.25,85.66 135.37,86.79 140.89,86.79 141.58,87.48 141.58,89.21 144.42,92.05 144.42,93.09 144.74,93.4 150.16,93.4 152.75,95.99 155.72,95.99 156.36,96.63 156.36,98.89 160.5,103.03 v1(160.5,104.79)
  BOTTOM w0.076: U0400.B19 126.85,43.66 127.28,44.1 128.93,44.1 129.03,44.2 129.08,44.2
  BOTTOM w0.102: v1(160.5,104.79) 160.96,104.33 C6015.2 ; 131.05,44.92 131.22,45.09 131.8,45.09 132.61,45.9 133.3,45.9 133.58,45.62 v1(133.71,45.62) ; 131.05,44.92 130.33,44.2 129.08,44.2 ; 131.05,44.92 v2(130.89,45.09)
PCIE4_GPU_TXN_C: length 7.7
  BOTTOM w0.102: C6015.1 160.96,103.02 160.86,102.91 160.35,102.91 160.22,102.79 160.22,102.34 ; 160.22,102.34 160.22,101.98 159.98,101.73 159.13,101.73 158.06,100.65 158.06,99.58 158.16,99.38 158.16,99.09 158.09,98.94 158.09,98.7 158.24,98.45 158.24,98.21 U6000.AB28 ; 160.22,102.34 v2(160.45,102.34)
PCIE4_GPU_TXP: length 90.3
  IN1 w0.109: v1(132.99,45.39) 133.3,45.7 133.3,45.8 133.5,45.99 133.5,46.19 132.94,46.75 132.94,49.99 133.42,50.46 133.42,51.43 135.68,53.69 135.68,67.53 136.91,68.75 136.91,76.89 134.04,79.76 134.04,85.75 135.29,87 140.8,87 141.37,87.57 141.37,89.3 144.21,92.14 144.21,93.18 144.65,93.61 150.07,93.61 152.66,96.2 155.63,96.2 156.15,96.72 156.15,98.98 160.29,103.12 160.29,104.13 160.17,104.26 159.99,104.26 159.78,104.05 159.6,104.05 159.47,104.19 159.47,104.37 v1(159.89,104.79)
  BOTTOM w0.076: U0400.A19 127.24,43.72 127.24,43.82 127.35,43.93 128.99,43.93 129.06,44 129.08,44
  BOTTOM w0.102: v1(159.89,104.79) 160.02,104.66 C6014.2 ; 129.08,44 130.42,44 131.3,44.88 131.89,44.88 132.65,45.65 132.83,45.65 132.99,45.48 v1(132.99,45.39)
PCIE4_GPU_TXP_C: length 7.5
  BOTTOM w0.102: v2(158.57,101.81) 158.75,101.63 ; 158.75,101.63 157.85,100.74 157.85,99.5 157.96,99.3 157.96,99.14 157.89,98.99 157.89,98.65 158.04,98.4 158.04,98.22 157.95,98.14 157.77,98.14 157.63,98.28 U6000.AC29 ; 158.75,101.63 159.05,101.93 159.89,101.93 160.02,102.06 C6014.1
PCIE5_LAN_RXN: length 94.5
  IN1 w0.109: v5(192.33,20.37) 192.33,20.21 192.2,20.08 191.63,20.08 191.53,19.98 191.53,19.78 191.67,19.64 192.45,19.64 192.58,19.51 192.58,18.3 190.36,16.09 179.54,16.09 179.19,16.44 165.14,16.44 162.04,19.54 158.97,19.54 157.77,20.74 156.82,20.74 156.41,21.14 156.41,22.43 154.86,23.98 152.88,23.98 152.78,23.88 150.8,23.88 149.99,24.69 144.62,24.69 143.58,25.73 138.6,25.73 137.29,27.05 137.29,29.28 134.43,32.13 130.89,32.13 129.48,33.54 125.84,33.54 124.23,35.16 122.47,35.16 121.89,35.74 121.89,40.26 122.31,40.69 123.27,40.69 123.48,40.9 123.75,40.9 v3(124.15,41.3)
  BOTTOM w0.102: U0400.F16 123.92,41.53 v3(124.15,41.3) ; v5(192.33,20.37) 192.51,20.19 192.51,20.01 192.32,19.83 CON5104.5
PCIE5_LAN_RXP: length 94.6
  IN1 w0.109: v3(123.59,41.31) 123.18,40.9 122.23,40.9 121.68,40.35 121.68,35.65 122.39,34.95 124.14,34.95 125.76,33.33 129.39,33.33 130.8,31.92 134.35,31.92 137.08,29.19 137.08,26.96 138.51,25.52 143.49,25.52 144.54,24.48 149.9,24.48 150.71,23.67 152.87,23.67 152.97,23.77 154.78,23.77 156.2,22.34 156.2,21.06 156.73,20.53 157.69,20.53 158.89,19.32 161.95,19.32 165.05,16.23 179.1,16.23 179.46,15.88 190.45,15.88 192.79,18.21 192.79,20.14 v1(193.01,20.37)
  BOTTOM w0.102: v3(123.59,41.31) 123.59,41.87 123.81,42.09 124.21,42.09 124.53,41.77 U0400.E16 ; CON5104.6 192.82,20.18 v1(193.01,20.37)
PCIE5_LAN_TXN: length 90.9
  IN1 w0.109: v1(137.84,32.97) 137.63,32.76 137.63,30.75 138.56,29.82 138.56,28.17 140.33,26.4 143.8,26.4 144.77,25.43 154.4,25.43 159.04,20.79 161.84,20.79 165.57,17.06 179.45,17.06 179.8,16.71 185.83,16.71 190.67,21.55 190.67,23.17 190.54,23.29 190.07,23.29 189.94,23.42 189.94,23.7 190.07,23.83 v1(190.27,23.83)
  BOTTOM w0.076: U0400.C19 126.14,43.52 126.22,43.52 126.39,43.45 126.52,43.4 126.54,43.39 126.74,43.39 126.83,43.43 127.12,43.43 127.22,43.38 127.47,43.38 127.72,43.63 127.99,43.63 128.1,43.74 129.18,43.74
  BOTTOM w0.102: v1(137.84,32.97) 137.62,33.2 137.62,38.08 137.12,38.57 ; 129.18,43.74 130.47,43.74 130.78,44.05 131.21,44.05 131.54,44.38 132.1,44.38 132.38,44.66 133.23,44.66 133.43,44.45 134.73,44.45 136.58,42.61 136.58,39.12 137.12,38.57 ; 137.12,38.57 v2(137.29,38.74) ; C5136.2 190.4,23.04 190.64,23.28 190.64,23.46 v1(190.27,23.83)
PCIE5_LAN_TXN_C: length 5.2
  BOTTOM w0.102: CON5104.7 193.32,20.1 193.42,20.2 193.42,20.59 192.85,21.16 191.43,21.16 190.67,21.92 190.58,21.92 190.32,22.18 C5136.1
PCIE5_LAN_TXP: length 90.9
  IN1 w0.109: v1(190.88,23.83) 190.88,21.47 185.92,16.5 179.72,16.5 179.36,16.85 165.48,16.85 161.76,20.58 158.95,20.58 154.31,25.22 144.68,25.22 143.71,26.19 140.24,26.19 138.35,28.08 138.35,29.73 137.41,30.67 137.41,32.79 v1(137.23,32.97)
  BOTTOM w0.076: U0400.D19 125.65,43.36 126.19,43.36 126.39,43.27 126.51,43.23 126.77,43.23 126.86,43.27 127.07,43.27 127.1,43.25 127.17,43.22 127.54,43.22 127.79,43.47 128.05,43.47 128.16,43.58 129.1,43.58 129.11,43.57 129.15,43.57 129.17,43.54 129.18,43.54
  BOTTOM w0.102: 129.18,43.54 130.56,43.54 130.86,43.84 131.29,43.84 131.62,44.17 132.18,44.17 132.46,44.45 133.15,44.45 133.35,44.25 134.65,44.25 136.37,42.52 136.37,39.04 137.41,37.99 137.41,36.58 ; 137.41,36.58 137.41,33.16 v1(137.23,32.97) ; 137.41,36.58 v2(137.19,36.58) ; C5135.2 191.14,23.04 190.88,23.29 v1(190.88,23.83)
PCIE5_LAN_TXP_C: length 5.4
  BOTTOM w0.102: 193.33,20.97 193.62,20.68 193.62,20.16 193.69,20.09 193.75,20.09 193.82,20.02 CON5104.8 ; 193.33,20.97 192.94,21.36 191.52,21.36 190.93,21.95 190.93,22.05 191.06,22.18 C5135.1 ; 193.33,20.97 v2(193.5,21.14)
PCIE6_WLAN_RXN: length 118.3
  IN1 w0.109: v1(202.36,30.46) 202.16,30.25 202.16,29.97 202.29,29.85 202.54,29.85 202.67,29.72 202.67,29.42 202.54,29.29 202.2,29.29 201.98,29.5 201.47,29.5 201.25,29.29 201.25,29.29 200.6,28.64 200.6,21.58 194.48,15.46 179.28,15.46 178.93,15.81 164.88,15.81 163.35,17.35 158.35,17.35 155.78,19.92 152.73,19.92 149.53,23.12 147.67,23.12 146.75,24.03 144.4,24.03 143.32,25.11 138.32,25.11 136.42,27 136.42,29.26 134.18,31.5 129.5,31.5 128.18,32.83 125.11,32.83 124.18,33.76 121.67,33.76 120.47,34.95 120.47,40.35 120.73,40.6 121.08,40.6 122.84,42.37 122.84,42.49 122.95,42.6 123.11,42.6 123.24,42.73 123.24,42.96 v3(123.03,43.17)
  BOTTOM w0.102: CON5103.18 205.43,31.76 205.36,31.83 205.17,31.83 205.11,31.77 205.11,31.65 205.05,31.6 204.84,31.6 204.31,31.07 202.96,31.07 202.86,30.96 202.64,30.96 202.54,31.07 202.42,31.07 202.24,30.88 202.24,30.58 v1(202.36,30.46) ; U0400.G18 123.24,42.71 123.24,42.95 v3(123.03,43.17)
