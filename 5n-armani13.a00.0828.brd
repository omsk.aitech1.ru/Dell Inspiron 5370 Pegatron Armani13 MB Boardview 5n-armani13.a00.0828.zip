# Allegro board 5n-armani13.a00.0828.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TUSB546_A0: length 8.8
  TOP w0.102: v1(29.62,81.05) 29.21,81.05 28.97,81.3 U5703.11 ; v1(34.06,79.07) 33.93,79.07 33.91,79.1 R5717.2 33.48,79.17 33.78,79.48 34.34,79.48 34.65,79.17 R5720.1
  BOTTOM w0.102: v1(34.06,79.07) 34.06,79.35 32.36,81.05 v2(30.25,81.05) v1(29.62,81.05)
TUSB546_A1: length 8.7
  TOP w0.102: R5716.1 34.65,79.99 34.34,79.68 33.78,79.68 33.48,79.99 R5718.2 v1(34.06,80.11) ; U5703.14 29.55,82.5 v1(29.67,82.37)
  BOTTOM w0.102: v1(29.67,82.37) 30.4,81.64 v2(32.03,81.64) 32.06,81.64 33.59,80.11 v1(34.06,80.11)
TUSB546_DPEQ1: length 7.4
  TOP w0.102: v2(21.59,75.77) 22.17,75.77 22.34,75.94 R5705.2 22.34,76.85 22.22,76.97 R5704.1 23.43,77.28 23.69,77.54 23.69,78.12 23.81,78.25 24.69,78.25 25.71,79.27 U5703.2
TUSB546_EQ0: length 8.2
  TOP w0.102: v1(23.97,81.13) 24.14,81.3 U5703.38
  BOTTOM w0.102: R5700.1 R5702.2 21.95,77.52 22.12,77.35 23.4,77.35 v2(24.15,78.1) 24.56,78.51 24.56,80.54 v1(23.97,81.13)
TUSB546_EQ1: length 7.1
  TOP w0.102: U5703.35 24.28,82.5 24.18,82.4 v1(23.98,82.4)
  BOTTOM w0.102: v1(23.98,82.4) 23.98,81.71 23.57,81.3 23.57,80.73 v2(23.9,80.39) 23.9,79.83 23.72,79.66 22.1,79.66 21.95,79.5 R5703.2 R5701.1
TUSB546_SSEQ1: length 5.4
  TOP w0.102: v2(24.44,76.23) 24.64,76.43 24.64,77.24 24.51,77.37 24.28,77.37 24.16,77.5 R5707.2 R5706.1 25.1,78.36 26.11,79.38 U5703.3
TX1N_P1: length 3.4
  TOP w0.102: L5704.4 17.07,83.06 16.86,82.86 14.97,82.86 14.85,82.98 14.85,83.2 C5720.2
TX1N_P1_C: length 7.8
  TOP w0.102: C5720.1 14.02,83.44 13.88,83.31 U5700.6 U5700.5 11.26,83.31 10.49,84.08 v5(10.49,84.48)
  BOTTOM w0.102: v5(10.49,84.48) 10.49,84.66 10.34,84.81 8.38,84.81 7.94,85.25 CON5700.A3
TX1N_P1_MUX: length 6.1
  TOP w0.102: L5704.3 19.59,83.06 19.66,83.14 20.33,83.14 20.45,83.26 20.66,83.26 21.08,82.83 24.44,82.83 24.5,82.9 U5703.34
TX1P_P1: length 3.4
  TOP w0.102: L5704.1 17.04,83.62 16.69,83.26 15.8,83.26 15.52,83.54 15.52,83.97 15.09,84.41 C5719.2
TX1P_P1_C: length 7.7
  TOP w0.102: v1(11.1,84.1) 11.49,83.71 11.83,83.71 11.92,83.81 U5700.4 U5700.7 13.15,83.81 13.24,83.71 13.72,83.71 14.22,84.22 C5719.1
  BOTTOM w0.102: v1(11.1,84.1) 10.99,84.22 10.81,84.22 10.67,84.08 10.32,84.08 9.99,84.41 8.21,84.41 7.87,84.75 CON5700.A2
TX1P_P1_MUX: length 6.1
  TOP w0.102: L5704.2 19.61,83.62 19.69,83.54 20.16,83.54 20.29,83.67 20.82,83.67 21.25,83.24 24.27,83.24 24.32,83.3 U5703.33
TX2N_P1: length 6.5
  TOP w0.102: C5722.2 15.49,82.4 15.75,82.15 17.26,82.15 17.62,81.79 18.82,81.79 19.26,81.36 20.31,81.36 20.69,81.74 L5705.1
TX2N_P1_C: length 17.7
  TOP w0.102: v1(11.46,82.08) 11.76,81.77 U5701.6 U5701.5 13.2,81.77 13.45,82.02 13.51,82.02 13.89,82.4 C5722.1
  IN1 w0.097: v1(11.46,82.08) 11.46,82.43 11.58,82.55 11.76,82.55 11.91,82.4 11.91,81.97 12.06,81.82 12.3,81.82 12.48,82 12.48,85.42 11.23,86.67 11.23,87.68 9.78,89.13 7.94,89.13 7.69,88.88 5.87,88.88 CON5700.B3
TX2N_P1_MUX: length 2.6
  TOP w0.102: U5703.36 24.36,82.1 24.23,81.97 23.58,81.97 23.23,81.61 22.98,81.61 22.86,81.74 L5705.2
TX2P_P1: length 6.5
  TOP w0.102: C5721.2 15.44,81.41 15.77,81.74 17.09,81.74 17.45,81.38 18.66,81.38 19.09,80.95 20.48,80.95 20.71,81.19 L5705.4
TX2P_P1_C: length 17.9
  TOP w0.102: C5721.1 13.92,81.41 13.72,81.61 13.61,81.61 13.28,81.27 U5701.4 U5701.7 11.65,81.27 v1(11.46,81.47)
  IN1 w0.097: CON5700.B2 5.95,89.23 7.54,89.23 7.79,89.48 9.92,89.48 11.58,87.83 11.58,86.81 12.83,85.56 12.83,81.85 12.45,81.47 v1(11.46,81.47)
TX2P_P1_MUX: length 2.5
  TOP w0.102: U5703.37 24.47,81.7 24.33,81.56 23.75,81.56 23.37,81.19 L5705.3
TYPEC_SMBCLK: length 76.8
  TOP w0.102: R1916.2 43.83,22.23 v1(43.43,21.82) ; v1(77.8,17.93) 77.11,18.62 77.11,21.16 76.81,21.47 v2(76.15,21.47) R1918.2 75.13,22.02 74.93,22.23 C1906.1 ; v1(37.67,30.18) 37.87,30.18 38.9,29.15 U2300.91
  IN1 w0.097: v1(37.67,30.18) 37.26,29.77 37.26,29.38 37.74,28.9 40.09,28.9 40.52,28.47 40.52,28.33 39.72,27.54 39.72,27.4 40,27.13 40.13,27.13 40.93,27.92 41.07,27.92 41.34,27.65 41.34,27.51 40.54,26.72 40.54,26.58 40.82,26.31 40.95,26.31 41.62,26.98 41.76,26.98 42.3,26.44 42.3,24.9 42.39,24.81 44.1,24.81 44.2,24.71 44.2,24.32 44.1,24.23 42.39,24.23 42.3,24.13 42.3,23.65 42.39,23.56 44.75,23.56 44.85,23.46 44.85,23.07 44.75,22.98 42.39,22.98 42.3,22.88 42.3,22.5 42.39,22.4 43.33,22.4 43.43,22.3 v1(43.43,21.82) 43.89,21.36 44.53,21.36 45.36,20.53 45.76,20.53 48.98,17.31 57.37,17.31 60.07,14.61 71.65,14.61 72.01,14.96 72.58,14.96 73.87,16.26 76.31,16.26 76.71,16.65 76.71,16.84 v1(77.8,17.93)
  BOTTOM w0.102: v1(77.8,17.93) 77.57,17.93 77.28,17.65 Q1901.6
TYPEC_SMBDA: length 57.9
  TOP w0.102: U2300.89 38.1,29.11 v1(37.67,29.54) ; v1(76.17,16.69) 76.17,16.97 75.84,17.3 75.72,17.3 75.39,16.97 75.39,16.65 75.27,16.54 R1914.2 74.45,16.54 74.24,16.74 C1905.1 v2(72.85,17.71)
  IN1 w0.097: v1(76.17,16.69) 76.12,16.74 73.68,16.74 72.38,15.44 71.75,15.44 71.4,15.09 60.26,15.09 57.56,17.79 49.26,17.79 46.48,20.56 46.48,23.12 44.3,25.3 43.43,25.3 42.82,25.91 42.82,26.7 41.88,27.64 41.88,28.42 40.76,29.54 v1(37.67,29.54)
  BOTTOM w0.102: Q1901.3 78.99,16.35 78.55,15.9 76.38,15.9 76.17,16.11 v1(76.17,16.69)
UART1_CTS#: length 7
  TOP w0.102: T1505.1 115.66,30.24 115.66,33.04 115.31,33.39 115.31,35.03 v3(115.58,35.3)
  BOTTOM w0.102: U0400.AB4 115.83,35.05 v3(115.58,35.3)
UART1_RTS#: length 6.9
  BOTTOM w0.076: 115.56,32.14 115.56,32.79 115.6,32.92 115.6,33.14 115.56,33.26 115.56,33.94 U0400.AC3
  BOTTOM w0.102: T1506.1 117.05,28.47 116.76,28.75 116.76,28.81 116.56,29.01 116.56,29.39 115.9,30.05 115.9,31.8 115.56,32.14
UART_2_CRXD_DTXD: length 8.1
  BOTTOM w0.102: U0400.AD1 114.58,32.63 114.58,31.11 114.33,30.86 114.33,30.31 113.82,29.81 113.82,29.44 113.87,29.39 R1513.2 113.41,28.5 113.41,27.85 113.13,27.57 113.13,27.26 112.17,26.29 T1502.1
UART_2_CTXD_DRXD: length 4.9
  BOTTOM w0.076: 114.77,32.53 114.8,32.55 114.8,32.75 114.73,32.89 114.73,33.31 114.69,33.36 U0400.AD2
  BOTTOM w0.102: 114.77,32.53 114.77,31.64 114.81,31.6 T1503.1 115.11,30.36 115.11,29.29 R1514.2
USB2_COMP: length 12
  IN3 w0.127: v1(113.61,27.47) 113.59,27.49 113.59,32.64 114.63,33.67 114.63,33.68 115.14,34.19 115.14,35.42 v3(115.58,35.87)
  BOTTOM w0.102: v1(113.61,27.47) 113.7,27.38 114.2,27.38 114.33,27.26 R1400.1 113.54,26.93 v2(113.44,26.82) ; U0400.AB6 115.68,35.87 v3(115.58,35.87)
USB3_RX_N1: length 106.2
  IN1 w0.109: v3(122.3,36.78) 122.67,37.16 122.67,37.54 123.35,38.21 125.33,38.21 126.72,39.6 130.4,39.6 131.13,38.87 131.82,38.87 132.78,39.84 135.73,39.84 143.66,31.91 143.66,31.26 144.65,30.28 147.52,30.28 148.56,29.24 159.03,29.24 161.37,26.9 161.37,25.1 162.3,24.17 163.04,24.17 166.32,20.89 184.16,20.89 184.79,21.52 184.79,26.11 191.78,33.09 199.25,33.09 200.07,33.9 200.07,35.52 202.13,37.58 203.77,37.58 v1(203.91,37.72)
  BOTTOM w0.089: v3(122.3,36.78) 122.3,36.87 U0400.H8
  BOTTOM w0.102: v1(203.91,37.72) 204.23,37.72 204.27,37.76 CON5103.30
USB3_RX_N3: length 190.7
  TOP w0.102: v5(26.19,76.15) 26.36,76.32 26.36,76.72 26.09,76.99 C5708.1
  IN3 w0.127: v5(26.19,76.15) 26.44,76.41 26.44,76.95 26.25,77.14 25.43,77.14 25.02,76.74 25.02,76.1 25.78,75.34 25.78,73.69 23.49,71.41 22.59,71.41 21.2,70.02 21.2,68.71 21.41,68.5 21.41,59.39 26.24,54.56 26.24,45.21 27.52,43.93 27.52,33.85 27.81,33.56 27.81,29.1 28.42,28.49 28.42,26.27 28.58,26.11 31.29,26.11 33.69,23.71 33.69,21.07 34.59,20.17 37.04,20.17 39.61,17.6 43.31,17.6 43.64,17.93 46.45,17.93 48.5,15.88 48.5,12.91 51.42,9.99 54.38,9.99 54.78,9.59 60.89,9.59 61.87,10.57 66.8,10.57 67.38,9.99 67.95,9.99 68.24,10.28 70.83,10.28 71.01,10.1 75.25,10.1 76.03,10.89 76.57,10.89 78.05,12.36 78.05,13.47 78.6,14.02 83.57,14.02 84.35,13.24 91.36,13.24 91.64,12.96 94.04,12.96 95.22,14.14 95.22,14.37 96.72,15.87 105.42,15.87 106.99,17.43 108.24,17.43 108.48,17.19 115.62,17.19 116.29,17.87 117.56,17.87 119.25,19.56 119.25,22.12 121.26,24.13 121.26,27.65 123.17,29.57 123.17,31.47 121.82,32.83 121.82,33.28 122.45,33.91 122.45,34.89 121.31,36.03 121.31,37.18 121.82,37.69 121.82,37.98 v3(122.35,38.51)
  BOTTOM w0.102: v3(122.35,38.51) 122.28,38.44 122.28,38.41 U0400.J10
USB3_RX_N3_C: length 2.3
  TOP w0.102: C5708.2 26.11,77.85 26.4,78.15 26.4,78.92 26.59,79.11 26.59,79.38 26.51,79.46 U5703.4
USB3_RX_N4: length 102.1
  IN1 w0.109: v1(203.33,35.03) 203.38,35.03 203.55,34.86 203.55,34.33 203.42,34.2 202.13,34.2 199.73,31.79 192.25,31.79 186.04,25.59 186.04,21 184.66,19.62 165.81,19.62 162.54,22.89 161.81,22.89 161.09,23.61 158.98,23.61 154.97,27.62 145.52,27.62 138.58,34.56 135.94,34.56 135.21,33.84 132.65,33.84 129.56,36.92 129.56,37.36 128.97,37.95 127.74,37.95 127.14,37.35 125.01,37.35 124.88,37.48 v3(124.88,37.6)
  BOTTOM w0.102: 203.91,35.67 203.8,35.67 203.56,35.43 203.56,35.26 v1(203.33,35.03) ; 203.91,35.67 v2(203.91,35.92) ; 203.91,35.67 204.84,35.67 205.26,35.26 CON5103.25 ; U0400.E10 124.5,38.18 124.5,38.36 124.63,38.49 124.81,38.49 124.88,38.42 v3(124.88,37.6)
USB3_RX_P1: length 106.3
  IN1 w0.109: v5(203.89,37.01) 203.89,37.09 203.61,37.37 202.21,37.37 200.28,35.43 200.28,33.82 199.34,32.88 191.86,32.88 185,26.02 185,21.43 184.25,20.68 166.23,20.68 162.95,23.95 162.21,23.95 161.16,25.01 161.16,26.81 158.94,29.03 148.47,29.03 147.43,30.07 144.56,30.07 143.45,31.18 143.45,31.82 135.64,39.63 132.87,39.63 131.91,38.66 131.05,38.66 130.32,39.39 126.81,39.39 125.42,38 123.44,38 122.89,37.45 122.89,36.83 v3(122.98,36.73)
  BOTTOM w0.089: U0400.G8 122.98,36.91 v3(122.98,36.73)
  BOTTOM w0.102: v5(203.89,37.01) 204.43,37.56 205.3,37.56 205.59,37.26 CON5103.29
USB3_RX_P3: length 190.7
  TOP w0.102: v1(26.87,76.38) 27,76.51 C5707.1
  IN3 w0.127: v3(122.28,37.62) 122.15,37.49 121.95,37.49 121.54,37.09 121.54,36.13 122.68,34.99 122.68,33.82 122.05,33.18 122.05,32.92 123.4,31.57 123.4,29.48 121.49,27.56 121.49,24.03 119.48,22.03 119.48,19.47 117.66,17.64 116.39,17.64 115.71,16.96 108.39,16.96 108.14,17.21 107.08,17.21 105.52,15.64 96.82,15.64 95.45,14.28 95.45,14.05 94.13,12.73 91.54,12.73 91.26,13.01 84.26,13.01 83.47,13.79 78.69,13.79 78.27,13.38 78.27,12.27 76.67,10.66 76.13,10.66 75.34,9.87 70.91,9.87 70.74,10.05 68.33,10.05 68.04,9.76 67.29,9.76 66.71,10.34 61.97,10.34 60.99,9.36 54.68,9.36 54.28,9.76 51.33,9.76 48.27,12.82 48.27,15.79 46.35,17.71 43.73,17.71 43.4,17.38 39.51,17.38 36.95,19.94 34.49,19.94 33.46,20.97 33.46,23.62 31.2,25.89 28.48,25.89 28.19,26.17 28.19,28.39 27.58,29 27.58,33.46 27.29,33.75 27.29,43.84 26.01,45.12 26.01,54.47 21.18,59.3 21.18,68.4 20.97,68.62 20.97,70.11 22.49,71.64 23.4,71.64 25.55,73.79 25.55,75.24 24.79,76.01 24.79,76.83 25.33,77.37 26.34,77.37 26.67,77.04 26.67,76.53 26.82,76.38 v1(26.87,76.38)
  BOTTOM w0.102: v3(122.28,37.62) 122.28,37.76 U0400.H10
USB3_RX_P3_C: length 2.3
  TOP w0.102: C5707.2 26.92,77.85 26.61,78.17 26.61,78.83 26.8,79.02 26.8,79.33 26.91,79.45 U5703.5
USB3_RX_P4: length 101.8
  IN1 w0.109: v3(124.23,37.57) 124.66,37.14 127.23,37.14 127.82,37.74 128.89,37.74 129.35,37.28 129.35,36.84 132.56,33.62 135.3,33.62 136.02,34.35 138.5,34.35 145.43,27.41 154.88,27.41 158.89,23.39 161,23.39 161.72,22.68 162.45,22.68 165.72,19.41 184.74,19.41 186.25,20.92 186.25,25.5 192.33,31.58 199.81,31.58 202.22,33.99 203.51,33.99 203.76,34.24 203.76,34.75 v5(204.04,35.03)
  BOTTOM w0.089: U0400.F10 124.23,37.8 v3(124.23,37.57)
  BOTTOM w0.102: CON5103.24 205.6,34.76 205.32,35.05 205.18,35.05 204.76,35.47 203.89,35.47 203.76,35.34 203.76,35.26 203.99,35.03 v5(204.04,35.03)
USB3_TX_N1: length 103.5
  IN1 w0.109: v1(204.57,36.73) 204.55,36.76 204.22,36.76 204.06,36.6 204.06,36.43 203.94,36.31 201.74,36.31 200.69,35.26 200.69,33.64 199.47,32.42 191.99,32.42 185.42,25.85 185.42,21.26 184.4,20.25 166.07,20.25 162.78,23.53 162.05,23.53 160.73,24.85 160.73,26.44 158.87,28.31 145.72,28.31 138.84,35.19 135.68,35.19 134.97,34.47 132.9,34.47 131.38,35.99 131.38,37.69 130.55,38.52 129.86,38.52 129.68,38.69 128.21,38.69 128.18,38.73 127.95,38.73 v3(127.81,38.86)
  BOTTOM w0.076: U0400.C13 125.84,39.68 125.84,39.58 125.92,39.5 126.11,39.5 126.29,39.68 126.29,39.98 126.33,40.02 126.52,40.09 126.62,40.12 126.73,40.12 126.89,40.06 127.08,40.06 127.2,40.11 127.55,40.11 127.62,40.04 127.62,39.59 128.13,39.08 128.13,38.87 128.05,38.79 127.89,38.79 v3(127.81,38.86)
  BOTTOM w0.102: CON5103.28 205.56,36.76 205.41,36.6 204.7,36.6 204.57,36.73 v1(204.57,36.73)
USB3_TX_N3: length 217.9
  TOP w0.102: C5706.1 31.32,77.73 31.57,77.98 32,77.98 32.08,77.9 32.08,77.45 29.72,75.08 29.72,74.66 29,73.94 24.86,73.94 24.61,73.7 24.61,73.51 24.4,73.3 23.65,73.3 v1(23.55,73.4)
  IN3 w0.127: v1(130.02,40.03) 129.82,39.83 129.82,39.53 128.7,38.41 128.7,38.13 128.07,37.5 128.07,35.25 128.45,34.87 128.45,32.97 129.48,31.94 129.48,30.19 130.45,29.21 130.45,28.65 131.93,27.18 131.93,22.46 131.57,22.1 131.57,21.29 130.51,20.22 130.51,16.21 126.55,12.26 115.15,12.26 114.45,11.56 110.69,11.56 110.17,12.08 105.11,12.08 104.04,11.01 96.99,11.01 95.76,9.78 92.27,9.78 91.22,8.73 86.39,8.73 84.96,7.29 74.86,7.29 73.92,8.24 71.75,8.24 70.82,7.3 70.82,6.7 68.88,4.77 51.25,4.77 49.57,6.44 45.85,6.44 45.69,6.6 44.87,7.42 44.87,8.66 44.44,9.1 42.88,9.1 42.14,9.84 42.14,11.36 32.8,20.7 32.8,22.24 31.49,23.55 28.68,23.55 28.27,23.96 28.27,25.08 26.92,26.43 26.92,33.16 26.63,33.45 26.63,41.6 25.35,42.88 25.35,47.58 22.1,50.83 22.1,55.48 20.4,57.18 20.4,57.92 19.15,59.17 19.15,68.17 20.07,69.09 20.07,71.15 22.32,73.4 v1(23.55,73.4)
  BOTTOM w0.076: U0400.B15 126.86,41.18 127.12,41.45 127.44,41.45
  BOTTOM w0.102: 127.44,41.45 128.87,41.45 129.81,40.51 129.81,40.24 v1(130.02,40.03)
USB3_TX_N3_C: length 4.3
  TOP w0.102: C5706.2 30.45,77.78 29.77,78.46 28.21,78.46 27.71,78.96 U5703.7
USB3_TX_N4: length 106.7
  IN1 w0.109: v1(203.86,33.35) 203.86,33.05 203.71,32.9 203.71,32.69 203.79,32.62 204.11,32.62 204.21,32.52 204.21,32.37 203.98,32.14 203.68,32.14 202.67,33.15 201.98,33.15 198.87,30.04 191.96,30.04 186.66,24.74 186.66,19.43 185.27,18.04 180.36,18.04 179.4,19 165.55,19 162.28,22.26 161.55,22.26 160.83,22.98 158.72,22.98 154.79,26.91 145.35,26.91 138.33,33.93 136.2,33.93 135.44,33.17 130.99,33.17 129.69,34.47 128.85,34.47 128.1,35.22 128.1,36.48 128.42,36.81 v3(128.75,36.81)
  BOTTOM w0.076: 128.73,39.87 128.73,40.25 128.07,40.9 127.22,40.9 127.14,40.94 126.8,40.94 126.75,40.92 126.54,40.92 126.39,40.98 126.29,41.02 126.2,41.05 126.13,41.05 U0400.C15
  BOTTOM w0.102: v3(128.75,36.81) 128.75,37.01 129.02,37.28 129.02,39.57 128.73,39.87 ; CON5103.23 205.6,34.26 205.46,34.11 204.59,34.11 204.24,33.77 204.24,33.48 204.11,33.35 v1(203.86,33.35)
USB3_TX_P1: length 103.4
  IN1 w0.109: v1(204.52,36.1) 201.83,36.1 200.9,35.17 200.9,33.56 199.55,32.21 192.07,32.21 185.63,25.76 185.63,21.17 184.49,20.03 165.98,20.03 162.69,23.32 161.96,23.32 160.52,24.76 160.52,26.36 158.78,28.09 145.63,28.09 138.75,34.98 135.77,34.98 135.05,34.26 132.81,34.26 131.17,35.9 131.17,37.6 130.46,38.31 129.77,38.31 129.59,38.48 128.16,38.48 v3(128.02,38.34)
  BOTTOM w0.076: v3(128.02,38.34) 128.02,38.36 128.3,38.64 128.3,39.17 127.79,39.68 127.79,40.11 127.61,40.28 127.17,40.28 127.04,40.22 126.92,40.22 126.76,40.29 126.59,40.29 126.52,40.26 126.39,40.22 126.15,40.13 125.83,40.13 125.53,39.83 U0400.D13
  BOTTOM w0.102: CON5103.27 205.58,36.26 205.44,36.4 204.82,36.4 v1(204.52,36.1)
USB3_TX_P3: length 217.8
  TOP w0.102: C5705.1 31.34,78.31 31.47,78.18 32.08,78.18 32.28,77.98 32.28,77.36 29.92,75 29.92,74.58 29.08,73.74 28.91,73.74 28.91,73.74 24.94,73.74 24.82,73.61 24.82,73.43 24.48,73.09 23.88,73.09 v1(23.55,72.76)
  IN3 w0.127: v1(129.4,40.03) 129.59,39.84 129.59,39.63 128.47,38.51 128.47,38.23 127.84,37.59 127.84,35.16 128.22,34.78 128.22,32.88 129.25,31.85 129.25,30.1 130.23,29.12 130.23,28.56 131.7,27.09 131.7,22.55 131.34,22.2 131.34,21.38 130.28,20.32 130.28,16.31 126.45,12.49 115.06,12.49 114.36,11.79 110.79,11.79 110.27,12.31 105.01,12.31 103.94,11.24 96.9,11.24 95.66,10.01 92.18,10.01 91.12,8.96 86.3,8.96 84.86,7.52 74.96,7.52 74.01,8.47 71.66,8.47 70.59,7.4 70.59,6.79 68.79,4.99 51.35,4.99 49.67,6.67 45.94,6.67 45.1,7.51 45.1,8.76 44.53,9.32 42.98,9.32 42.37,9.93 42.37,11.46 33.03,20.79 33.03,22.33 31.59,23.78 28.78,23.78 28.5,24.06 28.5,25.17 27.15,26.52 27.15,33.25 26.86,33.54 26.86,41.7 25.58,42.98 25.58,47.68 22.33,50.93 22.33,55.58 20.63,57.28 20.63,58.02 19.37,59.27 19.37,68.08 20.29,69 20.29,71.05 22.41,73.17 22.89,73.17 23.06,72.99 23.06,72.39 23.19,72.27 23.42,72.27 23.55,72.39 v1(23.55,72.76)
  BOTTOM w0.102: U0400.A15 127.36,41.25 128.78,41.25 129.61,40.42 129.61,40.24 v1(129.4,40.03)
USB3_TX_P3_C: length 4.3
  TOP w0.102: C5705.2 30.48,78.51 30.35,78.39 30.13,78.39 29.85,78.67 29.1,78.67 29,78.77 29,78.84 28.9,78.95 28.7,78.95 28.6,78.84 28.6,78.77 28.49,78.67 28.29,78.67 27.92,79.04 27.92,79.42 28.11,79.62 U5703.8
USB3_TX_P4: length 106.7
  IN1 w0.109: v5(204.55,33.12) 204.42,33 204.42,32.28 204.07,31.93 203.59,31.93 202.58,32.94 202.07,32.94 198.96,29.83 192.05,29.83 186.88,24.66 186.88,19.34 185.36,17.83 180.27,17.83 179.31,18.79 165.46,18.79 162.19,22.05 161.46,22.05 160.74,22.77 158.63,22.77 154.71,26.7 145.26,26.7 138.24,33.72 136.28,33.72 135.53,32.96 130.9,32.96 129.61,34.26 128.76,34.26 127.89,35.13 127.89,36.57 128.5,37.18 v3(128.5,37.32)
  BOTTOM w0.076: U0400.D15 125.9,40.88 126.2,40.88 126.23,40.86 126.51,40.75 126.79,40.75 126.84,40.78 127.1,40.78 127.18,40.74 128,40.74 128.56,40.18 128.56,39.95 128.55,39.94 128.55,39.76 128.58,39.72
  BOTTOM w0.102: CON5103.22 205.59,33.76 205.44,33.91 204.67,33.91 204.44,33.68 204.44,33.34 204.55,33.24 v5(204.55,33.12) ; 128.58,39.72 128.82,39.49 128.82,37.44 128.69,37.32 v3(128.5,37.32)
USB_ADT: length 14.3
  TOP w0.432: PR7641.1 28.32,107.62 v1(28.42,107.72) ; PR7645.1 39.22,107.14
  BOTTOM w0.508: v1(39.27,106.3) 39.27,107.22 38.07,108.41 29.11,108.41 v1(28.42,107.72)
  vias: v2(43.36,105.77)
USB_EN#: length 280.7
  TOP w0.102: v1(24.1,52.38) 24.54,51.95 29.16,51.95 29.87,52.66 34.11,52.66 34.24,52.53 v2(34.8,52.53) 36.27,52.53 36.47,52.33 36.47,50.6 35.52,49.65 35.52,47.43 35.76,47.2 36.22,47.2 36.63,46.79 R2326.2 36.63,45.87 v2(37.11,45.39) 37.11,45.14 36.87,44.9 36.21,44.9 36.1,44.78 U2300.13
  IN2 w0.102: v1(24.1,52.38) 24.87,51.62 24.87,40.59 26.26,39.19 26.26,37.49 25.68,36.91 25.44,36.91 24.51,35.98 24.51,32.16 24.18,31.83 24.18,23.28 24.6,22.86 26.19,22.86 27.53,21.52 27.53,20.16 35.68,12.02 37.87,12.02 38.3,11.58 47.46,11.58 50.4,8.64 53.89,8.64 54.45,8.08 60.5,8.08 61.54,7.04 69.98,7.04 71.65,8.71 91.64,8.71 92.94,10.01 97.26,10.01 97.27,10.01 97.85,10.59 103.08,10.59 103.11,10.62 103.11,10.62 104.3,11.81 105.33,11.81 105.96,12.45 108.97,12.45 109.53,11.89 114.71,11.89 115.6,12.78 115.77,12.78 115.77,12.78 123.77,12.78 124.23,12.32 132.4,12.32 135.39,15.32 143.26,15.32 144.17,16.23 154.97,16.23 155.9,15.29 199.18,15.29 206.25,22.36 206.25,38.06 205.41,38.89 v1(203.4,38.89)
  BOTTOM w0.102: U5101.4 201.97,45.69 201.35,45.06 201.35,43.78 201.68,43.45 201.68,39.92 202.71,38.89 v1(203.4,38.89)
USB_OC0#: length 141.2
  TOP w0.102: v1(154.33,12.27) 155.4,13.34 v2(155.75,13.34) 156.39,13.34 156.62,13.57 164.08,13.57 165.32,12.32 171.49,12.32 172.25,13.08 176.31,13.08 177.02,12.37 187.3,12.37 188.34,13.41 198.79,13.41 202.47,17.1 203.63,17.1 203.79,16.94 204.29,16.94 204.9,17.56 204.9,18.9 v1(204.67,19.13)
  IN2 w0.102: v1(204.67,19.13) 204.67,19.55 206.48,21.35 206.48,38.15 205.51,39.12 204.51,39.12 v1(204.33,39.3)
  IN3 w0.102: v1(129.98,37.21) 129.98,36.79 129.16,35.97 129.16,34.55 130.51,33.2 130.51,30.81 131.9,29.42 132.26,29.42 132.54,29.14 132.79,29.14 133.22,28.7 133.22,26.83 133.5,26.55 133.5,23.87 133.07,23.44 133.07,22.51 132.28,21.72 132.28,20.25 131.66,19.62 131.66,12.72 132.87,11.51 138.4,11.51 138.7,11.8 149.06,11.8 150.62,13.36 153.24,13.36 v1(154.33,12.27)
  BOTTOM w0.076: 129.54,36.76 129.36,36.58 129.31,36.58 129.01,36.27 128.37,36.27 127.3,37.35 U0400.A9
  BOTTOM w0.102: CON5103.33 205.6,39.26 205.46,39.12 204.51,39.12 v1(204.33,39.3) ; R1402.2 132.21,40.95 132.21,40.3 132.21,40.3 132.21,40.13 132.21,40.12 132.21,40.11 130.48,38.38 130.48,37.72 v1(129.98,37.21) 129.98,37.19 129.54,36.76
USB_OC1#: length 373.7
  TOP w0.102: v1(202.96,39.31) 203.56,39.31 203.98,38.89 205.26,38.89 206.02,39.65 212.84,39.65 213.64,38.85 213.64,35.66 v1(213.21,35.23) ; v1(18.82,87.15) 18.36,86.69 v2(17.3,86.69)
  IN1 w0.102: v1(213.21,35.23) 212.8,34.83 212.8,34.45 216.64,30.62 216.64,28.76 215.28,27.41 215.28,23.41 213.89,22.02 210.33,22.02 202.87,14.56 v1(202.87,12.07)
  IN2 w0.102: v1(120.5,10.52) 120.89,10.91 123.06,10.91 123.57,10.39 137.8,10.39 138.81,11.41 142.91,11.41 143.24,11.08 147.19,11.08 147.39,10.87 149.83,10.87 150.18,11.23 152.08,11.23 152.58,11.73 152.58,12.29 154.06,13.77 164.73,13.77 166.29,12.21 172.02,12.21 172.64,12.83 179.26,12.83 179.62,12.47 202.46,12.47 v1(202.87,12.07) ; v1(18.82,87.15) 19.56,86.41 20.22,86.41 20.63,86.01 20.63,79.24 18.72,77.34 18.72,55.25 17.84,54.37 17.84,45.76 18.47,45.13 18.47,40.19 21.16,37.49 21.16,21.59 36.04,6.71 46.86,6.71 v1(48.03,5.54)
  IN3 w0.102: v1(130.04,37.85) 129.54,37.35 129.54,36.71 128.96,36.12 128.96,34.44 130.3,33.1 130.3,30.89 130.3,30.72 131.81,29.21 132.16,29.21 132.44,28.93 132.71,28.93 133.02,28.62 133.02,26.75 133.3,26.47 133.3,23.96 132.84,23.5 132.84,22.66 132.08,21.9 132.08,20.37 131.24,19.54 131.24,16.25 126.07,11.08 121.06,11.08 v1(120.5,10.52) 119.99,11.03 110.48,11.03 109.92,11.58 108.01,11.58 107.34,10.91 104.64,10.91 104.24,10.52 97.2,10.52 94.12,7.44 90.75,7.44 87.38,4.07 49.5,4.07 v1(48.03,5.54)
  BOTTOM w0.076: U0400.C9 126.26,37.62 127.45,37.62 127.61,37.46 127.61,37.28 128.45,36.44 128.92,36.44 129.24,36.76 129.26,36.76 129.37,36.87 129.37,37.19
  BOTTOM w0.102: v1(18.82,87.15) 17.96,88.01 17.27,88.01 16.97,88.32 16.97,88.7 17.18,88.91 U5900.10 ; R1403.2 132,41.68 132,40.21 ; U5101.3 201.97,39.91 202.58,39.31 v1(202.96,39.31) ; 130.61,38.81 130.04,38.25 v1(130.04,37.85) 130.04,37.85 129.37,37.19
  BOTTOM w0.108: 130.61,38.81 132,40.21
USB_OC2#: length 14.2
  BOTTOM w0.076: U0400.D9 125.85,37.06 126.15,37.06 126.18,37.08 126.91,37.08 127.15,36.85 127.33,36.85 128.24,35.94 129.18,35.94 129.44,36.2 129.54,36.2
  BOTTOM w0.102: R1404.2 135.31,41.46 135.18,41.33 135.03,41.33 v2(133.86,40.16) 133.6,39.91 132.6,39.91 131.17,38.48 131.17,36.58 130.79,36.2 129.54,36.2
USB_OC3#: length 11.6
  BOTTOM w0.076: 129.54,36.4 129.39,36.4 129.1,36.11 128.3,36.11 127.4,37.01 127.22,37.01 126.87,37.36 U0400.B9
  BOTTOM w0.102: 129.54,36.4 130.15,36.4 v2(130.55,36.8) 130.84,37.09 130.84,38.43 133.07,40.67 133.66,40.67 134.37,41.38 R1405.2
USB_POWERSHARE_VBUS_EN: length 226.4
  TOP w0.102: U2300.71 30.9,29.02 30.73,29.19 30.73,30.13 30.97,30.37 31.34,30.37 31.58,30.61 31.58,30.95 31.34,31.18 30.37,31.18 28.23,29.05 28.23,28.93 26.31,27.02 v2(26.31,26.72) 26.31,26.01 26.16,25.86 v1(26.16,25.48)
  IN2 w0.102: v1(26.16,25.48) 26.16,24.04 28.22,21.98 28.22,20.45 29.46,19.2 31,19.2 37.04,13.16 38.42,13.16 39.2,12.37 47.64,12.37 49.91,10.1 59.92,10.1 61.55,8.48 70.45,8.48 71.37,9.4 91.23,9.4 92.52,10.7 96.98,10.7 97.57,11.28 102.8,11.28 104.02,12.5 104.67,12.5 105.89,13.72 108.69,13.72 109.63,12.78 110.36,12.78 110.87,13.29 111.56,13.29 112.17,12.68 114.43,12.68 115.24,13.49 124.57,13.49 124.7,13.62 126.37,13.62 126.85,13.13 132.22,13.13 135.1,16.02 142.97,16.02 143.86,16.92 155.25,16.92 156.19,15.98 198.9,15.98 205.56,22.65 205.56,37.37 205.21,37.72 205.08,37.72 v1(204.55,38.25)
  BOTTOM w0.102: v1(204.55,38.25) 205.05,38.76 CON5103.32
USB_PWR_SHR_EN_L#: length 246
  TOP w0.102: R2324.2 R2325.1 47.32,38.43 46.94,38.81 46.12,38.81 45.95,38.65 44.16,38.65 43.81,38.3 U2300.118 41.13,38.3 41.05,38.38 38.85,38.38 38.61,38.14 38.61,34.45 37.92,33.75 36.8,33.75 36.29,34.27 33.16,34.27 27.75,28.86 27.54,28.86 v2(27.18,28.5) 27.18,28.25 25.78,26.85 v1(25.78,26.09)
  IN2 w0.102: v1(25.78,26.09) 25.76,26.06 25.76,24.12 27.99,21.89 27.99,20.35 29.37,18.98 30.9,18.98 36.95,12.93 38.32,12.93 39.19,12.07 47.62,12.07 49.82,9.87 59.83,9.87 61.45,8.25 70.54,8.25 71.46,9.17 91.36,9.17 92.66,10.47 97.08,10.47 97.66,11.05 102.9,11.05 102.97,11.13 104.11,12.27 104.77,12.27 105.98,13.49 108.59,13.49 109.64,12.45 110.36,12.45 110.97,13.06 111.46,13.06 112.17,12.35 114.52,12.35 115.41,13.24 115.58,13.24 115.58,13.24 124.03,13.24 124.48,12.78 132.21,12.78 135.2,15.78 143.05,15.78 143.96,16.69 155.16,16.69 156.09,15.75 198.99,15.75 205.79,22.55 205.79,37.62 v1(205.16,38.25)
  BOTTOM w0.102: v1(205.16,38.25) 205.16,38.26 CON5103.31
USBN1: length 113.2
  IN1 w0.109: v5(203.89,25.53) 203.89,25.57 203.95,25.63 203.95,25.81 203.64,26.11 203.2,26.11 202.64,25.55 202.64,22.3 194.89,14.55 178.91,14.55 178.55,14.9 164.5,14.9 162.97,16.43 157.21,16.43 156.14,17.5 149.41,17.5 148.22,18.69 136.39,18.69 135.63,19.45 132.9,19.45 130.2,22.15 130.2,22.98 129.9,23.27 128.19,24.99 122.36,24.99 118.79,28.57 116.78,28.57 116.13,29.22 116.13,32.19 115.7,32.63 115.7,34.86 115.98,35.14 115.98,36.88 115.86,37.01 v3(115.58,37.01)
  BOTTOM w0.089: U0400.AB9 115.88,37.39 115.58,37.08 v3(115.58,37.01)
  BOTTOM w0.102: CON5103.4 205.57,24.76 205.44,24.89 204.32,24.89 203.89,25.33 v5(203.89,25.53)
USBN3_TYPEC: length 167.2
  IN1 w0.109: v1(111.32,29.32) 111.16,29.48 110.78,29.48 109.82,30.45 109.82,31.21 109.22,31.81 109.22,32.72 108.26,33.68 105.02,33.68 104.04,32.7 104.04,32.36 103.48,31.8 101.73,31.8 100.71,30.79 94.79,30.79 94.71,30.87 88.87,30.87 87.23,29.23 86.36,29.23 85.29,28.16 84.19,28.16 78.61,22.58 76.77,22.58 76.08,21.89 72.47,21.89 72.23,22.14 67.88,22.14 67.6,21.86 65.01,21.86 64.55,22.33 60.38,22.33 59.37,23.34 54.83,23.34 53.7,24.46 52.84,24.46 51.86,25.44 51.86,25.72 51.14,26.44 50.71,26.44 49.24,27.91 49.24,31.61 48.18,32.68 48.18,33.67 46.6,35.25 46.6,41.5 46.09,42 46.09,45.56 44.41,47.24 43.19,47.24 42.04,48.39 42.04,56.48 43.51,57.95 43.51,65.51 42.14,66.88 34.47,66.88 32.39,68.96 26.96,68.96 23.81,72.11 18.34,72.11 18.07,72.11 15.45,74.73 14.65,75.53 14.65,76.9 14.19,77.35 14.19,78.27 15.23,79.31 15.23,83.88 15.75,84.41 16.17,84.41 16.42,84.16 16.42,84.03 v1(16.65,83.8)
  BOTTOM w0.076: U0400.AH3 112.3,34.12 112.3,33.92 112.25,33.78 112.25,33.58 112.27,33.53 112.28,33.5 112.28,33.24 112.25,33.11 112.25,32.93 112.27,32.88 112.3,32.83 112.3,32.55 112.32,32.53
  BOTTOM w0.102: U5702.2 17.28,82.17 16.84,82.6 16.66,82.6 16.51,82.76 16.51,83.51 16.65,83.65 v1(16.65,83.8) ; 111.96,30.53 111.96,29.79 111.71,29.55 111.55,29.55 v1(111.32,29.32) ; 111.96,30.53 111.96,31.02 112.32,31.38 112.32,32.53 ; 111.96,30.53 v2(112.19,30.53)
USBN4: length 113.8
  IN1 w0.109: v5(204.44,23.57) 204.44,23.45 204.2,23.21 204.2,22.27 195.7,13.77 182.75,13.77 182.36,13.38 179.02,13.38 178.2,14.2 164.21,14.2 162.68,15.73 156.92,15.73 155.89,16.77 149.05,16.77 147.83,17.99 133.33,17.99 129.5,21.82 129.5,22.69 129.22,22.96 127.92,24.26 123.9,24.26 123.55,23.91 121.82,23.91 120.96,24.77 120.96,25.38 118.48,27.86 116.47,27.86 115.36,28.97 115.36,31.96 114.96,32.36 114.96,37.25 v3(114.52,37.7)
  BOTTOM w0.102: U0400.AD9 115.05,37.66 114.98,37.73 114.92,37.73 114.81,37.84 114.66,37.84 v3(114.52,37.7) ; v5(204.44,23.57) 204.34,23.57 204.27,23.65 204.27,23.85 204.42,24.01 205.36,24.01 205.61,23.76 CON5103.2
USBN5_CAM: length 155.3
  IN1 w0.109: v1(44.78,88.22) 45.06,87.93 45.06,78.1 45.65,77.51 45.65,73.94 45.03,73.32 45.03,72.21 44.42,71.59 44.42,70.65 44.68,70.39 44.68,69.01 44.21,68.54 44.21,57.66 42.74,56.19 42.74,48.89 43.64,47.98 44.96,47.98 48.71,44.24 48.71,34.13 48.92,33.92 48.92,33.16 50.03,32.05 50.03,28.13 50.81,27.35 51.32,27.35 52.22,26.46 53.87,26.46 54.31,26.02 54.31,24.89 55.15,24.05 59.68,24.05 60.69,23.04 64.85,23.04 65.32,22.58 67.2,22.58 67.47,22.84 72.51,22.84 72.76,22.59 75.79,22.59 76.48,23.28 78.32,23.28 83.91,28.87 85.01,28.87 86.06,29.93 86.24,29.93 88.23,31.92 100.83,31.92 101.42,32.51 102.69,32.51 105.16,34.98 108.86,34.98 110.03,33.82 110.03,32.07 110.76,31.34 111.16,31.34 v3(111.33,31.17)
  BOTTOM w0.102: v3(111.33,31.17) 111.85,31.69 111.85,32.55 U0400.AJ1 ; 44.17,88.88 44.17,89.74 46.28,91.85 46.28,93.19 50.02,96.93 51.21,96.93 51.56,97.28 51.56,98.38 51.81,98.63 52.05,98.63 52.22,98.8 L3000.2 ; 44.17,88.88 v2(43.94,88.88) ; 44.17,88.88 44.17,88.68 44.39,88.46 44.54,88.46 v1(44.78,88.22)
USBN6_SD: length 123
  IN1 w0.109: v1(203.33,26.95) 203.8,27.43 204.15,27.43 204.43,27.71 205.11,27.71 205.61,27.21 205.61,22.98 195.73,13.11 187.03,13.11 186.36,12.44 182.5,12.44 182.05,12.89 177.7,12.89 177.22,13.38 164.34,13.38 162.47,15.24 156.72,15.24 155.7,16.26 148.72,16.26 147.73,17.25 143.43,17.25 143.15,16.97 140.36,16.97 139.83,17.5 133.09,17.5 129.01,21.58 129.01,21.72 128.37,22.35 127.25,22.35 126.62,22.99 124.13,22.99 123.7,23.42 121.59,23.42 121.3,23.71 119.16,23.71 118.82,24.05 117.67,24.05 115.92,25.8 115.92,26.37 115.39,26.9 115.39,28.25 114.86,28.78 114.86,31.67 114.18,32.35 114.18,35.77 114.31,35.89 114.41,35.89 v3(114.57,35.73)
  BOTTOM w0.102: U0400.AF6 113.98,35.65 114.22,35.89 114.41,35.89 v3(114.57,35.73) ; 203.78,27.1 203.78,26.93 203.66,26.8 203.48,26.8 v1(203.33,26.95) ; 203.78,27.1 v2(204.01,27.1) ; 203.78,27.1 203.78,27.38 204.17,27.76 204.89,27.76 205.08,27.58 205.08,27.43 205.26,27.26 CON5103.9
USBN7_BT: length 131.9
  IN1 w0.109: v3(112.91,31.72) 112.79,31.72 112.65,31.57 112.42,31.57 112.29,31.7 112.29,31.92 112.18,32.02 112.07,32.02 111.94,31.9 111.94,29.72 113.18,28.48 113.18,27.13 114.52,25.79 114.52,25.22 115.06,24.69 115.06,24.06 116.47,22.65 118.24,22.65 118.58,22.31 120.64,22.31 121.08,21.87 121.3,21.87 122.51,20.66 127.47,20.66 132.04,16.09 139.26,16.09 139.78,15.57 143.43,15.57 144.03,14.97 146.37,14.97 146.68,14.67 149.8,14.67 150.62,13.84 161.87,13.84 163.74,11.98 176.64,11.98 177.12,11.49 181.47,11.49 181.92,11.04 195.64,11.04 207.04,22.43 207.04,30.97 206.6,31.4 204.74,31.4 204.5,31.16 204.5,30.69 204.63,30.56 205.31,30.56 205.47,30.4 205.47,30.19 205.35,30.06 204.6,30.06 204.47,29.94 v5(204.47,29.57)
  BOTTOM w0.102: CON5103.14 205.61,29.76 205.32,30.06 205.14,30.06 204.89,30.3 204.53,30.3 204.16,29.94 204.16,29.76 204.35,29.57 v5(204.47,29.57) ; v3(112.91,31.72) 112.76,31.56 112.59,31.56 112.51,31.63 U0400.AH1
USBN9_FP: length 123.1
  IN1 w0.109: v3(112.91,31.16) 113.15,31.16 113.65,31.66 113.87,31.66 114.05,31.48 114.05,30.92 113.89,30.76 113.49,30.76 113.37,30.65 113.37,30.22 113.65,29.94 113.65,29 114.27,28.38 114.27,27.03 115.22,26.08 115.22,25.51 115.76,24.98 115.76,24.38 116.78,23.35 118.53,23.35 118.87,23.01 120.96,23.01 121.37,22.6 122.91,22.6 123.58,21.93 125.88,21.93 126.27,21.54 127.59,21.54 132.33,16.79 139.55,16.79 140.07,16.27 143.44,16.27 143.72,16.55 147.44,16.55 148.45,15.53 155.44,15.53 156.43,14.54 162.18,14.54 164.05,12.68 176.93,12.68 177.41,12.19 181.76,12.19 182.21,11.74 186.65,11.74 187.32,12.41 196.02,12.41 206.32,22.71 206.32,28.09 205.52,28.9 204.45,28.9 204.33,28.77 204.33,28.6 v1(204.55,28.37)
  BOTTOM w0.102: CON5103.12 205.38,28.76 205.28,28.86 205.28,28.91 205.23,28.96 204.54,28.96 204.3,28.71 204.3,28.49 204.42,28.37 v1(204.55,28.37) ; v3(112.91,31.16) 113.05,31.16 113.31,31.42 113.31,32.57 U0400.AG1
USBP1: length 113.1
  IN1 w0.109: v1(204.57,25.4) 204.57,25.48 204.51,25.54 204.51,25.55 203.73,26.32 203.11,26.32 202.43,25.64 202.43,22.39 194.8,14.76 178.99,14.76 178.64,15.11 164.59,15.11 163.06,16.64 157.3,16.64 156.23,17.71 149.5,17.71 148.31,18.9 136.48,18.9 135.72,19.66 132.99,19.66 130.41,22.24 130.41,23.07 130.11,23.36 128.28,25.2 122.45,25.2 118.88,28.78 116.87,28.78 116.34,29.31 116.34,32.28 115.91,32.72 115.91,34.77 116.19,35.06 116.19,36.99 115.59,37.6 v3(115.57,37.6)
  BOTTOM w0.089: U0400.AB10 115.68,37.6 v3(115.57,37.6)
  BOTTOM w0.102: CON5103.5 205.6,25.26 205.44,25.1 204.72,25.1 204.57,25.25 v1(204.57,25.4)
USBP3_TYPEC: length 167.1
  IN1 w0.109: v1(16.03,83.72) 16.21,83.9 16.21,84.07 16.08,84.2 15.84,84.2 15.44,83.8 15.44,79.23 14.4,78.18 14.4,77.44 14.86,76.98 14.86,75.62 15.66,74.81 18.16,72.32 18.34,72.32 23.9,72.32 27.04,69.17 32.47,69.17 34.56,67.09 42.23,67.09 43.72,65.6 43.72,57.86 42.25,56.39 42.25,48.48 43.28,47.45 44.5,47.45 46.3,45.65 46.3,42.09 46.81,41.58 46.81,35.33 48.39,33.76 48.39,32.77 49.45,31.7 49.45,27.99 50.79,26.65 51.22,26.65 52.07,25.81 52.07,25.53 52.93,24.67 53.79,24.67 54.92,23.55 59.46,23.55 60.46,22.54 64.64,22.54 65.1,22.08 67.51,22.08 67.79,22.35 72.31,22.35 72.56,22.1 75.99,22.1 76.68,22.79 78.53,22.79 84.11,28.37 85.2,28.37 86.27,29.44 87.14,29.44 88.78,31.08 94.8,31.08 94.88,31 100.62,31 101.64,32.01 103.39,32.01 103.83,32.45 103.83,32.79 104.93,33.89 108.34,33.89 109.43,32.8 109.43,31.9 110.03,31.3 110.03,30.53 110.15,30.42 110.3,30.42 110.53,30.65 110.68,30.65 110.81,30.52 110.81,30.37 110.59,30.15 110.59,29.97 110.87,29.69 111.1,29.69 111.23,29.82 111.23,29.87 v1(111.31,29.95)
  BOTTOM w0.076: U0400.AJ3 111.85,34.24 111.98,34.37 112.07,34.37 112.14,34.29 112.14,33.95 112.08,33.82 112.08,33.54 112.12,33.46 112.12,33.27 112.08,33.14 112.08,32.89 112.12,32.81 112.12,32.53
  BOTTOM w0.102: 16.31,83.09 16.31,82.67 16.58,82.4 16.76,82.4 16.88,82.28 U5702.1 ; 16.31,83.09 16.31,83.44 v1(16.03,83.72) ; 16.31,83.09 v2(16.08,83.09) ; v1(111.31,29.95) 111.49,29.77 111.64,29.77 111.75,29.88 111.75,31.1 112.12,31.47 112.12,32.53
USBP4: length 113.9
  IN1 w0.109: v1(203.75,23.54) 203.99,23.31 203.99,22.36 195.61,13.98 182.67,13.98 182.27,13.59 179.1,13.59 178.29,14.41 164.3,14.41 162.77,15.94 157.01,15.94 155.97,16.98 149.14,16.98 147.92,18.2 133.42,18.2 129.71,21.91 129.71,22.78 129.41,23.07 128.01,24.47 123.81,24.47 123.46,24.12 121.91,24.12 121.17,24.86 121.17,25.47 118.57,28.07 116.56,28.07 115.57,29.06 115.57,32.04 115.17,32.44 115.17,37.34 114.9,37.61 114.9,38.06 v3(114.58,38.38)
  BOTTOM w0.089: v3(114.58,38.38) 114.7,38.38 U0400.AD10
  BOTTOM w0.102: v1(203.75,23.54) 204.06,23.85 204.06,24.01 204.27,24.21 205.46,24.21 205.51,24.26 CON5103.3
USBP5+_CAM: length 9.7
  BOTTOM w0.102: L3000.4 54.46,98.25 54.64,98.44 54.79,98.44 54.89,98.33 54.89,97.56 55.6,96.85 56.67,96.85 57.49,97.67 D3002.1 57.18,98.87 57.18,99.66 57.36,99.85 58.75,99.85 58.94,100.04 58.94,100.17 59.08,100.31 CON3000.7
USBP5-_CAM: length 9.9
  BOTTOM w0.102: 56.97,99.49 56.97,98.94 D3001.1 57.25,97.89 57.27,97.89 57.27,97.74 56.58,97.06 55.69,97.06 55.09,97.65 55.09,98.43 54.86,98.66 54.58,98.66 54.44,98.8 L3000.1 ; 56.97,99.49 56.97,99.75 57.28,100.05 58.67,100.05 58.74,100.13 58.74,100.21 58.58,100.37 CON3000.6 ; 56.97,99.49 v2(56.74,99.49)
USBP5_CAM: length 155.2
  IN1 w0.109: v3(111.31,31.73) 111.13,31.55 110.85,31.55 110.24,32.16 110.24,33.9 108.95,35.19 105.07,35.19 102.61,32.73 101.34,32.73 100.74,32.13 88.15,32.13 86.15,30.14 85.98,30.14 84.92,29.09 83.83,29.09 78.24,23.49 76.39,23.49 75.7,22.8 72.85,22.8 72.6,23.05 67.38,23.05 67.11,22.79 65.41,22.79 64.94,23.25 60.77,23.25 59.77,24.26 55.24,24.26 54.52,24.98 54.52,26.1 53.95,26.67 52.3,26.67 51.41,27.56 50.89,27.56 50.24,28.21 50.24,32.13 49.13,33.24 49.13,34.01 48.92,34.22 48.92,44.33 45.05,48.19 43.73,48.19 42.95,48.97 42.95,56.1 44.42,57.57 44.42,68.45 44.89,68.92 44.89,70.48 44.63,70.74 44.63,71.5 45.25,72.12 45.25,73.23 45.86,73.85 45.86,77.6 45.27,78.18 45.27,88.33 v1(44.78,88.83)
  BOTTOM w0.102: v1(44.78,88.83) 44.62,88.67 44.48,88.67 44.37,88.77 44.37,89.66 45.03,90.31 ; L3000.3 52.24,98.25 52.07,98.43 51.89,98.43 51.77,98.3 51.77,97.2 51.29,96.73 50.11,96.73 46.48,93.1 46.48,91.76 45.03,90.31 ; 45.03,90.31 v2(45.2,90.13) ; v3(111.31,31.73) 111.52,31.73 111.65,31.86 111.65,32.47 111.57,32.55 111.57,33.08 U0400.AJ2
USBP6_SD: length 122.9
  IN1 w0.109: v3(114.57,36.29) 114.38,36.1 114.22,36.1 113.97,35.85 113.97,32.26 114.65,31.58 114.65,28.69 115.18,28.16 115.18,26.81 115.71,26.28 115.71,25.72 117.59,23.84 118.73,23.84 119.07,23.5 121.21,23.5 121.5,23.21 123.61,23.21 124.04,22.78 126.53,22.78 127.17,22.14 128.28,22.14 128.8,21.63 128.8,21.49 133,17.29 139.75,17.29 140.27,16.76 143.24,16.76 143.52,17.04 147.64,17.04 148.63,16.05 155.61,16.05 156.63,15.03 162.39,15.03 164.25,13.17 177.13,13.17 177.62,12.68 181.96,12.68 182.41,12.23 186.45,12.23 187.12,12.9 195.82,12.9 205.82,22.9 205.82,27.3 205.2,27.92 204.34,27.92 204.06,27.64 v5(203.33,27.64)
  BOTTOM w0.089: v3(114.57,36.29) 114.37,36.08 U0400.AF7
  BOTTOM w0.102: v5(203.33,27.64) 203.73,27.64 204.06,27.97 204.98,27.97 205.19,27.76 CON5103.10
USBP7_BT: length 132
  IN1 w0.109: v1(203.78,29.39) 204.06,29.67 204.06,30.03 204.29,30.25 204.29,31.24 204.66,31.61 206.69,31.61 207.25,31.05 207.25,22.34 195.73,10.83 181.83,10.83 181.38,11.28 177.04,11.28 176.55,11.77 163.65,11.77 161.79,13.63 150.53,13.63 149.71,14.46 146.59,14.46 146.29,14.76 143.94,14.76 143.35,15.36 139.69,15.36 139.17,15.88 131.96,15.88 127.39,20.45 122.42,20.45 121.21,21.66 120.99,21.66 120.55,22.1 118.49,22.1 118.15,22.44 116.38,22.44 114.85,23.98 114.85,24.6 114.31,25.14 114.31,25.7 112.97,27.04 112.97,28.39 111.73,29.63 111.73,31.98 112.03,32.29 v3(112.9,32.29)
  BOTTOM w0.102: U0400.AH2 112.8,33.39 112.8,32.84 112.72,32.76 112.72,32.47 v3(112.9,32.29) ; CON5103.15 205.23,30.26 204.98,30.51 204.44,30.51 203.94,30 203.94,29.54 v1(203.78,29.39)
USBP9_FP: length 123.2
  IN1 w0.109: v1(112.94,30.55) 112.94,30.35 113.44,29.84 113.44,28.91 114.06,28.29 114.06,26.95 115.01,25.99 115.01,25.43 115.55,24.89 115.55,24.29 116.7,23.14 118.44,23.14 118.78,22.8 120.87,22.8 121.28,22.39 122.83,22.39 123.5,21.72 125.79,21.72 126.18,21.33 127.5,21.33 132.25,16.58 139.46,16.58 139.98,16.06 143.53,16.06 143.81,16.33 147.35,16.33 148.37,15.32 155.35,15.32 156.34,14.33 162.1,14.33 163.96,12.47 176.84,12.47 177.33,11.98 181.67,11.98 182.12,11.53 186.74,11.53 187.41,12.2 196.11,12.2 206.54,22.62 206.54,28.18 205.61,29.11 204.37,29.11 204.11,28.86 204.11,28.58 v1(203.91,28.37)
  BOTTOM w0.076: U0400.AG2 113.41,33.12 113.41,32.89 113.48,32.71 113.51,32.65 113.51,32.49
  BOTTOM w0.102: v1(112.94,30.55) 113.29,30.91 113.29,31.12 113.51,31.34 113.51,32.49 ; CON5103.13 205.43,29.26 205.33,29.16 204.46,29.16 204.1,28.8 204.1,28.56 v1(203.91,28.37)
VA_RTC: length 6.4
  TOP w0.254: v2(99.52,87.45) 99.49,87.43 R3613.2 99.49,85.4 98.72,84.64 D3604.1 98.72,82.65 98.4,82.32 R3614.1
VCONN_VMON_P1: length 6.2
  TOP w0.254: T5801.1 34.65,82.45 35.11,81.98 v1(35.46,81.98) ; v1(38.48,80.32) 38.66,80.14 U5800.19
  BOTTOM w0.254: v1(35.46,81.98) 37.3,81.98 38.48,80.8 v1(38.48,80.32)
VCREF0: length 6.6
  TOP w0.102: U2300.25 31.3,44.65 30.91,45.04 30.91,45.75 v2(30.96,45.8) 31.27,46.1 C2401.1 31.27,46.91 31.13,47.04 30.92,47.04 30.8,47.17 30.8,48.28 R2413.1 R2412.2
VDC_IN_SN:
  vias: v2(46.1,104.22)
VGA_SVID_ALERT#: length 67.2
  IN3 w0.102: v1(149.91,80.8) 149.91,80.8 148.87,80.8 148.23,81.43 148.23,82.07 147.98,82.32 v1(147.45,82.32) 145.52,82.32 139.57,88.27 139.57,89.26 138.81,90.02 134.86,90.02 132.09,92.79 131.19,92.79 128.75,95.23 128.75,100.38 126.21,102.92 123.46,102.92 122.61,103.77 122.61,105.64 121.29,106.96 115.17,106.96 114.86,106.66 109.89,106.66 v1(109.47,107.08)
  BOTTOM w0.102: U6000.AL11 151.9,84.42 150.8,83.31 150.8,81.69 v1(149.91,80.8) ; PR9459.1 PC9422.1 147.45,81.77 v1(147.45,82.32) ; PR9450.2 110.05,106.5 v1(109.47,107.08) 108.78,107.77 PR9401.2 v2(108.46,106.91)
VGA_SVID_CLK: length 11.7
  IN3 w0.102: v1(149.91,80.19) 149.02,80.19 148.11,81.1 147.4,81.1 v1(146.74,80.44)
  BOTTOM w0.102: v1(149.91,80.19) 150.32,80.6 150.32,80.82 151.03,81.53 151.03,83.21 151.87,84.05 152.86,84.05 U6000.AJ11 ; v2(146.91,79.66) 146.74,79.83 v1(146.74,80.44) 146.49,80.2 PR9451.2
VGA_SVID_DATA: length 10.7
  IN3 w0.102: v1(149.92,81.41) 149.64,81.69 149.25,81.69 148.16,82.78 v1(146.81,82.78)
  BOTTOM w0.102: PR9449.2 146.58,83.01 v1(146.81,82.78) 147.52,82.78 v2(147.68,82.93) ; U6000.AK12 152.4,84.79 151.99,84.79 149.92,82.72 v1(149.92,81.41)
VHG_VSYS_R: length 3.6
  TOP w0.432: PR7711.1 197.66,23.45 v1(197.66,22.81) v2(198.18,22.29)
  BOTTOM w0.229: v1(197.66,22.81) 197.22,22.81 196.59,23.44 PU7700.3
VHIO: length 20.4
  TOP w0.279: C3903.1 32.24,60.57 U3901.22 ; U3901.14 34.73,64.02 34.95,64.24 C3914.1
  TOP w0.432: v1(31.84,56.29) 31.8,56.33 R3912.2 C3905.1 C3913.1 C3903.1 ; C3914.1 C3907.1 R3915.2 36.8,64.49 v1(36.64,64.32)
  IN1 w0.508: v1(31.84,56.29) 31.84,60.49 35.67,64.32 v1(36.64,64.32)
  BOTTOM w0.102: v1(36.64,64.32) v2(35.99,64.32)
VIDALERT#: length 52.2
  TOP w0.102: PR7840.2 169.37,50.07 v1(169.27,50.17) 169.27,50.45 v2(168.97,50.74)
  IN3 w0.127: v1(133.93,65.61) 135.78,65.61 136.61,66.44 148.45,66.44 148.92,65.97 148.92,64.84 149.7,64.06 152.66,64.06 153.75,62.97 153.75,61.57 156.36,58.96 159.54,58.96 161.52,56.97 162.66,56.97 164.06,55.57 164.06,54.29 164.75,53.6 168.15,53.6 169.86,51.89 169.86,51.01 169.74,50.88 168.28,50.88 168.12,50.73 168.12,49.89 168.28,49.74 168.83,49.74 v1(169.27,50.17)
  BOTTOM w0.102: R0601.1 134.02,65.52 v1(133.93,65.61) 133.88,65.55 R0603.2
VIDALERT#_VCPU: length 3.8
  TOP w0.102: PR7840.1 171.04,49.43 v1(171.22,49.25) 172.21,49.25 v2(172.49,49.53)
  BOTTOM w0.102: PU7800.36 v1(171.22,49.25)
VIDSCLK: length 52.2
  TOP w0.102: v2(167.87,52.25) 167.87,52 v1(168.17,51.69) 167.87,51.39 PR7846.1 168.17,50.93 168.43,51.18 169.42,51.18 PR7843.2
  IN3 w0.127: v1(168.17,51.69) 167.72,52.15 166.27,52.15 166.14,52.28 166.14,52.56 166.27,52.68 168,52.68 168.12,52.81 168.12,53.09 168,53.22 164.59,53.22 163.68,54.13 163.68,55.41 162.5,56.59 161.37,56.59 159.39,58.57 156.2,58.57 153.37,61.41 153.37,62.82 152.5,63.68 149.54,63.68 148.54,64.69 148.54,65.81 148.29,66.06 136.77,66.06 135.6,64.89 v1(133.94,64.89)
  BOTTOM w0.102: R0604.1 133.68,64.63 v1(133.94,64.89)
VIDSCLK_VCPU: length 5.2
  TOP w0.102: PR7843.1 171.78,49.68 v1(171.86,49.68) 172.14,49.96 174.27,49.96 174.65,50.35 v2(174.65,50.6)
  BOTTOM w0.102: v1(171.86,49.68) 171.89,49.65 PU7800.37
VIDSOUT: length 52.5
  TOP w0.102: PR7839.2 169.52,48.21 v2(169.42,48.11) 169.34,48.03 PR7847.1 v1(168.66,48.69)
  IN3 w0.127: v1(133.93,66.25) 134.51,66.82 148.61,66.82 149.3,66.12 149.3,65 149.86,64.44 152.82,64.44 154.13,63.13 154.13,61.73 156.52,59.34 159.7,59.34 161.68,57.36 162.81,57.36 164.44,55.73 164.44,54.44 164.91,53.98 168.31,53.98 170.24,52.05 170.24,50.55 168.66,48.97 v1(168.66,48.69)
  BOTTOM w0.102: R0605.1 133.69,66.49 v1(133.93,66.25) 134.14,66.45 R0602.1
VIDSOUT_VCPU: length 4.5
  TOP w0.102: PR7839.1 171.6,48.21 171.73,48.34 v1(171.73,48.82) 174.02,48.82 v2(174.14,48.95)
  BOTTOM w0.102: PU7800.35 172.16,48.85 172.14,48.82 v1(171.73,48.82)
VR_CAP: length 2.8
  TOP w0.229: U2300.18 34.1,45.12
  TOP w0.432: v2(35.33,45.49) 35.13,45.7 C2310.1
  TOP w0.508: 34.1,45.12 34.1,45.3 C2310.1
VR_HOT#_VCPU: length 4.4
  BOTTOM w0.102: v2(169.04,49.41) 169.19,49.41 169.52,49.08 170.52,49.08 170.65,49.2 PR7834.1 170.65,49.62 170.92,49.89 171.4,49.89 171.63,50.12 172.06,50.12 172.13,50.05 PU7800.38
VRALERT#: length 14.8
  TOP w0.102: v3(111.5,38.56) 112.54,37.52 112.54,34.62 113.96,33.19 114.94,32.22 114.94,29.47 116.51,27.9 v2(116.51,27.59) 116.08,27.16 R1210.2
  BOTTOM w0.102: v3(111.5,38.56) U0400.AM11
VRAM_ID1: length 11.9
  TOP w0.102: v3(110.13,36.76) 110.1,36.72 110.1,35.45 110.31,35.23 110.31,33.38 110.1,33.16 110.1,30.7 110.61,30.19 R1508.1 110.61,29.44 110.48,29.31 110.22,29.31 110.1,29.19 110.1,28.64 110.26,28.48 110.45,28.48 110.57,28.36 R1507.2 110.08,27.99 109.65,27.56 v2(109.65,27.21)
  BOTTOM w0.102: v3(110.13,36.76) 110.13,36.79 110.04,36.89 109.88,37.05 U0400.AP8
VRAM_ID2: length 13.8
  BOTTOM w0.076: U0400.U2 118.25,33.12 118.25,32.93 118.21,32.79 118.21,32.55 118.5,32.27 118.5,31.19 118.69,30.99 118.69,30.89
  BOTTOM w0.102: R1505.1 125.15,25.2 124.82,24.87 R1504.2 124.61,24.87 124.18,25.3 124.18,25.44 123.46,26.16 122.88,26.16 122.79,26.26 122.37,26.26 122.17,26.06 121.87,26.06 121,26.93 120.64,26.93 120.33,27.23 120.33,28.51 119.91,28.93 v2(119.91,29.09) 119.91,29.39 118.69,30.61 118.69,30.89
VRAM_RST#: length 48
  TOP w0.102: R6301.1 182.22,81.26 v1(182.75,80.72) ; v2(182.96,82.73) 183.5,83.27 v1(183.5,83.27) 183.5,82.96 186.51,79.95 186.98,79.95 187.82,79.95 U6803.J2 188.17,79.6 v1(188.57,79.19) ; U6801.J2 196.95,98.58 v1(196.58,98.96)
  IN3 w0.102: v1(183.5,83.27) 184.24,84.01 187.07,84.01 187.42,84.37 192.47,84.37 193.3,83.54 194.74,83.54 195.47,82.81 198.38,82.81 198.77,83.2 198.77,97.37 197.54,98.59 196.94,98.59 v1(196.58,98.96)
  BOTTOM w0.102: v1(183.5,83.27) 182.75,82.52 v1(182.75,80.72) ; v1(188.57,79.19) 188.17,79.6 U6803.J2 ; U6801.J2 196.95,98.58 v1(196.58,98.96)
VREF_CPU: length 6.7
  TOP w0.229: U2300.95 40.5,27.35
  TOP w0.254: v2(43.54,23.85) 43.54,25.4 42.77,26.16 R2321.1 C2315.1 40.74,26.39 40.74,27.1 40.5,27.35
VREF_PINSET_RC: length 1.8
  BOTTOM w0.254: v2(103.61,103.66) 103.71,103.56 PC9420.1 PR9448.2
VRM_PWRGD: length 124.7
  TOP w0.102: v1(145.34,9.96) 145.85,10.47 146.53,10.47 v2(147.22,11.15) 147.75,11.69 147.75,13.01 148.51,13.77 148.51,16.67 146.81,18.37 146.81,20.3 145.97,21.14 145.97,25.1 150.42,29.55 150.42,30.5 151.47,31.55 156.84,31.55 159.84,34.55 159.84,41.05 158.93,41.96 158.93,43.51 159.39,43.97 159.39,47.42 164.8,52.83 167.92,52.83 168.83,51.92 v1(168.83,51.59) ; v1(103.4,26.38) 103.61,26.17 104.13,26.17 104.37,25.93 104.37,18.02 104.04,17.69 103.67,17.69 v1(103.26,18.1)
  IN1 w0.102: v1(145.34,9.96) 144.91,10.39 141.4,10.39 140.93,9.91 130.89,9.91 126.55,14.26 124.91,14.26 122.11,11.46 118.72,11.46 114.42,15.76 105.59,15.76 v1(103.26,18.1)
  BOTTOM w0.102: v1(103.4,26.38) 103.39,26.38 102.74,25.73 R1222.2 102.03,25.73 102,25.7 U1203.1 ; PR7836.2 170.08,50.57 169.57,51.08 169.34,51.08 v1(168.83,51.59)
WCKA0_0: length 38
  TOP w0.114: U6801.P4 v1(194.94,102.99) 194.46,102.99 194.12,103.33 192.74,103.33 192.37,103.7 192.37,105.87 191.4,106.83 184.95,106.83 180.51,102.39 179.89,102.39 179.77,102.5 179.77,103.41 179.53,103.65 178.89,103.65 178.65,103.41 178.65,102.5 178.54,102.39 178.08,102.39 177.97,102.5 177.97,103.41 177.73,103.65 177.09,103.65 176.85,103.41 176.85,102.5 176.74,102.39 176.28,102.39 176.16,102.5 176.16,103.41 175.92,103.65 175.29,103.65 175.05,103.41 175.05,102.5 174.93,102.39 172.82,102.39 172.35,101.92 172.35,101.44 172.75,101.04 v1(172.75,100.76)
  BOTTOM w0.114: v1(194.94,102.99) U6801.P4 ; v1(172.75,100.76) 172.67,100.84 172.47,100.84 172.03,100.4 172.03,99.92 172.03,99.92 U6000.E32
WCKA0_1: length 34.7
  TOP w0.114: U6801.D4 195,94.94 v1(194.95,94.94) 194.95,94.5 194.68,94.22 194.02,94.22 193.65,93.85 193.65,90.83 191.83,89.02 182,89.02 180.92,90.1 180.76,90.1 180.06,89.4 179.72,89.4 179.27,89.85 179.27,90.19 180.16,91.08 180.16,91.24 179.85,91.55 179.69,91.55 178.81,90.67 178.44,90.67 177.99,91.13 177.99,91.47 178.5,91.98 178.5,92.37 178.26,92.61 178.26,93.16 v1(178.05,93.36)
  BOTTOM w0.102: U6000.A21 174.05,92.42 174.11,92.47 176.5,92.47 176.55,92.52 176.64,92.52
  BOTTOM w0.114: U6801.D4 195,94.94 v1(194.95,94.94) ; v1(178.05,93.36) 178.15,93.26 178.15,92.81 177.86,92.52 176.64,92.52
WCKA0B_0: length 38.5
  TOP w0.114: v1(173.15,101.22) 172.87,101.22 172.57,101.53 172.57,101.83 172.91,102.17 175.02,102.17 175.26,102.41 175.26,103.32 175.38,103.44 175.83,103.44 175.95,103.32 175.95,102.41 176.19,102.17 176.83,102.17 177.07,102.41 177.07,103.32 177.18,103.44 177.64,103.44 177.75,103.32 177.75,102.41 177.99,102.17 178.63,102.17 178.87,102.41 178.87,103.32 178.98,103.44 179.44,103.44 179.56,103.32 179.56,102.41 179.8,102.17 180.6,102.17 185.04,106.62 191.31,106.62 192.15,105.78 192.15,103.61 192.65,103.11 193.74,103.11 v1(193.95,102.91) 194.23,102.91 U6801.P5
  BOTTOM w0.114: v1(173.15,101.22) 172.54,101.22 171.81,100.49 171.81,100.01 171.67,99.87 171.67,99.2 172.03,98.84 U6000.E30 ; v1(193.95,102.91) 194.23,102.91 U6801.P5
WCKA0B_1: length 35.1
  TOP w0.114: v1(178.69,93.33) 178.47,93.12 178.47,92.7 178.72,92.46 178.72,91.89 178.21,91.38 178.21,91.21 178.53,90.89 178.72,90.89 179.6,91.77 179.94,91.77 180.37,91.33 180.37,90.99 179.48,90.1 179.48,89.94 179.81,89.61 179.97,89.61 180.67,90.31 181.01,90.31 182.09,89.23 191.74,89.23 193.43,90.92 193.43,93.94 193.93,94.44 194.07,94.44 194.2,94.57 194.2,94.77 v1(194.1,94.86) 194.4,94.86 194.42,94.85 194.44,94.85 194.56,94.74 U6801.D5
  BOTTOM w0.102: 176.64,92.3 176.62,92.3 176.59,92.27 174.19,92.27 174.18,92.26 174.02,92.13 173.89,92.11 173.78,92.09 173.61,92.09 173.54,92.09 173.44,92.14 173.3,92.28 173.3,92.34 173.22,92.42 U6000.C21
  BOTTOM w0.114: v1(194.1,94.86) 194.27,94.86 U6801.D5 ; 176.64,92.3 177.95,92.3 178.41,92.76 178.64,92.76 178.77,92.89 178.77,93.25 v1(178.69,93.33)
WCKA1_0: length 46.1
  TOP w0.114: U6803.D4 190.17,83.2 v1(190.2,83.2) 190.65,83.2 191.46,82.38 191.46,80.04 191.95,79.56 191.95,75.94 192.54,75.34 192.54,72.89 191.1,71.44 183.56,71.44 182.48,72.52 177.38,72.52 175.26,74.64 174.05,74.64 173.07,75.62 173.07,84.9 172.67,85.31 172.4,85.31 172.09,85.63 171.83,85.63 v1(171.75,85.54)
  BOTTOM w0.102: v1(171.75,85.54) 171.75,85.73 U6000.E13
  BOTTOM w0.114: U6803.D4 190.17,83.2 v1(190.2,83.2)
WCKA1_1: length 37.3
  TOP w0.114: v1(173.57,76.39) 173.77,76.19 174.39,76.19 177.7,79.5 178.06,79.5 178.61,78.95 178.61,78.59 175.78,75.76 175.78,75.58 177.83,73.54 183.79,73.54 185.05,72.28 190.75,72.28 191.71,73.24 191.71,74.39 191.48,74.62 191.21,74.62 190.89,74.93 190.89,74.97 190.68,75.19 v1(190.2,75.19) 190.18,75.19 U6803.P4
  BOTTOM w0.102: v1(173.57,76.39) 173.57,76.25 173.46,76.15 173.22,76.15 173.05,76.32 173.05,76.54 172.23,77.36 172.08,77.36 171.68,77.77 171.68,78.1 171.76,78.28 171.84,78.36 171.91,78.36 172.03,78.48 U6000.E3
  BOTTOM w0.114: v1(190.2,75.19) 189.79,75.6 U6803.P4
WCKA1B_0: length 45.9
  TOP w0.114: v1(171.95,84.96) 172.09,85.09 172.58,85.09 172.86,84.81 172.86,75.53 173.96,74.43 175.17,74.43 177.29,72.3 182.39,72.3 183.47,71.22 191.19,71.22 192.76,72.8 192.76,75.43 192.16,76.03 192.16,79.67 191.68,80.15 191.68,82.47 191.2,82.95 v1(191.2,83.23) 190.92,83.23 190.57,83.58 U6803.D5
  BOTTOM w0.102: U6000.D12 172.17,84.96 v1(171.95,84.96)
  BOTTOM w0.114: v1(191.2,83.23) 190.94,83.23 U6803.D5
WCKA1B_1: length 38.1
  TOP w0.114: v1(173.57,75.74) 173.81,75.98 174.48,75.98 177.79,79.29 177.97,79.29 178.4,78.86 178.4,78.68 175.57,75.85 175.57,75.49 177.74,73.32 183.7,73.32 184.96,72.06 190.84,72.06 191.92,73.15 191.92,74.48 v1(191.31,75.1) 191.07,75.1 U6803.P5
  BOTTOM w0.102: v1(173.57,75.74) 173.37,75.95 173.13,75.95 172.85,76.23 172.85,76.4 172.85,76.46 172.15,77.16 172,77.16 171.47,77.69 171.47,78.14 171.63,78.47 171.63,78.57 U6000.F4
  BOTTOM w0.114: U6803.P5 191.07,75.1 v1(191.31,75.1)
