# Allegro board 5n-armani13.a00.0828.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQS2: length 52.7
  IN1 w0.122: v1(68.29,78.64) 68.29,78.31 68.44,78.16 69.24,78.16 69.95,78.86 91.34,78.86 92.68,77.52 92.68,75.73 93.06,75.36 93.26,75.36 93.41,75.5 v1(93.41,75.63)
  BOTTOM w0.076: U0400.AY64 106.17,69.01 105.77,68.61 105.48,68.58 105.4,68.57 105.19,68.51 105.19,68.51 105.09,68.48 104.9,68.48 104.39,68.61 104.21,68.68 104.21,68.68 104.1,68.72 103.16,68.72 103.04,68.84 102.93,68.95 102.9,68.95
  BOTTOM w0.109: 92.73,74.04 92.73,74.98 92.98,75.23 93.28,75.23 93.41,75.36 v1(93.41,75.63) ; 92.73,74.04 92.73,72.64 93.22,72.15 93.55,72.15 94.12,72.72 94.27,72.72 94.58,72.41 94.58,72.25 94.01,71.68 94.01,71.35 97.12,68.24 101.06,68.24 101.77,68.95 102.9,68.95 ; 92.73,74.04 v2(92.48,74.04) ; CON2000.55 69.31,78.82 69.09,79.05 69.02,79.05 68.9,79.17 68.45,79.17 68.29,79 v1(68.29,78.64)
M_A_DQS3: length 52.9
  IN1 w0.122: v5(64,73.31) 64.46,73.77 64.46,74.26 64.72,74.52 66.17,74.52 66.67,74.02 66.67,72.88 67.19,72.36 69.34,72.36 69.82,72.84 73.03,72.84 73.72,73.54 91.45,73.54 92.39,72.6 95.45,72.6 96.2,71.85 96.37,71.85 96.56,72.04 96.98,72.04 97.33,71.68 97.33,71.3 96.87,70.84 96.87,70.42 98.88,68.4 101.73,68.4 102.16,67.97 102.16,67.83 v3(102.44,67.55)
  BOTTOM w0.076: v3(102.44,67.55) 102.29,67.4 102.29,67.1 102.53,66.86 102.53,66.5 102.84,66.18 102.86,66.18 104.27,66.18 104.31,66.22 104.41,66.33 104.81,66.33 104.92,66.28 105.06,66.28 105.17,66.33 105.41,66.33 U0400.BA60
  BOTTOM w0.109: v5(64,73.31) 64.25,73.57 64.25,73.74 64.13,73.87 63.28,73.87 62.98,73.57 CON2000.76
M_A_DQS4: length 51.1
  IN1 w0.122: v1(88.06,51.92) 87.53,51.92 87.28,51.67 87.1,51.67 86.99,51.79 86.99,52.2 86.64,52.55 86.02,52.55 85.69,52.22 85.69,51.34 85.57,51.21 84.87,51.21 83.39,49.73 79.75,49.73 74.98,44.96 74.51,44.96 73.96,45.51 73.47,45.51 72.91,44.96 72.53,44.96 71.96,45.52 71.44,45.52 70.87,44.96 70.52,44.96 69.9,45.57 69.46,45.57 68.85,44.96 68.31,44.96 68.11,45.17 v1(68.11,45.54)
  BOTTOM w0.076: 102.89,54.17 102.91,54.17 102.93,54.14 103.11,54.14 103.58,54.61 104.42,54.61 104.45,54.58 104.76,54.58 104.8,54.6 104.85,54.62 104.93,54.62 105.06,54.62 105.13,54.62 105.2,54.6 105.25,54.59 106,54.59 U0400.AY38
  BOTTOM w0.109: 89,51.45 88.25,51.45 88.06,51.64 v1(88.06,51.92) ; 89,51.45 v2(89,51.67) ; 89,51.45 89.52,51.45 89.88,51.81 89.88,51.97 89.29,52.56 89.29,52.92 89.61,53.24 90.14,53.24 90.65,52.73 90.8,52.73 91.31,53.24 91.63,53.56 98.41,53.56 98.77,53.93 101.73,53.93 101.81,54 102.02,54 102.18,54.17 102.38,54.17 102.89,54.17 ; v1(68.11,45.54) 68.11,45.9 68.21,46 69.09,46 69.27,45.82 CON2000.179
M_A_DQS5: length 52.1
  IN1 w0.122: v1(63.99,40.03) 64.23,40.27 64.23,40.44 64.58,40.79 65.5,40.79 66.59,39.7 76.01,39.7 81.81,45.5 85.44,45.5 87.51,47.57 87.51,48.14 89.1,49.73 99.18,49.73 99.41,49.96 99.41,50.14 v1(99.26,50.29)
  BOTTOM w0.076: U0400.BA34 105.85,51.84 105.89,51.79 105.89,51.66 105.81,51.6 105.75,51.57 105.53,51.57 105.45,51.6 105.17,51.6 105.06,51.55 104.92,51.55 104.79,51.61 104.42,51.61 104.23,51.42 104.21,51.42 104.19,51.4 103.17,51.4 103.17,51.4 102.78,51.4 102.77,51.39
  BOTTOM w0.109: 100.13,50.95 99.85,50.95 99.66,50.76 99.66,50.69 v1(99.26,50.29) ; 100.13,50.95 100.61,50.95 100.94,51.29 101.76,51.29 101.87,51.39 102.77,51.39 ; 100.13,50.95 v2(100.13,51.18) ; v1(63.99,40.03) 64.23,40.27 64.23,40.5 64,40.74 63.21,40.74 63.05,40.57 CON2000.200
M_A_DQS6: length 54.1
  IN1 w0.122: v5(68.23,34.76) 68.07,34.6 68.07,34.42 68.19,34.29 69.27,34.29 69.39,34.42 69.39,34.64 69.65,34.9 70.3,34.9 70.56,34.64 70.56,34.42 70.69,34.29 71.22,34.29 71.34,34.41 71.34,34.59 71.59,34.84 72.26,34.84 72.52,34.59 72.52,34.41 72.64,34.29 76.65,34.29 83.81,41.46 88.02,41.46 90.51,43.94 90.51,46.3 90.31,46.49 90.31,46.84 90.59,47.11 v1(91.19,47.11)
  BOTTOM w0.076: U0400.AY30 106.07,49.31 106.01,49.38 106.01,49.42 105.98,49.44 105.78,49.64 105.51,49.64 105.44,49.61 105.39,49.61 105.23,49.61 105.13,49.63 105.07,49.64 104.92,49.64 104.85,49.63 104.79,49.61 104.77,49.6 104.19,49.6 104.1,49.52 104.1,49.52 104.05,49.47 103.46,49.47 103.03,49.04 102.55,49.04 102.53,49.06 102.44,49.06
  BOTTOM w0.109: 102.44,49.06 97.93,49.06 97.56,49.43 96.1,49.43 95.78,49.1 95.24,49.1 94.91,49.43 93.7,49.43 93.37,49.1 93.37,48.54 92.94,48.1 92.78,48.1 92.44,48.45 92.11,48.45 91.67,48.01 91.67,47.69 92.02,47.34 92.02,47.19 91.49,46.66 91.31,46.66 91.19,46.79 v1(91.19,47.11) ; CON2000.221 69.4,35.32 69.35,35.38 69.22,35.38 69.04,35.2 68.16,35.2 68.05,35.09 68.05,34.94 v5(68.23,34.76)
M_A_DQS7: length 56
  IN1 w0.122: v1(100.66,44.7) 100.9,44.46 100.9,44.26 98.6,41.96 97.52,41.96 97.19,41.63 97.19,41.63 97.18,41.62 97.18,41.23 97.29,41.12 97.29,40.91 97.04,40.67 96.86,40.67 96.75,40.78 96.39,40.78 96.01,40.4 96.01,40.03 96.12,39.92 96.12,39.66 95.85,39.39 94.65,39.39 92.75,37.49 85.43,37.49 76.92,28.97 68.34,28.97 68.11,29.21 65.82,29.21 64.44,30.59 64.44,30.89 v5(64.74,31.19)
  BOTTOM w0.076: U0400.BA26 105.77,46.73 105.77,46.69 105.67,46.59 105.53,46.59 105.45,46.62 105.17,46.62 105.06,46.57 104.92,46.57 104.81,46.62 104.39,46.62 104.06,46.29 103.31,46.29 103.09,46.07 102.25,46.07 102.15,45.96
  BOTTOM w0.109: 102.15,45.96 102.11,45.93 101.3,45.93 101.03,45.66 101.03,44.9 100.84,44.7 v1(100.66,44.7) ; v5(64.74,31.19) 64.4,30.85 64.4,30.47 64.15,30.22 63.19,30.22 63.05,30.07 CON2000.242
M_A_DQS#0: length 64.2
  IN1 w0.122: v3(111.18,74.98) 111.46,74.98 111.63,75.16 111.63,75.8 111.41,76.02 111.41,76.4 111.05,76.76 111.05,81.2 110.34,81.91 109.91,81.91 109.73,81.74 109.5,81.74 109.19,82.05 109.19,82.32 109.4,82.53 109.4,82.93 108.94,83.39 108.63,83.39 108.4,83.16 108.18,83.16 107.83,83.51 107.83,83.66 108.03,83.86 108.03,84.3 107.58,84.75 107.18,84.75 106.97,84.55 106.79,84.55 106.46,84.88 106.46,85.06 106.65,85.26 106.65,85.68 105.28,87.05 102.45,87.05 102.2,87.3 90.26,87.3 88.84,88.72 79.59,88.72 77.53,90.78 70.14,90.78 69.1,89.75 68.2,89.75 68.07,89.88 68.07,90.05 v1(68.33,90.31)
  BOTTOM w0.076: v3(111.18,74.98) 111.31,75.11 111.47,75.11 111.56,75.02 111.56,74.17 111.06,73.67 111.06,73.19 111.11,73.09 111.11,72.93 111.06,72.83 111.06,72.4 111.02,72.36 111,72.36 U0400.AM70
  BOTTOM w0.109: v1(68.33,90.31) 68.05,90.03 68.05,89.77 68.17,89.64 68.95,89.64 69.14,89.82 CON2000.11
M_A_DQS#1: length 56.5
  IN1 w0.122: v5(64.29,84.69) 64.52,84.46 64.52,83.77 65.08,83.21 66.73,83.21 67.44,83.93 87.59,83.93 88.38,83.14 100.37,83.14 105.79,77.71 105.79,76.55 106.1,76.25 106.64,76.25 v1(106.79,76.09)
  BOTTOM w0.076: 107.37,75.26 107.37,74.26 108.08,73.55 108.08,73.23 108.03,73.13 108.03,72.89 108.08,72.79 108.08,72.58 108.03,72.48 108.03,72.26 108.09,72.07 108.23,71.97 108.4,71.97 108.47,71.89 U0400.AT69
  BOTTOM w0.109: v1(106.79,76.09) 106.95,76.25 107.05,76.25 107.37,75.93 107.37,75.26 ; v5(64.29,84.69) 64.48,84.49 64.48,84.31 64.29,84.13 63.44,84.13 63.17,84.4 63.17,84.51 63.1,84.57 CON2000.32
M_A_DQS#2: length 52.3
  IN1 w0.122: v5(67.59,78.64) 68.3,77.93 69.33,77.93 70.04,78.64 91.25,78.64 92.46,77.43 92.46,75.64 92.97,75.14 93.64,75.14 v1(93.76,75.02)
  BOTTOM w0.076: 102.9,69.16 102.95,69.16 103.23,68.89 104.13,68.89 104.61,68.73 104.92,68.65 105.07,68.65 105.37,68.73 105.47,68.74 105.47,68.74 U0400.BA64
  BOTTOM w0.109: v5(67.59,78.64) 68.33,79.38 68.99,79.38 69.1,79.26 69.3,79.26 69.37,79.32 CON2000.53 ; v1(93.76,75.02) 93.07,75.02 92.94,74.89 92.94,72.72 93.3,72.36 93.46,72.36 94.03,72.93 94.36,72.93 94.79,72.49 94.79,72.17 94.22,71.59 94.22,71.44 97.21,68.46 100.97,68.46 101.68,69.16 102.9,69.16
M_A_DQS#3: length 53
  IN1 w0.122: v3(101.91,67.36) 101.91,67.89 101.62,68.18 98.79,68.18 96.65,70.32 96.65,70.93 97.11,71.39 97.11,71.59 96.88,71.81 96.67,71.81 96.48,71.62 96.11,71.62 95.36,72.37 92.3,72.37 91.36,73.31 73.82,73.31 73.13,72.62 69.91,72.62 69.43,72.14 67.09,72.14 66.45,72.79 66.45,73.93 66.08,74.3 64.81,74.3 64.68,74.17 v1(64.68,73.32)
  BOTTOM w0.076: v3(101.91,67.36) 102.12,67.15 102.12,67.04 102.36,66.79 102.36,66.43 102.78,66.02 102.79,66.02 104.33,66.02 104.43,66.11 104.48,66.16 104.77,66.16 104.89,66.11 105.1,66.11 105.21,66.16 105.49,66.16 105.62,66.21 105.69,66.28 105.84,66.33 106,66.33 U0400.AY60
  BOTTOM w0.109: CON2000.74 63.19,74.07 63.19,74.08 64.22,74.08 64.47,73.83 64.47,73.54 v1(64.68,73.32)
M_A_DQS#4: length 50.9
  IN1 w0.122: v1(87.68,51.44) 87.02,51.44 86.77,51.7 86.77,52.11 86.55,52.33 86.12,52.33 85.92,52.13 85.92,51.24 85.66,50.99 84.96,50.99 83.48,49.51 79.84,49.51 75.07,44.73 74.42,44.73 73.86,45.29 73.56,45.29 73,44.73 72.44,44.73 71.87,45.3 71.54,45.3 70.97,44.73 70.42,44.73 69.81,45.35 69.55,45.35 68.94,44.74 68.22,44.74 v5(67.41,45.54)
  BOTTOM w0.076: U0400.BA38 105.41,54.42 105.23,54.42 105.16,54.43 105.1,54.45 105.05,54.46 104.94,54.46 104.89,54.45 104.86,54.44 104.79,54.42 104.38,54.42 104.35,54.45 103.65,54.45 103.18,53.98 102.92,53.98 102.9,53.95 102.89,53.95
  BOTTOM w0.109: v1(87.68,51.44) 87.91,51.44 88.11,51.24 89.61,51.24 90.09,51.73 90.09,52.06 89.5,52.65 89.5,52.83 89.7,53.03 90.05,53.03 90.56,52.52 90.89,52.52 91.4,53.03 91.72,53.35 98.5,53.35 98.86,53.72 101.82,53.72 101.9,53.79 102.11,53.79 102.27,53.95 102.29,53.95 102.89,53.95 ; v5(67.41,45.54) 68.08,46.21 69.1,46.21 69.21,46.32 CON2000.177
M_A_DQS#5: length 51.8
  IN1 w0.122: v5(64.72,40.03) 64.47,40.29 64.47,40.36 64.67,40.57 65.41,40.57 66.5,39.48 76.1,39.48 81.9,45.27 85.53,45.27 87.73,47.48 87.73,48.05 89.19,49.51 99.29,49.51 99.87,50.09 v1(99.87,50.29)
  BOTTOM w0.076: 102.77,51.18 102.86,51.18 102.92,51.23 103.24,51.23 103.24,51.24 104.26,51.24 104.28,51.26 104.3,51.26 104.49,51.45 104.76,51.45 104.89,51.39 105.1,51.39 105.21,51.44 105.42,51.44 105.5,51.4 105.78,51.4 105.89,51.45 106.03,51.53 106.06,51.56 106.06,51.65 106.15,51.74 U0400.AY34
  BOTTOM w0.109: v1(99.87,50.29) 99.87,50.6 100.02,50.74 100.78,50.74 101.11,51.08 101.85,51.08 101.95,51.18 102.77,51.18 ; CON2000.198 63.09,41.07 63.22,40.95 64.09,40.95 64.44,40.59 64.44,40.31 v5(64.72,40.03)
M_A_DQS#6: length 54.3
  IN1 w0.122: v1(67.53,34.76) 67.84,34.44 67.84,34.33 68.1,34.07 69.36,34.07 69.62,34.33 69.62,34.55 69.74,34.68 70.21,34.68 70.34,34.55 70.34,34.33 70.6,34.07 71.31,34.07 71.56,34.32 71.56,34.5 71.68,34.62 72.17,34.62 72.29,34.5 72.29,34.32 72.55,34.07 76.74,34.07 83.9,41.23 88.12,41.23 90.73,43.84 v1(90.73,46.66)
  BOTTOM w0.076: 102.44,48.85 102.53,48.85 102.55,48.87 103.1,48.87 103.53,49.3 104.12,49.3 104.17,49.35 104.26,49.44 104.8,49.44 104.85,49.46 104.89,49.47 104.93,49.48 105.06,49.48 105.1,49.47 105.21,49.44 105.41,49.44 105.48,49.46 105.54,49.48 105.72,49.48 105.82,49.38 105.82,49.27 105.76,49.21 U0400.BA30
  BOTTOM w0.109: v1(90.73,46.66) 91.02,46.66 91.23,46.45 91.58,46.45 92.23,47.1 92.23,47.43 91.89,47.77 91.89,47.93 92.2,48.24 92.35,48.24 92.69,47.89 93.02,47.89 93.58,48.45 93.58,49.01 93.78,49.22 94.31,49.22 ; CON2000.219 69.35,35.82 69.27,35.75 69.27,35.73 68.95,35.41 68.07,35.41 67.82,35.16 67.82,35.05 v1(67.53,34.76) ; v2(94.31,48.99) 94.31,49.22 ; 94.31,49.22 94.82,49.22 95.15,48.89 95.86,48.89 96.19,49.22 97.47,49.22 97.84,48.85 102.44,48.85
M_A_DQS#7: length 56
  IN1 w0.122: v1(64.01,31.14) 64.22,30.94 64.22,30.5 65.73,28.98 68.02,28.98 68.25,28.75 77.01,28.75 77.04,28.79 85.53,37.27 92.84,37.27 94.74,39.17 95.95,39.17 96.34,39.56 96.34,40.01 96.23,40.12 96.23,40.3 96.48,40.55 96.66,40.55 96.77,40.44 97.13,40.44 97.51,40.82 97.51,41.23 97.41,41.33 97.41,41.54 97.62,41.74 98.7,41.74 101.12,44.17 101.13,44.17 101.14,44.18 101.14,44.42 v1(101.37,44.65)
  BOTTOM w0.076: U0400.AY26 106.16,46.62 106.14,46.62 105.89,46.47 105.83,46.44 105.78,46.42 105.5,46.42 105.42,46.46 105.21,46.46 105.1,46.41 104.89,46.41 104.77,46.46 104.46,46.46 104.13,46.13 103.38,46.13 103.15,45.9 102.39,45.9 102.29,45.81
  BOTTOM w0.109: 102.29,45.81 102.2,45.71 101.38,45.71 101.24,45.58 101.24,44.78 v1(101.37,44.65) ; v1(64.01,31.14) 64.19,30.97 64.19,30.56 64.06,30.43 63.27,30.43 63.13,30.57 CON2000.240
M_B_A0: length 65.6
  TOP w0.165: v1(53.47,58.58) 52.72,57.84 v2(52.2,57.84)
  IN3 w0.152: v1(100.23,59.46) 99.42,59.46 98.11,60.78 79.97,60.78 78.53,59.34 75.42,59.34 73.65,57.56 56.97,57.56 56.1,58.43 55.04,58.43 54.29,59.18 53.59,59.18 53.47,59.06 v1(53.47,58.58)
  BOTTOM w0.076: 101.97,58.85 102.11,58.71 103.22,58.71 103.51,58.42 104.31,58.42 104.51,58.22 104.91,58.22 105.18,58.48 U0400.BA46
  BOTTOM w0.165: 101.97,58.85 101.97,58.85 101.73,58.85 101.62,58.96 100.73,58.96 v1(100.23,59.46) ; v1(53.47,58.58) 52.91,58.03 52.91,57.48 52.57,57.15 52.25,57.15 52.12,57.27 52.12,57.97 51.99,58.1 51.54,58.1 51.41,57.97 51.41,56.53 51.28,56.4 50.72,56.4 50.6,56.53 50.6,57.45 50.47,57.57 CON2100.144
M_B_A1: length 67
  TOP w0.165: v1(55.93,59.5) 55.93,59.77 55.52,60.18 54.92,60.18 v2(54.62,60.47)
  IN3 w0.152: v1(102.21,59.54) 102.21,59.97 101.78,60.4 99.52,60.4 98.12,61.8 78.48,61.8 78.28,61.61 78.28,60.49 78.08,60.29 77.29,60.29 77.09,60.49 77.09,61.61 76.89,61.8 76.42,61.8 73.65,59.03 59.56,59.03 59.35,58.83 57.42,58.83 56.87,59.38 56.05,59.38 v1(55.93,59.5)
  BOTTOM w0.076: 102.39,59.36 102.71,59.04 103.54,59.04 103.83,58.75 104.78,58.75 104.79,58.74 104.85,58.71 105.11,58.71 105.23,58.75 105.43,58.75 105.5,58.71 105.84,58.71 105.95,58.6 U0400.AY46
  BOTTOM w0.165: CON2100.133 56.42,60.32 55.68,61.06 54.69,61.06 53.82,61.93 53.52,61.93 53.38,61.79 53.38,60.31 53.73,59.96 55.77,59.96 55.93,59.8 v1(55.93,59.5) ; 102.39,59.36 v1(102.21,59.54)
M_B_A2: length 64.7
  TOP w0.165: v2(52.02,60.23) 52.3,59.95 v1(52.3,59.57)
  IN3 w0.152: v1(52.3,59.57) 52.3,59.95 52.43,60.07 62.71,60.07 63.22,59.57 70.29,59.57 71.4,60.67 71.4,60.98 71.57,61.16 72.43,61.16 72.63,60.96 72.63,59.92 72.83,59.72 73.62,59.72 73.82,59.92 73.82,60.96 74.02,61.16 74.85,61.16 74.9,61.16 76.02,62.28 98.22,62.28 99.77,60.73 102.54,60.73 103.35,59.92 v3(103.35,59.49)
  BOTTOM w0.076: U0400.AY47 106.02,58.91 105.85,58.91 105.73,58.88 105.55,58.88 105.49,58.9 105.46,58.91 105.2,58.91 105.18,58.91 105.17,58.9 105.08,58.88 104.89,58.88 104.81,58.91 103.93,58.91 v3(103.35,59.49)
  BOTTOM w0.165: v1(52.3,59.57) 52.3,60.28 52,60.57 CON2100.132
M_B_A3: length 64.1
  TOP w0.165: v1(54.66,59.5) 54.66,58.75 v2(54.41,58.5)
  IN3 w0.152: v1(54.66,59.5) 55.25,58.91 55.32,58.91 55.32,58.91 56.67,58.91 57.36,58.21 61.67,58.21 62.01,58.55 73.84,58.55 75.1,59.81 78.33,59.81 78.77,60.25 78.77,61.01 79.01,61.26 98.13,61.26 99.31,60.07 101.06,60.07 v1(101.56,59.57)
  BOTTOM w0.076: 102.23,58.95 102.3,58.88 103.29,58.88 103.58,58.58 104.57,58.58 U0400.BB46
  BOTTOM w0.165: v1(54.66,59.5) 53.6,59.5 53.14,59.96 53.14,60.02 53.11,60.05 53.11,60.94 53.12,60.94 53.12,61.31 53.11,61.31 52.63,61.8 52.63,62.05 52.77,62.19 53.96,62.19 54.69,61.46 55.75,61.46 56.38,60.82 CON2100.131 ; 102.23,58.95 102.08,59.1 102.03,59.1 101.77,59.36 101.77,59.36 v1(101.56,59.57)
M_B_A4: length 64.7
  IN3 w0.152: v1(88.23,63.26) 75.6,63.26 74.45,62.12 70.65,62.12 70.44,61.9 70.44,61.07 70.03,60.66 69.33,60.66 63.55,60.66 62.27,61.94 59.99,61.94 59.22,61.17 53.47,61.17 52.86,61.78 52.86,62.61 52.7,62.77 52.23,62.77 52.07,62.61 52.07,62.23 51.94,62.11 50.95,62.11 50.81,61.97 50.81,61.65 v1(51.35,61.11)
  BOTTOM w0.076: U0400.BA47 105.46,59.15 104.99,59.61 104.99,59.91 104.82,60.08 104.51,60.08 104.46,60.02 102.59,60.02 102.54,59.97
  BOTTOM w0.165: v1(51.35,61.11) 50.88,61.57 CON2100.128 ; 102.54,59.97 102.36,59.97 102.31,60.03 100.73,60.03 100.71,60.01 99.83,60.01 99.23,59.41 93.85,59.41 v2(93.45,59.82) 93.43,59.84 91.65,59.84 v1(88.23,63.26)
M_B_A5: length 65.6
  IN3 w0.152: v1(52.02,61.12) 52.02,60.73 52.2,60.55 59.79,60.55 60.02,60.78 60.02,61.24 60.24,61.46 60.64,61.46 60.88,61.22 60.88,60.84 61.01,60.71 61.49,60.71 61.62,60.84 61.62,61.22 61.81,61.41 62.13,61.41 63.35,60.18 63.74,60.18 69.53,60.19 70.23,60.19 70.92,60.87 70.92,61.52 71.03,61.64 74.65,61.64 75.8,62.79 88.43,62.79 88.43,62.79 90.07,62.79 90.2,62.92 v1(90.2,63.26)
  BOTTOM w0.076: U0400.AY48 105.74,59.81 105.06,60.49 104.22,60.49
  BOTTOM w0.165: CON2100.126 51.78,62.07 52.02,61.84 v1(52.02,61.12) ; v1(90.2,63.26) 90.2,63.04 91.21,62.03 91.44,62.03 91.62,62.22 91.8,62.22 92.09,61.93 92.09,61.75 91.83,61.49 91.83,61.31 92.3,60.84 94.79,60.84 v2(95,60.63) 95.33,60.3 95.77,60.3 95.94,60.47 95.94,60.68 96.1,60.85 96.76,60.85 96.93,60.68 96.93,60.47 97.09,60.3 98.86,60.3 99.46,60.9 100.6,60.9 100.79,60.71 102.39,60.71 102.61,60.49 104.22,60.49
M_B_A6: length 65.2
  TOP w0.165: v2(53.71,62.11) v1(54.31,62.7)
  IN3 w0.152: v1(54.31,62.7) 54.31,62.61 54.18,62.49 53.52,62.49 53.33,62.3 53.33,61.97 53.58,61.73 56.59,61.73 56.6,61.73 57.44,61.73 57.64,61.93 57.64,62.06 57.83,62.26 58.23,62.26 58.43,62.06 58.43,61.93 58.63,61.73 59.01,61.73 59.21,61.93 59.21,62.26 59.36,62.41 65.14,62.41 65.19,62.36 65.78,62.36 65.96,62.18 65.96,61.27 66.09,61.14 69.13,61.14 69.84,61.14 69.96,61.27 69.96,62.1 70.46,62.59 74.25,62.59 75.4,63.74 89.32,63.74 89.5,63.56 v1(89.5,63.26)
  BOTTOM w0.076: U0400.BA48 105.32,59.97 105.05,60.24 104.13,60.24 104.12,60.24 102.5,60.24
  BOTTOM w0.165: CON2100.127 54.71,61.82 54.31,62.23 v1(54.31,62.7) ; 102.5,60.24 102.28,60.45 99.64,60.45 99.05,59.86 94.98,59.86 94.56,60.28 91.84,60.28 91.45,60.67 91.45,61.06 91.18,61.33 90.79,61.33 90.52,61.6 90.52,61.99 90.24,62.27 89.85,62.27 89.5,62.62 v1(89.5,63.26)
M_B_A7: length 66.3
  TOP w0.165: v1(51.26,62.6) v2(51.74,63.08)
  IN3 w0.152: v1(51.26,62.6) 51.91,63.25 57.52,63.25 58.14,63.87 65.79,63.87 66.48,63.18 66.76,62.9 69.01,62.9 69.01,62.9 69.41,62.9 69.97,63.46 70.06,63.55 73.86,63.55 75.01,64.7 79.05,64.7 79.05,64.7 87.09,64.7 87.09,64.7 92.93,64.7 94.39,63.24 98.36,63.24 99.26,62.33 104.8,62.33 105.92,61.22 105.92,60 106.15,59.77 107.61,59.77 107.89,60.05 108.97,60.05 v3(109.43,60.51)
  BOTTOM w0.102: v3(109.43,60.51) 109.43,60.36 U0400.AP48
  BOTTOM w0.165: CON2100.122 50.78,63.07 v1(51.26,62.6)
M_B_A8: length 61.3
  TOP w0.165: v2(55.55,62.06) v1(55.55,62.7)
  IN3 w0.152: v1(55.55,62.7) 55.55,62.36 55.68,62.23 56.54,62.23 57.05,62.74 58.93,62.74 59.01,62.82 59.02,62.82 59.28,63.09 59.28,63.09 59.58,63.39 65.47,63.39 66.44,62.42 68.82,62.42 69.61,62.42 70.26,63.07 74.06,63.07 75.2,64.22 92.73,64.22 94.19,62.76 98.26,62.76 99.98,61.03 102.66,61.03 103.04,60.66 103.81,60.66 104.01,60.86 104.01,61.32 104.17,61.47 105.18,61.47 105.66,60.99 105.66,60.15 105.36,59.84 104.14,59.84 v3(103.91,59.62)
  BOTTOM w0.076: U0400.BB48 104.21,59.81 104.02,59.62 v3(103.91,59.62)
  BOTTOM w0.165: v1(55.55,62.7) 55.55,62.22 55.68,62.09 56.22,62.09 56.46,62.32 CON2100.125
M_B_A9: length 63.7
  TOP w0.165: v1(54.23,64.3) v2(53.78,63.85)
  IN3 w0.076: 106.81,61.26 107.02,61.05 108.32,61.05 108.71,61.44 v3(109.39,61.44)
  IN3 w0.152: 106.81,61.26 104.91,63.16 99.45,63.16 98.12,64.49 96.32,64.49 94.44,66.37 85.55,66.37 84.86,65.68 72.1,65.68 71.41,64.99 69.8,64.99 69.2,64.39 68.82,64.39 68.82,64.39 67.77,64.39 67.34,64.82 56.75,64.82 56.74,64.82 54.75,64.82 v1(54.23,64.3)
  BOTTOM w0.089: U0400.AP50 109.39,61.32 v3(109.39,61.44)
  BOTTOM w0.165: CON2100.121 55.2,63.32 v1(54.23,64.3)
M_B_A10: length 65.3
  IN3 w0.152: v1(86.22,57.62) 85.86,57.97 81.64,57.97 81.3,57.63 77.93,54.26 63.61,54.26 63.16,54.71 54.01,54.71 53.52,55.2 52.45,55.2 52.2,55.45 52.2,55.82 51.99,56.04 50.62,56.04 50.5,55.91 50.5,55.4 50.62,55.27 50.98,55.27 51.22,55.03 v1(51.22,54.6)
  BOTTOM w0.076: 103,58.5 103.2,58.5 103.44,58.25 104.24,58.25 104.44,58.05 105.38,58.05 105.59,58.26 106.07,58.26 106.38,58.58 U0400.AW46
  BOTTOM w0.165: v1(86.22,57.62) 86.22,59.14 86.47,59.39 93.21,59.39 93.68,58.93 v2(97.31,58.93) 100.13,58.93 100.37,58.69 101.51,58.69 101.7,58.5 103,58.5 ; v1(51.22,54.6) 51.22,54.93 51.07,55.07 CON2100.146
M_B_A11: length 66.6
  IN3 w0.076: 110.01,60.53 110.37,60.89 110.37,61.58 110.08,61.87
  IN3 w0.152: 110.08,61.87 106.72,61.87 105.95,62.63 105.95,62.75 104.48,64.22 98.83,64.22 97.96,65.08 97.49,65.08 97.33,65.08 95.56,66.85 85.36,66.85 84.66,66.16 71.9,66.16 71.21,65.47 61.62,65.47 61.45,65.3 56.55,65.3 56.55,65.29 53.42,65.29 53.41,65.29 52.42,65.29 v1(51.23,64.1) ; v3(109.99,60.51) 110.01,60.53
  BOTTOM w0.102: U0400.AN48 109.99,60.45 v3(109.99,60.51)
  BOTTOM w0.165: v1(51.23,64.1) 51.23,63.92 50.89,63.57 CON2100.120
M_B_A12: length 67
  TOP w0.165: v1(55.52,64.27) v2(55.52,64.91) ; v3(109.99,61.43) 109.7,61.71 v2(109.7,62)
  IN3 w0.076: v3(109.99,61.43) 109.99,61.08 109.87,60.96 108.58,60.96 108.47,60.85 106.76,60.85
  IN3 w0.152: v1(55.52,64.27) 55.52,63.93 55.65,63.81 56.77,63.81 57.31,64.35 65.98,64.35 66.95,63.38 69.21,63.38 69.49,63.66 69.49,64.01 70,64.51 70.72,64.51 71.21,64.03 71.79,64.03 71.91,64.15 71.91,64.82 72.27,65.18 72.75,65.18 72.95,64.98 72.95,64.22 73.15,64.03 73.54,64.03 73.74,64.22 73.74,64.98 73.94,65.18 85.14,65.18 85.8,65.84 94.23,65.84 96.09,63.99 98.15,63.99 99.33,62.8 104.81,62.8 106.76,60.85
  BOTTOM w0.089: v3(109.99,61.43) 109.99,61.36 U0400.AN50
  BOTTOM w0.165: CON2100.119 56.66,63.82 56.43,63.59 56.24,63.59 56.08,63.75 55.84,63.75 55.68,63.59 55.42,63.59 55.25,63.76 55.25,64 v1(55.52,64.27)
M_B_A13: length 62.5
  TOP w0.165: v1(51.26,51.57) 51.59,51.9 v2(51.59,52.22)
  IN3 w0.152: v3(103.3,56.95) 102.91,56.56 98,56.56 97.87,56.69 91.08,56.69 91.08,56.69 90.53,56.69 88.6,54.76 88.6,54.76 85.52,54.76 82.97,52.21 79.87,52.21 79,51.34 76.54,51.34 74.93,49.73 68.81,49.73 68.81,49.72 67.64,49.72 67.64,49.73 65.7,49.73 65.08,49.1 63.12,49.1 62.43,49.79 58.93,49.79 57.61,51.11 56.76,51.11 56.53,51.34 53.81,51.34 52.99,52.17 51.86,52.17 51.27,51.58 51.27,51.58 v1(51.26,51.57)
  BOTTOM w0.076: v3(103.3,56.95) 103.68,56.57 104.8,56.57 104.89,56.52 105.07,56.52 105.18,56.55 105.18,56.55 105.2,56.56 105.41,56.56 U0400.BA43
  BOTTOM w0.165: CON2100.158 50.82,52.07 51.26,51.64 v1(51.26,51.57)
M_B_A14: length 65.2
  TOP w0.165: v2(55.02,52.86) 54.89,52.73 v1(54.89,52.18)
  IN3 w0.152: v3(102.13,57.02) 98.12,57.02 97.86,57.29 90.45,57.29 90.33,57.17 88.4,55.24 82.29,55.24 81.95,54.9 81.95,54.55 83.02,53.48 83.02,53.2 82.46,52.64 82.18,52.64 81.04,53.78 80.83,53.78 78.87,51.82 75.21,51.82 74.96,51.57 74.96,50.44 74.73,50.2 73.05,50.2 72.86,50.4 72.86,50.46 72.66,50.65 71.87,50.65 71.67,50.46 71.67,50.4 71.47,50.2 70.68,50.2 70.48,50.4 70.48,50.46 70.28,50.65 69.49,50.65 69.29,50.46 69.29,50.4 69.09,50.2 68.61,50.2 68.61,50.2 67.84,50.2 67.83,50.2 65.44,50.2 65.44,50.2 63.57,50.2 63.51,50.14 62.8,50.14 62.48,50.46 62.04,50.46 61.09,51.41 57.98,51.41 57.1,52.3 56.03,52.3 55.58,51.84 55.23,51.84 v1(54.89,52.18)
  BOTTOM w0.076: U0400.AY44 105.84,57.22 105.5,57.22 105.43,57.19 105.22,57.19 105.1,57.22 104.86,57.22 104.85,57.22 104.78,57.19 104.37,57.19 104.03,57.53 102.64,57.53 v3(102.13,57.02)
  BOTTOM w0.165: v1(54.89,52.18) 54.89,52.73 55.98,53.82 CON2100.151
M_B_A15: length 67.4
  TOP w0.165: v1(51.23,53.1) 51.36,53.22 51.36,53.62 v2(51.08,53.9)
  IN3 w0.152: v3(102.75,57.03) 102.75,57.45 102.62,57.58 98.2,57.58 98.01,57.77 90.25,57.77 89.71,57.23 89.7,57.23 89.64,57.16 89.29,57.16 89.29,57.16 89.1,56.98 89.1,56.97 87.93,55.79 87.92,55.79 87.85,55.72 82.09,55.72 78.67,52.3 75.01,52.3 73.84,51.13 68.87,51.13 68.41,50.68 68.04,50.68 68.03,50.68 65.24,50.68 65.24,50.68 64.86,50.68 64.86,50.68 64.81,50.68 64.45,51.05 63.51,51.05 63.51,51.05 63.13,51.05 63.13,51.05 62.16,51.05 61.32,51.89 58.18,51.89 57.3,52.78 55.83,52.78 55.76,52.71 51.72,52.71 51.57,52.56 50.11,52.56 49.86,52.81 49.86,53.55 50.04,53.72 51.1,53.72 51.23,53.6 v1(51.23,53.1)
  BOTTOM w0.076: U0400.AY43 105.93,57.06 105.55,57.06 105.49,57.04 105.46,57.02 105.2,57.02 105.07,57.06 104.9,57.06 104.84,57.03 104.81,57.02 104.3,57.02 103.96,57.36 102.87,57.36 102.75,57.24 v3(102.75,57.03)
  BOTTOM w0.165: v1(51.23,53.1) 51.23,53.02 50.79,52.57 CON2100.156
M_B_A16: length 65.9
  TOP w0.165: v1(53.15,54.6) v2(53.15,53.97)
  IN3 w0.152: v1(87.47,57.62) 87.47,57.36 87.26,57.15 85.44,57.15 85.1,57.49 84.64,57.49 84.3,57.15 83.85,57.15 83.51,57.49 83.06,57.49 82.72,57.15 82.69,57.15 81.5,57.15 81.5,57.15 78.13,53.78 67.37,53.78 67.04,53.45 66.88,53.3 66.08,53.3 66.08,53.29 63.21,53.29 62.73,53.77 62.18,53.77 61.76,53.36 61.36,53.36 61.24,53.48 61.24,54.1 61.11,54.23 53.52,54.23 v1(53.15,54.6)
  BOTTOM w0.076: 103.14,58.26 103.31,58.09 104.17,58.09 104.37,57.89 105.33,57.89 105.54,57.67 106.06,57.67 106.38,57.36 U0400.AW44
  BOTTOM w0.165: v1(53.15,54.6) 53.15,53.81 53.02,53.68 50.59,53.68 50.48,53.57 CON2100.152 ; 103.14,58.26 103.13,58.25 102.09,58.25 102.08,58.23 100.2,58.23 100.08,58.35 93.6,58.35 93,58.95 86.79,58.95 86.66,58.82 86.66,58.4 86.79,58.27 87.15,58.27 87.27,58.14 87.27,57.81 v1(87.47,57.62)
M_B_ACT_N: length 66.2
  TOP w0.165: v2(51.76,65.04) v1(51.23,65.57)
  IN3 w0.076: v3(109.99,63.26) 109.99,63.52 109.8,63.71 108.82,63.71 108.43,64.09 108.43,64.26 108.2,64.5 107.27,64.5 106.91,64.14
  IN3 w0.152: 106.91,64.14 106.11,64.14 104.13,66.12 99.14,66.12 98.74,66.51 98.51,66.51 97.92,66.51 97.66,66.78 96.81,67.62 96.15,68.28 84.76,68.28 84.07,67.59 71.24,67.59 71.05,67.39 66.12,67.39 66.12,67.38 61.27,67.38 61.05,67.6 56.88,67.6 56.53,67.25 54.48,67.25 52.98,65.76 51.43,65.76 v1(51.23,65.57)
  BOTTOM w0.089: U0400.AN53 109.99,63.19 v3(109.99,63.26)
  BOTTOM w0.165: CON2100.114 50.74,65.07 v1(51.23,65.57)
M_B_BA0: length 65.9
  TOP w0.165: v1(52.5,54.6) 52.5,54.84 51.74,55.6 v2(51.56,55.6)
  IN3 w0.152: v1(88.81,57.62) 88.81,57.36 88.63,57.17 88.63,57.17 87.73,56.27 87.72,56.27 87.65,56.2 82.29,56.2 81.89,56.2 81.89,56.2 78.47,52.78 73.58,52.78 73.41,52.61 73.41,51.82 73.2,51.61 70.92,51.61 70.72,51.81 70.72,52.45 70.6,52.58 70.06,52.58 69.93,52.45 69.93,51.81 69.73,51.61 68.44,51.61 68.44,51.61 66.13,51.61 66.13,51.61 62.31,51.61 61.55,52.37 59.09,52.37 58.2,53.25 52.59,53.25 52.2,53.65 52.2,54.29 52.32,54.41 52.32,54.42 v1(52.5,54.6)
  BOTTOM w0.076: U0400.BB44 104.57,57.56 104.24,57.56 104.1,57.69 103.12,57.69 103.07,57.74 102.95,57.74
  BOTTOM w0.165: v1(88.81,57.62) 88.81,57.93 88.94,58.06 89.77,58.06 90.37,57.46 90.81,57.46 90.98,57.63 90.98,57.89 91.15,58.06 91.85,58.06 91.97,57.94 91.97,57.63 92.14,57.46 101.95,57.46 102.06,57.46 102.25,57.65 102.26,57.65 102.34,57.74 102.95,57.74 ; CON2100.150 52.37,54.07 52.5,54.2 v1(52.5,54.6)
M_B_BA1: length 67.2
  TOP w0.165: v2(56.38,53.94) 56.15,53.72 v1(54.87,53.72)
  IN3 w0.152: v1(88.15,57.62) 88.15,57.36 87.53,56.75 87.53,56.75 87.45,56.68 82.49,56.68 81.7,56.68 78.4,53.38 78.4,53.38 78.28,53.25 69.51,53.25 69.29,53.04 69.29,52.28 69.1,52.09 68.64,52.09 68.45,52.28 68.45,53.09 68.24,53.3 67.7,53.3 67.56,53.16 67.56,52.75 67.34,52.53 66.81,52.53 66.52,52.81 63.55,52.81 63.32,52.59 63.32,52.25 63.2,52.12 62.54,52.12 62.38,52.28 62.38,52.73 62.27,52.85 60.1,52.85 59.2,53.75 54.9,53.75 v1(54.87,53.72)
  BOTTOM w0.076: U0400.BA44 105.06,57.71 105.05,57.72 104.31,57.72 104.1,57.92 103.24,57.92 103.17,57.99 103.02,57.99
  BOTTOM w0.165: CON2100.145 55.63,55.32 55.54,55.23 53.94,55.23 53.59,54.89 53.59,53.32 53.72,53.19 54.34,53.19 v1(54.87,53.72) ; 103.02,57.99 102.21,57.99 102.12,57.91 92.91,57.91 v2(92.71,58.11) 92.31,58.51 87.86,58.51 87.73,58.38 87.73,58.04 v1(88.15,57.62)
M_B_BG0: length 65.4
  TOP w0.165: v1(54.38,65.85) 54.09,66.14 v2(53.62,66.14)
  IN3 w0.076: v3(109.41,63.32) 108.66,63.32 108.33,63.66 107.01,63.66
  IN3 w0.152: 107.01,63.66 106.1,63.66 104.02,65.74 98.83,65.74 98.53,66.04 97.88,66.04 97.72,66.04 97.03,66.73 95.96,67.81 84.96,67.81 84.27,67.11 71.5,67.11 71.07,66.68 70.61,66.68 70.38,66.91 69.85,66.91 69.62,66.68 69.62,66.55 69.49,66.42 66.37,66.42 65.89,66.91 61.07,66.91 61.07,66.92 60.85,67.13 57.08,67.13 57.01,67.06 56.73,66.78 55.22,66.78 55.02,66.57 55.02,65.98 54.89,65.85 v1(54.38,65.85)
  BOTTOM w0.089: U0400.AP52 109.73,62.35 109.41,62.68 v3(109.41,63.32)
  BOTTOM w0.165: v1(54.38,65.85) 54.38,64.95 54.51,64.82 CON2100.115
M_B_BG1: length 67.1
  TOP w0.165: v2(57.23,66.58) 56.08,66.58 55.58,66.07 v1(55.58,65.85)
  IN3 w0.152: v1(55.58,65.85) 56.03,66.3 56.48,66.3 57,65.78 57.42,65.78 57.58,65.94 57.58,66.42 57.73,66.58 58.17,66.58 58.32,66.42 58.32,65.97 58.47,65.81 58.95,65.81 59.13,65.99 59.13,66.52 59.26,66.65 60.66,66.65 60.88,66.43 65.69,66.43 65.89,66.23 66.17,65.95 71.01,65.95 71.7,66.63 84.46,66.63 85.16,67.33 95.76,67.33 97.53,65.56 97.68,65.56 98.09,65.56 98.96,64.7 104.45,64.7 105.88,63.27 106.55,63.27 106.83,62.99 106.83,62.39 107.02,62.21 107.45,62.21 108.01,62.77 109.79,62.77 v3(110.21,62.35)
  BOTTOM w0.076: v3(110.21,62.35) 110.38,62.17 U0400.AN52
  BOTTOM w0.165: CON2100.113 54.95,65.32 54.83,65.45 54.83,65.72 54.95,65.85 55.04,65.85 v1(55.58,65.85)
M_B_D0: length 79.9
  TOP w0.102: v1(51.26,87.06) v2(51.26,86.31)
  IN3 w0.097: v3(113.38,69.75) 112.93,70.2 112.93,73.6 113.02,73.69 113.02,75.69 112.96,75.75 112.96,76.61 112.97,76.61 112.97,76.96 112.96,76.97 112.96,78.2 112.72,78.45 112.71,78.45 112.57,78.59 111.97,78.59 109.97,80.59 105.35,85.21 83.83,85.21 83.57,84.94 71.84,84.94 71.78,85 70.66,85 70.08,84.42 65.83,84.42 65.76,84.35 65.76,84.34 65.31,83.9 65.31,83.9 65.29,83.89 63.28,83.89 62.93,84.24 61.67,84.24 60.16,85.75 57.31,85.75 56.95,86.11 52.54,86.11 52.42,85.98 52.42,85.7 52.29,85.58 52.04,85.58 51.91,85.7 51.91,85.98 51.78,86.11 51.44,86.11 51.26,86.29 v1(51.26,87.06)
  BOTTOM w0.089: v3(113.38,69.75) 113.51,69.75 U0400.AF65
  BOTTOM w0.102: CON2100.24 50.74,87.57 v1(51.26,87.06)
M_B_D1: length 78.6
  TOP w0.102: v2(54.38,86.27) v1(54.38,86.91)
  IN3 w0.097: v1(54.38,86.91) 54.97,86.91 55.71,87.65 57.69,87.65 58.22,87.12 60.47,87.12 61.88,85.71 62.88,85.71 63.14,85.45 68.94,85.45 68.94,85.45 69.21,85.45 69.21,85.45 69.65,85.45 70.57,86.37 106.02,86.37 113.7,78.69 113.7,72.53 113.95,72.29 113.95,69.68 v3(113.38,69.11)
  BOTTOM w0.089: v3(113.38,69.11) 113.51,69.11 U0400.AF64
  BOTTOM w0.102: v1(54.38,86.91) 54.8,87.32 CON2100.25
M_B_D2: length 79.4
  TOP w0.102: v1(55.63,84.02) 55.63,83.46 v2(56.03,83.06)
  IN3 w0.097: v1(55.63,84.02) 56.05,84.44 56.43,84.44 56.94,83.93 58.9,83.93 59.84,83.93 61.67,82.1 69.38,82.1 69.51,82.22 69.51,82.76 69.63,82.88 69.89,82.88 70.02,82.76 70.02,82.22 70.14,82.1 70.4,82.1 70.52,82.22 70.52,82.76 70.65,82.88 70.9,82.88 71.03,82.76 71.03,82.22 71.16,82.1 71.41,82.1 71.54,82.22 71.54,82.76 71.67,82.88 71.92,82.88 72.05,82.76 72.05,82.22 72.17,82.1 72.4,82.1 72.53,82.22 72.53,83.24 72.66,83.37 72.91,83.37 73.04,83.24 73.04,82.25 73.19,82.1 73.42,82.1 73.55,82.22 73.55,83.24 73.67,83.37 73.93,83.37 74.05,83.24 74.05,82.88 74.18,82.76 74.6,82.76 74.73,82.88 74.73,83.29 74.85,83.41 105.01,83.41 111.48,76.94 111.48,76.94 111.61,76.81 111.61,74.12 111.56,74.07 111.56,71.72 111.78,71.5 112.17,71.11 112.17,70.33 v3(111.57,69.73)
  BOTTOM w0.089: U0400.AK65 111.71,69.73 v3(111.57,69.73)
  BOTTOM w0.102: v1(55.63,84.02) 56.06,84.45 56.51,84.45 56.63,84.32 CON2100.37
M_B_D3: length 80.2
  TOP w0.102: v2(50.7,82.7) 51.21,83.21 v1(51.21,83.58)
  IN3 w0.097: v1(51.21,83.58) 51.21,83.25 51.08,83.12 50.18,83.12 50.09,83.03 50.09,82.77 50.22,82.64 54.58,82.64 54.85,82.9 56.52,82.9 57.02,82.39 59.92,82.39 61.29,81.03 81.26,81.03 81.38,81.16 81.38,82.26 81.51,82.38 81.76,82.38 81.89,82.26 81.89,81.43 82.02,81.31 82.27,81.31 82.4,81.43 82.4,82.26 82.53,82.38 104.58,82.38 109.68,77.28 109.68,73.75 110.87,72.56 110.87,71.12 111.15,70.84 111.15,69.49 v3(111.53,69.11)
  BOTTOM w0.089: v3(111.53,69.11) 111.68,69.11 U0400.AK64
  BOTTOM w0.102: v1(51.21,83.58) 50.71,84.07 CON2100.38
M_B_D4: length 80.7
  TOP w0.102: v1(55.55,86.87) 55.55,86.51 55.7,86.36 56.74,86.36 v2(57.33,86.95)
  IN3 w0.097: v3(113.37,70.38) 113.72,70.74 113.72,72.18 113.47,72.43 113.47,78.44 105.88,86.03 83.35,86.03 83.22,85.9 83.22,85.82 83.09,85.69 82.84,85.69 82.71,85.82 82.71,85.9 82.58,86.03 82.33,86.03 82.2,85.9 82.2,85.82 82.08,85.69 81.82,85.69 81.69,85.82 81.69,85.9 81.57,86.03 81.31,86.03 81.19,85.9 81.19,85.82 81.06,85.69 80.81,85.69 80.68,85.82 80.68,85.9 80.55,86.03 80.3,86.03 80.17,85.9 80.17,85.82 80.04,85.69 79.79,85.69 79.66,85.82 79.66,85.9 79.54,86.03 79.28,86.03 79.15,85.9 79.15,85.82 79.03,85.69 78.77,85.69 78.65,85.82 78.65,85.9 78.52,86.03 78.27,86.03 78.14,85.9 78.14,85.82 78.01,85.69 77.76,85.69 77.63,85.82 77.63,85.9 77.5,86.03 77.25,86.03 77.12,85.9 77.12,85.82 77,85.69 76.74,85.69 76.61,85.82 76.61,85.9 76.49,86.03 76.23,86.03 76.11,85.9 76.11,85.82 75.98,85.69 75.73,85.69 75.6,85.82 75.6,85.9 75.47,86.03 75.22,86.03 75.09,85.9 75.09,85.82 74.96,85.69 74.71,85.69 74.58,85.82 74.58,85.9 74.46,86.03 74.2,86.03 74.07,85.9 74.07,85.82 73.95,85.69 73.69,85.69 73.57,85.82 73.57,85.9 73.44,86.03 73.19,86.03 73.06,85.9 73.06,85.82 72.93,85.69 72.68,85.69 72.55,85.82 72.55,85.9 72.42,86.03 72.17,86.03 72.04,85.9 72.04,85.82 71.92,85.69 71.66,85.69 71.53,85.82 71.53,85.9 71.41,86.03 70.71,86.03 69.79,85.11 61.94,85.11 60.27,86.78 58.07,86.78 57.55,87.3 55.98,87.3 v1(55.55,86.87)
  BOTTOM w0.089: v3(113.37,70.38) 113.54,70.38 U0400.AF66
  BOTTOM w0.102: CON2100.29 56.1,86.32 v1(55.55,86.87)
M_B_D5: length 78.6
  TOP w0.102: v2(52.46,87.6) v1(51.92,87.06)
  IN3 w0.097: v1(51.92,87.06) 51.92,86.58 52.04,86.45 52.58,86.45 52.71,86.58 52.71,86.85 52.84,86.97 53.09,86.97 53.22,86.85 53.22,86.58 53.35,86.45 57.09,86.45 57.45,86.09 60.37,86.09 61.88,84.58 63.07,84.58 63.42,84.23 65.15,84.23 65.16,84.24 65.17,84.24 65.42,84.49 65.42,84.5 65.68,84.76 69.93,84.76 70.52,85.35 83.41,85.35 83.62,85.55 105.88,85.55 112.4,79.02 112.52,79.02 113.25,78.3 113.25,72.18 113.33,72.1 v3(113.33,71)
  BOTTOM w0.089: U0400.AF67 113.56,71 v3(113.33,71)
  BOTTOM w0.102: v1(51.92,87.06) 51.44,86.57 CON2100.28
M_B_D6: length 77.5
  TOP w0.102: v2(52.46,82.93) v1(51.84,83.55)
  IN3 w0.097: v3(111.53,70.87) 111.53,71 111.1,71.43 111.1,72.65 110.52,73.23 110.52,76.93 104.72,82.73 80.87,82.73 80.69,82.54 80.69,81.51 80.56,81.38 80.31,81.38 80.18,81.51 80.18,82.31 80.05,82.44 79.8,82.44 79.67,82.31 79.67,81.51 79.55,81.38 79.29,81.38 79.16,81.51 79.16,82.31 79.04,82.44 78.78,82.44 78.66,82.31 78.66,81.51 78.53,81.38 61.42,81.38 60.06,82.74 57.17,82.74 56.66,83.24 52.89,83.24 52.79,83.15 52.25,83.15 v1(51.84,83.55)
  BOTTOM w0.089: U0400.AK67 111.87,70.87 v3(111.53,70.87)
  BOTTOM w0.102: v1(51.84,83.55) 51.84,83.48 51.44,83.07 CON2100.42
M_B_D7: length 78.5
  TOP w0.102: v1(54.38,83.98) 54.38,83.28 v2(54.2,83.11)
  IN3 w0.097: v1(54.38,83.98) 54.38,83.71 54.5,83.58 56.8,83.58 57.31,83.08 60.2,83.08 61.55,81.74 75.07,81.74 75.2,81.87 75.2,82.81 75.32,82.93 75.58,82.93 75.7,82.81 75.7,81.87 75.83,81.74 76.09,81.74 76.21,81.87 76.21,82.81 76.34,82.93 76.59,82.93 76.72,82.81 76.72,81.87 76.85,81.74 77.1,81.74 77.23,81.87 77.23,82.81 77.36,82.93 77.61,82.93 77.74,82.81 77.74,82.63 77.86,82.5 78.12,82.5 78.24,82.63 78.24,82.92 78.39,83.07 104.86,83.07 110.75,77.18 110.75,77.02 110.75,73.43 111.33,72.85 111.33,71.62 111.92,71.03 111.92,70.66 v3(111.57,70.31)
  BOTTOM w0.089: U0400.AK66 111.79,70.08 v3(111.57,70.31)
  BOTTOM w0.102: CON2100.41 54.58,83.32 54.38,83.53 v1(54.38,83.98)
M_B_D8: length 84.9
  TOP w0.102: v1(52.08,92.31) v2(52.08,91.67)
  IN3 w0.097: v1(52.08,92.31) 52.97,93.2 57.61,93.2 57.97,92.83 62.06,92.83 63.99,90.9 71.63,90.9 71.84,90.69 73.04,90.69 73.43,90.3 100.86,90.3 101.37,90.82 104.54,90.82 105.14,90.22 107.64,90.22 110.36,87.51 111.23,87.51 117.42,81.31 117.42,76.44 v3(115.33,74.35)
  BOTTOM w0.102: v3(115.33,74.35) 114.94,73.95 114.94,73.67 114.14,72.88 U0400.AF70 ; CON2100.8 51.69,91.57 52.08,91.96 v1(52.08,92.31)
M_B_D9: length 86.8
  TOP w0.102: v1(55.52,93.63) v2(55.52,94.31)
  IN3 w0.097: v3(115.33,73.73) 117.78,76.18 117.78,81.56 111.49,87.85 110.5,87.85 107.81,90.53 105.27,90.53 104.67,91.13 101.24,91.13 100.76,90.65 73.64,90.65 73.25,91.04 71.98,91.04 71.78,91.24 70.62,91.24 70.49,91.37 70.49,91.82 70.36,91.95 70.11,91.95 69.98,91.82 69.98,91.37 69.86,91.24 69.6,91.24 69.48,91.37 69.48,91.82 69.35,91.95 69.09,91.95 68.97,91.82 68.97,91.37 68.84,91.24 64.16,91.24 62.23,93.17 58.12,93.17 57.61,93.68 57.61,93.68 56.77,94.52 55.17,94.52 55.04,94.39 55.04,94.11 v1(55.52,93.63)
  BOTTOM w0.076: 114.45,72.8 114.45,71.96 114.21,71.72 114.04,71.38 U0400.AF68
  BOTTOM w0.102: 114.45,72.8 114.45,72.84 v3(115.33,73.73) ; CON2100.3 56.47,92.82 56.41,92.77 55.98,92.77 55.52,93.23 v1(55.52,93.63)
M_B_D10: length 84.4
  TOP w0.102: v2(54.17,88.46) v1(54.17,89.09)
  IN3 w0.097: v1(54.17,89.09) 52.35,89.09 52.16,89.28 52.16,89.65 51.77,90.05 51.77,90.93 51.99,91.16 53.03,91.16 53.15,91.05 53.46,91.05 53.85,90.66 57.04,90.66 58.91,88.78 61.67,88.78 62.44,88.01 62.46,88.01 63.08,87.39 69.24,87.39 69.88,88.04 106.71,88.04 115.41,79.34 115.41,78.35 v1(114.63,77.57)
  BOTTOM w0.076: U0400.AH71 112.82,73.5 112.92,73.6 112.92,74.24 113.43,74.75 113.43,75.02 113.49,75.09 113.49,75.24
  BOTTOM w0.102: v1(114.63,77.57) 114.07,77.02 114.07,76.85 113.49,76.26 113.49,75.24 ; v1(54.17,89.09) 54.58,89.51 55.52,89.51 55.54,89.49 55.61,89.49 55.62,89.49 56.25,89.49 56.41,89.32 CON2100.17
M_B_D11: length 87.5
  TOP w0.102: v2(50.11,88.62) 50.63,88.62 v1(51.18,88.07)
  IN3 w0.097: v3(114.13,74.04) 114.58,74.49 114.58,74.86 113.93,75.5 113.93,76.72 114.17,76.96 114.17,79.12 106.29,87.01 70.31,87.01 69.65,86.35 69.21,86.35 62.14,86.35 60.73,87.76 58.48,87.76 57.96,88.28 54.63,88.28 54.51,88.15 54.51,87.66 54.39,87.54 54.14,87.54 54,87.68 54,88.15 53.87,88.28 53.51,88.28 53.38,88.15 53.38,87.82 53.25,87.69 53,87.69 52.87,87.82 52.87,88.15 52.75,88.28 52.49,88.28 52.37,88.15 52.37,87.82 52.24,87.69 51.98,87.69 51.86,87.82 51.86,88.45 51.66,88.65 49.93,88.65 49.76,88.47 49.76,87.66 49.88,87.53 51.05,87.53 51.18,87.66 v1(51.18,88.07)
  BOTTOM w0.076: U0400.AH68 113.47,71.38 113.75,71.66 113.75,72.46 113.71,72.56 113.71,72.82 113.75,72.91 113.75,73.11 113.71,73.2 113.71,73.62 v3(114.13,74.04)
  BOTTOM w0.102: CON2100.20 50.68,88.57 v1(51.18,88.07)
M_B_D12: length 84.1
  TOP w0.102: v1(50.82,92.39) v2(50.82,93.03)
  IN3 w0.097: v1(115.49,75.39) 115.89,75.39 117.06,76.56 117.06,81.17 116.94,81.28 116.94,81.29 111.07,87.16 110.21,87.16 107.47,89.91 105.01,89.91 104.42,90.5 101.5,90.5 100.96,89.96 69.18,89.96 69.09,89.87 63.21,89.87 60.59,92.49 57.83,92.49 57.47,92.85 53.81,92.85 53.12,92.17 53.12,92.16 52.88,91.91 52.87,91.91 52.81,91.85 51.35,91.85 51.05,92.15 51.05,92.16 v1(50.82,92.39)
  BOTTOM w0.102: CON2100.4 50.4,92.57 50.59,92.39 v1(50.82,92.39) ; U0400.AF71 114.3,73.33 114.73,73.77 114.73,75.04 115.08,75.39 v1(115.49,75.39)
M_B_D13: length 86.4
  TOP w0.102: v2(53.98,91.26) v1(53.98,91.9)
  IN3 w0.097: v1(53.98,91.9) 53.98,91.52 53.85,91.39 53.29,91.39 53.16,91.52 53.16,91.7 53.98,92.51 57.32,92.51 57.69,92.14 59.4,92.14 59.59,91.95 59.59,91.72 59.72,91.59 59.97,91.59 60.1,91.72 60.1,92.03 60.21,92.14 60.45,92.14 63.07,89.52 69.23,89.52 69.32,89.62 101.06,89.62 101.63,90.19 104.29,90.19 104.88,89.6 107.3,89.6 110.07,86.82 110.92,86.82 116.6,81.14 116.72,81.03 116.72,76.82 116.34,76.45 116.34,76.44 116.17,76.26 116.17,76.12 116.04,76 v1(115.67,76)
  BOTTOM w0.076: 114.54,73.92 114.54,73.89 114.29,73.65 114.03,73.65 113.87,73.49 113.87,73.23 113.91,73.14 113.91,72.88 113.87,72.79 113.87,72.58 113.91,72.5 113.94,72.4 114.04,72.3 U0400.AF69
  BOTTOM w0.102: CON2100.7 54.05,91.82 v1(53.98,91.9) ; v1(115.67,76) 115.41,76 114.54,75.12 114.54,73.92
M_B_D14: length 85
  TOP w0.102: v2(55.95,88.46) 55.95,88.58 v1(55.44,89.09)
  IN3 w0.097: v1(114.63,78.18) 115.06,78.62 115.06,79.2 106.57,87.69 70.02,87.69 69.37,87.04 62.45,87.04 61.04,88.44 58.76,88.44 57.68,89.53 57.5,89.53 57.11,89.15 56.93,89.15 56.75,89.32 56.75,89.5 57.14,89.89 57.14,90.07 56.89,90.31 53.71,90.31 53.31,90.71 53.01,90.71 52.89,90.82 52.24,90.82 52.11,90.69 52.11,90.19 52.5,89.8 52.5,89.64 52.6,89.54 54.99,89.54 v1(55.44,89.09)
  BOTTOM w0.076: U0400.AH70 112.58,72.92 112.58,73.15 112.57,73.19 112.55,73.23 112.55,73.49 112.76,73.7 112.76,74.31 113.26,74.81 113.26,75.26
  BOTTOM w0.102: v1(55.44,89.09) 56.2,88.32 CON2100.21 ; 113.26,75.26 113.26,76.4 113.46,76.61 113.46,77.02 v1(114.63,78.18)
M_B_D15: length 85.8
  TOP w0.102: v2(51.71,89.54) v1(51.26,89.09)
  IN3 w0.097: v1(51.26,89.09) 50.78,89.56 50.04,89.56 49.91,89.69 49.91,91.19 50.41,91.7 50.93,91.7 51.16,91.47 51.16,90.17 51.82,89.51 51.82,89.05 52.25,88.62 58.1,88.62 58.62,88.1 60.9,88.1 62.31,86.69 69.51,86.69 70.17,87.35 106.43,87.35 114.63,79.15 v1(114.63,78.84)
  BOTTOM w0.076: U0400.AH69 112.82,72.24 112.42,72.63 112.42,73.12 112.38,73.19 112.38,73.56 112.59,73.77 112.59,74.38 113.06,74.85 113.06,75.26
  BOTTOM w0.102: CON2100.16 50.77,89.57 v1(51.26,89.09) ; 113.06,75.26 113.06,77.08 114.15,78.16 114.15,78.36 v1(114.63,78.84)
M_B_D16: length 70
  TOP w0.102: v2(56.9,79.3) 56.52,78.92 56.1,78.92 v1(55.65,78.47)
  IN3 w0.097: v3(108.16,70.55) 108.16,72.52 106.45,74.22 106.45,74.39 105.03,75.81 105.03,77.04 103.2,78.87 101.07,78.87 100.94,79 100.94,79.03 100.82,79.16 100.56,79.16 100.44,79.03 100.44,79 100.31,78.87 100.06,78.87 99.93,79 99.93,79.03 99.8,79.16 99.55,79.16 99.42,79.03 99.42,79 99.29,78.87 99.04,78.87 98.91,79 98.91,79.03 98.79,79.16 98.53,79.16 98.4,79.03 98.4,79 98.28,78.87 96.14,78.87 95.8,78.87 95.67,79 95.67,79.08 95.54,79.21 95.29,79.21 95.16,79.08 95.16,79 95.04,78.87 94.78,78.87 94.65,79 94.65,79.08 94.53,79.21 94.27,79.21 94.15,79.08 94.15,79 94.07,78.92 94.02,78.87 93.77,78.87 93.64,79 93.64,79.08 93.51,79.21 93.26,79.21 93.13,79.08 93.13,79 93,78.87 92.75,78.87 92.62,79 92.62,79.08 92.5,79.21 92.24,79.21 92.11,79.08 92.11,79 91.99,78.87 91.73,78.87 91.61,79 91.61,79.08 91.48,79.21 91.23,79.21 91.1,79.08 91.1,79 90.97,78.87 90.72,78.87 90.59,79 90.59,79.08 90.46,79.21 90.21,79.21 90.08,79.08 90.08,79 89.96,78.87 89.7,78.87 89.57,79 89.57,79.08 89.45,79.21 89.19,79.21 89.07,79.08 89.07,79 88.94,78.87 88.69,78.87 88.56,79 88.56,79.08 88.43,79.21 88.18,79.21 88.05,79.08 88.05,79 87.92,78.87 87.67,78.87 87.54,79 87.54,79.08 87.42,79.21 87.16,79.21 87.03,79.08 87.03,79 86.91,78.87 85.59,78.87 84.05,77.33 83.52,77.33 83.39,77.46 83.39,77.51 83.27,77.64 83.01,77.64 82.89,77.51 82.89,77.46 82.76,77.33 82.5,77.33 82.38,77.46 82.38,77.51 82.25,77.64 82,77.64 81.87,77.51 81.87,77.46 81.74,77.33 81.49,77.33 81.36,77.46 81.36,77.51 81.23,77.64 80.98,77.64 80.85,77.51 80.85,77.46 80.73,77.33 80.47,77.33 80.35,77.46 80.35,77.51 80.22,77.64 79.96,77.64 79.84,77.51 79.84,77.46 79.71,77.33 79.46,77.33 79.33,77.46 79.33,77.51 79.2,77.64 78.95,77.64 78.82,77.51 78.82,77.46 78.69,77.33 78.44,77.33 78.31,77.46 78.31,77.51 78.19,77.64 77.93,77.64 77.81,77.51 77.81,77.46 77.68,77.33 77.42,77.33 77.3,77.46 77.3,77.51 77.17,77.64 76.92,77.64 76.79,77.51 76.79,77.46 76.66,77.33 58.59,77.33 57.03,78.89 56.07,78.89 v1(55.65,78.47)
  BOTTOM w0.102: v1(55.65,78.47) 55.65,78.51 56.02,78.88 56.44,78.88 56.49,78.82 CON2100.59 ; U0400.AT66 108.16,70.39 v3(108.16,70.55)
M_B_D17: length 68.9
  TOP w0.102: v1(55.6,77.48) 55.6,76.89 v2(55.55,76.84)
  IN3 w0.097: v3(107.41,70.56) 107.41,72.53 106.12,73.81 105.99,73.94 105.99,74.2 104.47,75.72 104.47,76.62 104.12,76.97 104.12,76.97 102.9,78.19 96.42,78.19 96.42,78.19 85.87,78.19 84.34,76.65 83.99,76.65 72.79,76.65 72.66,76.52 72.66,76.25 72.54,76.13 72.28,76.13 72.15,76.25 72.15,76.52 72.03,76.65 71.77,76.65 71.65,76.52 71.65,76.25 71.52,76.13 71.27,76.13 71.14,76.25 71.14,76.52 71.01,76.65 70.76,76.65 70.63,76.52 70.63,76.25 70.5,76.13 70.25,76.13 70.12,76.25 70.12,76.52 70,76.65 69.74,76.65 69.61,76.52 69.61,76.25 69.49,76.13 66.75,76.13 66.63,76.25 66.63,76.41 66.5,76.53 66.22,76.53 66.09,76.41 66.09,76.25 65.96,76.13 62.89,76.13 62.76,76.25 62.76,76.52 62.63,76.65 62.38,76.65 62.25,76.52 62.25,76.25 62.12,76.13 61.87,76.13 61.74,76.25 61.74,76.52 61.62,76.65 61.36,76.65 61.24,76.52 61.24,76.25 61.11,76.13 60.85,76.13 60.73,76.25 60.73,76.52 60.6,76.65 60.35,76.65 60.22,76.52 60.22,76.25 60.09,76.13 59.84,76.13 59.71,76.25 59.71,76.52 59.58,76.65 59.33,76.65 59.2,76.52 59.2,76.25 59.08,76.13 58.73,76.13 57.81,77.05 57.42,77.05 57.29,77.18 57.29,77.52 57.17,77.65 56.91,77.65 56.78,77.52 56.78,77.18 56.65,77.05 55.73,77.05 55.6,77.18 v1(55.6,77.48)
  BOTTOM w0.102: v1(55.6,77.48) 55.6,77.84 55.78,78.02 56.36,78.02 56.55,77.82 CON2100.63 ; v3(107.41,70.56) 107.41,70.5 107.78,70.12 U0400.AU66
M_B_D18: length 72.7
  TOP w0.102: v2(49.76,81.23) 49.89,81.1 50.71,81.1 v1(51.21,81.6)
  IN3 w0.097: v1(51.21,81.6) 51.21,81.21 51.71,80.7 59.26,80.7 60.8,79.16 80.87,79.16 83.74,79.16 85.3,80.72 103.89,80.72 107.21,77.4 107.21,75.77 107.37,75.62 107.37,74.37 109.02,72.72 109.02,70.4 109.25,70.17 109.55,70.17 v3(110.06,69.66)
  BOTTOM w0.089: v3(110.06,69.66) 109.73,69.34 U0400.AP65
  BOTTOM w0.102: v1(51.21,81.6) 50.73,82.07 CON2100.46
M_B_D19: length 72.6
  TOP w0.102: v1(55.45,81.88) v2(55.45,81.08)
  IN3 w0.076: v3(110.63,69.66) 110.96,70 110.96,70.76 110.66,71.07
  IN3 w0.097: 110.66,71.07 110.26,71.47 110.26,72.47 109.17,73.56 109.17,75.14 109.04,75.26 109.04,77.02 104.32,81.75 84.87,81.75 84.28,81.16 84.1,81.16 83.91,81.35 83.74,81.35 83.56,81.17 83.56,80.99 83.74,80.8 83.74,80.62 83.31,80.19 82.8,80.19 82.68,80.32 82.68,80.55 82.55,80.67 82.3,80.67 82.17,80.55 82.17,80.34 82.02,80.19 81.46,80.19 81.26,80.39 80.95,80.39 80.75,80.19 80.45,80.19 80.24,80.39 79.94,80.39 79.73,80.19 79.43,80.19 79.23,80.39 78.92,80.39 78.72,80.19 78.41,80.19 78.21,80.39 77.91,80.39 77.7,80.19 77.4,80.19 77.19,80.39 76.89,80.39 76.69,80.19 76.38,80.19 76.18,80.39 75.87,80.39 75.67,80.19 75.37,80.19 75.16,80.39 74.86,80.39 74.65,80.19 74.35,80.19 74.15,80.39 73.84,80.39 73.64,80.19 73.33,80.19 73.13,80.39 72.83,80.39 72.62,80.19 72.32,80.19 72.11,80.39 71.81,80.39 71.61,80.19 71.3,80.19 71.1,80.39 70.79,80.39 70.59,80.19 70.29,80.19 70.08,80.39 69.78,80.39 69.57,80.19 61.23,80.19 59.66,81.76 56.76,81.76 56.26,82.26 55.84,82.26 v1(55.45,81.88)
  BOTTOM w0.089: U0400.AN65 110.38,69.42 v3(110.63,69.66)
  BOTTOM w0.102: v1(55.45,81.88) 55.9,82.32 CON2100.45
M_B_D20: length 71.7
  TOP w0.102: v1(54.15,81.85) v2(53.69,81.39)
  IN3 w0.097: v1(54.15,81.85) 53.37,81.85 53.24,81.72 53.24,81.54 53.37,81.42 59.51,81.42 61.08,79.85 81.16,79.85 83.45,79.85 85.01,81.41 104.17,81.41 107.65,77.94 107.65,76.05 107.98,75.72 108.2,75.72 108.97,74.96 108.97,73.46 110.05,72.38 110.05,70.63 v3(109.98,70.56)
  BOTTOM w0.089: U0400.AN66 109.98,70.52 v3(109.98,70.56)
  BOTTOM w0.102: CON2100.49 54.68,81.32 v1(54.15,81.85)
M_B_D21: length 70.6
  TOP w0.102: v2(51.84,80.96) v1(51.84,81.6)
  IN3 w0.097: v3(109.42,70.56) 109.42,71.18 109.26,71.34 109.26,72.84 108.76,73.33 108.76,74.86 108.13,75.49 107.82,75.49 107.44,75.87 107.44,77.3 107.44,77.3 107.44,77.49 107.44,77.65 104.03,81.06 85.16,81.06 83.6,79.5 81.98,79.5 60.94,79.5 59.37,81.07 53.22,81.07 53.09,81.21 52.65,81.21 52.65,81.2 52.3,81.2 52.3,81.21 52.23,81.21 v1(51.84,81.6)
  BOTTOM w0.089: v3(109.42,70.56) 109.42,70.43 U0400.AP66
  BOTTOM w0.102: CON2100.50 51.32,81.07 v1(51.84,81.6)
M_B_D22: length 70.6
  TOP w0.102: v2(52.5,78.07) v1(51.99,78.57)
  IN3 w0.076: 107.79,70.88 107.79,69.92 v3(108.07,69.64)
  IN3 w0.097: v1(51.99,78.57) 53.01,78.57 53.14,78.7 53.14,79.91 53.26,80.04 53.52,80.04 53.65,79.91 53.65,78.69 53.77,78.56 54.89,78.56 55.46,77.99 57.45,77.99 58.45,76.99 65.1,76.99 65.23,76.86 65.23,76.78 65.43,76.58 65.61,76.58 65.74,76.71 65.74,76.86 65.86,76.99 84.19,76.99 85.73,78.53 96.28,78.53 103.04,78.53 104.26,77.31 104.78,76.8 104.78,75.74 106.22,74.29 106.22,74.09 107.79,72.53 107.79,70.88
  BOTTOM w0.089: U0400.AT65 108.07,69.56 v3(108.07,69.64)
  BOTTOM w0.102: CON2100.62 51.49,78.07 v1(51.99,78.57)
M_B_D23: length 70
  TOP w0.102: v2(50.71,77.94) 50.71,77.95 v1(51.33,78.57)
  IN3 w0.076: v3(107.49,69.62) 107.03,70.08 107.03,70.94
  IN3 w0.097: 107.03,70.94 107.03,72.58 106.03,73.59 105.77,73.85 105.77,74.09 104.24,75.62 104.24,76.36 102.76,77.84 96.57,77.84 86.02,77.84 84.48,76.3 84.13,76.3 84.13,76.3 73.25,76.3 72.73,75.78 58.59,75.78 57.67,76.71 55.44,76.71 55.18,76.96 55.18,77.74 54.83,78.09 54.75,78.09 54.35,78.09 53.44,78.09 53.34,78 53.34,77.49 53.24,77.4 53.05,77.4 52.95,77.49 52.95,78 52.86,78.09 52.66,78.09 52.57,78 52.57,77.49 52.47,77.4 52.28,77.4 52.18,77.49 52.18,78 52.08,78.09 51.82,78.09 v1(51.33,78.57)
  BOTTOM w0.089: U0400.AU65 107.49,69.49 v3(107.49,69.62)
  BOTTOM w0.102: CON2100.58 50.83,79.07 v1(51.33,78.57)
M_B_D24: length 67.6
  TOP w0.102: v1(51.89,76.54) v2(51.89,75.91)
  IN3 w0.097: v3(108.1,67.82) 108.09,67.82 105.81,70.11 105.81,70.16 105.81,72.26 104.66,73.4 103.28,74.79 103.28,75.46 102.21,76.52 100.1,76.52 97.11,76.52 86.56,76.52 85.02,74.98 84.68,74.98 79.72,74.98 78.96,74.22 57.87,74.22 57.23,74.87 53.16,74.87 51.89,76.14 v1(51.89,76.54)
  BOTTOM w0.089: v3(108.1,67.82) 108.1,67.71 U0400.AT61
  BOTTOM w0.102: v1(51.89,76.54) 51.89,76.49 51.48,76.07 CON2100.70
M_B_D25: length 67.8
  TOP w0.102: v2(50.09,76.05) 50.77,76.05 v1(51.28,76.57)
  IN3 w0.097: v3(107.47,67.82) 107.47,68.1 105.58,69.99 105.58,70.06 105.58,70.06 105.58,70.44 105.58,70.44 105.58,72.16 105.04,72.7 104.17,73.57 103.02,74.72 103.02,75.23 102.07,76.18 100.25,76.18 100.25,76.18 99.28,76.18 97.26,76.18 97.26,76.18 86.71,76.18 85.17,74.64 84.82,74.64 79.87,74.64 79.1,73.88 57.73,73.88 57.08,74.52 53.02,74.52 51.28,76.26 v1(51.28,76.57)
  BOTTOM w0.089: U0400.AU61 107.47,67.68 v3(107.47,67.82)
  BOTTOM w0.102: CON2100.66 50.78,77.07 v1(51.28,76.57)
M_B_D26: length 70.6
  TOP w0.102: v1(51.92,73.09) 52.35,72.66 v2(52.35,72.39)
  IN3 w0.076: 107.15,65.88 107.39,65.64 108.88,65.64 109.14,65.9 109.14,66.6 v3(109.47,66.93)
  IN3 w0.097: 107.15,65.88 105.58,67.44 105.58,68.31 103.11,70.79 102.84,71.06 102.84,71.33 102.84,71.34 102.84,71.46 102.83,71.47 102.83,72.31 101.16,73.98 98.36,73.98 97.46,73.07 95.98,71.59 73.38,71.59 72.59,70.8 65.69,70.8 65.53,70.64 62.62,70.64 61.96,71.3 60.89,71.3 60.88,71.29 57.01,71.29 56.81,71.49 56.8,71.49 56.71,71.58 52.19,71.58 51.92,71.86 v1(51.92,73.09)
  BOTTOM w0.089: U0400.AP60 109.47,66.72 v3(109.47,66.93)
  BOTTOM w0.102: v1(51.92,73.09) 51.41,72.57 CON2100.84
M_B_D27: length 71.1
  TOP w0.102: v2(50.56,72.39) v1(51.26,73.09)
  IN3 w0.076: v3(110.06,66.93) 109.63,66.5 109.63,66.11 108.96,65.45 107.25,65.45
  IN3 w0.097: 107.25,65.45 105.36,67.34 105.36,68.06 102.6,70.82 102.5,70.92 102.5,71.05 102.5,71.3 102.5,71.33 102.49,71.46 102.49,72.16 101.02,73.64 98.51,73.64 97.7,72.83 96.12,71.25 84.03,71.25 73.52,71.25 72.73,70.45 65.83,70.45 65.67,70.3 62.47,70.3 62.05,70.72 62.05,70.72 61.82,70.95 61.03,70.95 61.03,70.95 56.87,70.95 56.67,71.15 56.66,71.15 56.57,71.24 51.98,71.24 51.26,71.96 v1(51.26,73.09)
  BOTTOM w0.089: v3(110.06,66.93) 110.06,66.78 U0400.AN60
  BOTTOM w0.102: CON2100.80 50.77,73.57 v1(51.26,73.09)
