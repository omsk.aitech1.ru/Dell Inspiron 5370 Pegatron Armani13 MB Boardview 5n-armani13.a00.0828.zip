# Allegro board 5n-armani13.a00.0828.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ISH_I2C0_SDA: length 24.7
  BOTTOM w0.076: 121.58,30.89 121.16,31.3 121.16,32.2 120.87,32.5 120.87,32.81 120.9,32.9 120.9,33.13 120.87,33.27 120.87,33.46 120.9,33.55 120.9,33.79 120.87,33.91 120.87,34.39 U0400.M4
  BOTTOM w0.102: Q3701.3 122.04,17.39 121.69,17.73 121.69,18.8 121.95,19.05 122.68,19.05 122.94,19.31 v2(122.94,19.74) 122.94,20.04 123.67,20.78 124.33,20.78 125.12,21.57 125.12,22.39 R3713.2 125.79,23.07 125.93,23.07 126.44,23.58 126.44,25.56 126.19,25.82 124.38,25.82 123.63,26.57 123.05,26.57 122.63,26.99 122.63,27.41 122.1,27.94 122.1,29.46 122.09,29.47 122.09,30.38 121.58,30.89
ISUM_A_R: length 4.7
  TOP w0.254: PR7805.2 144.55,65.64 v2(143.97,65.64) v1(142.6,65.64)
  BOTTOM w0.254: v1(142.6,65.64) 143.71,65.64 PRT7801.1
ISUMN_A_R: length 1.8
  TOP w0.229: PC7811.1 179.1,45.29 178.89,45.49 PR7809.2 v2(178.89,46.74)
ISUMN_A_VCPU: length 3.9
  TOP w0.229: v1(178.08,46.64) 178.03,46.59 PR7809.1 178.16,45.75 PR7810.1 177.65,45.04 v2(177.27,44.66)
  BOTTOM w0.229: v1(178.08,46.64) 177.95,46.64 177.65,46.94 177.65,47.08 177.48,47.25 PU7800.20
ISUMN_B_VCPU: length 6.6
  TOP w0.254: v1(177.54,54.18) 177.65,54.08 178.08,54.08 PR7853.2 v2(178.51,55.27)
  BOTTOM w0.229: 177.74,53.3 176.81,53.3 PC7805.1 176.29,52.24 175.9,51.85 PU7800.8
  BOTTOM w0.254: 177.74,53.3 PR7806.2 177.7,54.18 v1(177.54,54.18)
ISUMN_B_VCPU_R: length 2.1
  BOTTOM w0.254: PC7805.2 177.55,52.78 177.56,52.79 PR7804.2 178.16,51.74 v2(178.13,51.72)
ISUMN_C_R: length 7
  TOP w0.254: v2(168.38,44.12) 168.86,44.6 PR7835.2 PC7830.1 172.55,44.6 v1(173.14,45.19)
  BOTTOM w0.229: PU7800.28 173.9,46.35 173.14,45.58 v1(173.14,45.19)
ISUMN_C_RR: length 2
  TOP w0.254: v2(171.53,41.94) 171.53,42.45 171.42,42.55 PR7838.2 171.42,43.36 PC7830.2
ITP_PMODE: length 14.7
  IN2 w0.102: v3(124.82,36.76) 127.99,36.76 128.55,36.2 129.11,36.2 v3(129.54,35.77)
  BOTTOM w0.076: 129.54,35.77 v3(129.54,35.77)
  BOTTOM w0.102: U0400.E8 124.82,36.95 v3(124.82,36.76) ; 129.54,35.77 130.71,35.77 131.37,36.43 131.37,38.38 132.64,39.65 134.09,39.65 T0901.1
KB_DET#: length 81.8
  TOP w0.076: 115.46,30.89 115.46,32.9 114.57,33.79 v3(114.57,35.14)
  TOP w0.102: 115.46,30.89 115.46,29.76 117.23,27.99 117.23,27.99 117.48,27.74 117.48,27.74 118.19,27.03 118.19,25.89 118.31,25.76 118.31,25.12 118.19,25 118.19,24.41 117.04,23.27 115.93,23.27 115.04,22.38 114.53,22.38 114.4,22.51 v1(113.72,22.51) 113.28,22.51 v2(113.11,22.33) ; v1(105.59,21.49) 105.41,21.49 104.88,20.96 104.88,18.24 103.13,16.49 101.2,16.49 99.05,14.34 v1(98.77,14.34)
  IN2 w0.102: v1(64.49,13.64) 64.49,13.21 65.13,12.58 67.54,12.58 68.36,11.76 82.43,11.76 83.17,12.5 96.23,12.5 98.07,14.34 v1(98.77,14.34)
  IN3 w0.102: v1(105.59,21.49) 105.97,21.11 110.06,21.11 110.62,21.67 112.45,21.67 113.28,22.51 v1(113.72,22.51)
  BOTTOM w0.102: v3(114.57,35.14) 114.5,35.08 U0400.AD4 ; R1518.2 97.16,13.39 97.16,13.92 97.57,14.34 v1(98.77,14.34) ; v1(64.49,13.64) 64.49,13.34 64.92,12.91 66.3,12.91 66.43,12.78 CON5102.30
KB_LED_BL_DET: length 83.8
  IN1 w0.102: v1(119.99,21.19) 120.47,20.7 120.47,19.83 121.4,18.9 121.93,18.9 122.31,19.28 126.8,19.28 131.49,14.59 137.35,14.59 138.58,13.36 143.77,13.36 143.84,13.44 149.33,13.44 v1(149.71,13.82)
  IN2 w0.076: v3(117.7,37.06) 118.14,36.63 118.14,35.58 120.14,33.57 120.14,32.57 121.28,31.43 121.28,30.89
  IN2 w0.102: v1(149.71,13.82) 149.71,14.23 151.25,15.77 154.78,15.77 155.87,14.68 168.5,14.68 v1(169.39,13.79) ; v1(122.12,24.54) 122.12,25.4 121.28,26.25 121.28,30.89
  IN3 w0.102: v1(122.12,24.54) 122.12,23.97 119.99,21.84 v1(119.99,21.19)
  BOTTOM w0.102: U0400.W8 117.38,36.74 v3(117.7,37.06) ; v1(149.71,13.82) v2(149.71,14.53) ; R5101.1 169.73,20.23 169.46,19.96 R5110.1 169.46,19.01 169.8,18.67 169.8,16.89 169.39,16.49 v1(169.39,13.79)
KB_LED_BL_DET_R: length 1.9
  BOTTOM w0.432: CON5101.2 171.38,18.37 v2(171.21,18.54) R5101.2
KB_LED_PWM: length 171.9
  TOP w0.102: v1(86.7,6.09) 86.5,6.3 85.95,6.3 v1(84.24,8.01) ; v1(28.02,37.86) 27.98,37.9 U2300.44 25.61,37.9 25.45,38.05 25.07,38.05 25.04,38.03 R2347.2 ; v2(68.01,11.53) v1(68.01,10.86)
  IN1 w0.102: v1(68.01,10.86) 68.58,10.29 68.58,8.64 69.14,8.08 75.49,8.08 76,7.57 83.8,7.57 v1(84.24,8.01)
  IN2 w0.102: v1(156.16,12.32) 154.61,10.77 150.42,10.77 150.06,10.42 147.02,10.42 146.81,10.62 141.78,10.62 141.45,10.95 139.01,10.95 137.93,9.86 108.65,9.86 108.13,10.39 107.57,10.39 106.96,9.78 105.12,9.78 103.05,7.71 103.05,5.98 100.55,3.48 96.77,3.48 94,6.25 90.88,6.25 90.32,5.69 87.1,5.69 v1(86.7,6.09)
  IN3 w0.102: v1(28.02,37.86) 28.77,37.11 28.77,30.6 32.56,26.8 32.56,25.55 34.49,23.62 34.49,20.97 34.73,20.73 37.19,20.73 39.7,18.21 42.88,18.21 43.1,18.44 46.64,18.44 49,16.09 49,13.12 51.63,10.49 54.78,10.49 55.18,10.09 60.69,10.09 61.68,11.08 67.79,11.08 v1(68.01,10.86)
  BOTTOM w0.102: v1(156.16,12.32) 156.54,12.7 157.3,12.7 159.11,14.51 162.61,14.51 163.28,15.17 Q5100.1
KSI0: length 43.8
  TOP w0.102: v1(43.78,30.52) 43.55,30.3 U2300.98
  BOTTOM w0.102: CON5102.22 72.83,12.87 72.58,13.12 72.12,13.12 71.73,13.52 71.73,13.76 71.56,13.93 C5123.1 71.08,14.88 71.08,15.54 71.07,15.55 71.07,15.9 71.25,16.07 71.25,16.77 70.99,17.02 RN5101.1 71.37,17.31 71.6,17.54 71.6,18.78 70.46,19.92 v2(69.24,19.92) 68.76,19.92 68.17,20.5 63.05,20.5 61.55,22 58.32,22 57.18,23.14 53.35,23.14 52.62,23.87 50.13,23.87 49.38,24.62 47.75,24.62 46.05,26.31 46.05,29.16 44.69,30.52 v1(43.78,30.52)
KSI1: length 44
  TOP w0.102: U2300.99 41.62,30.7 v1(41.4,30.91)
  BOTTOM w0.102: CON5102.24 71.23,12.82 71.09,12.96 70.79,12.96 69.71,14.04 C5122.1 69.24,14.86 69.24,15.66 69.29,15.71 69.29,16.23 69.89,16.83 RN5101.5 69.89,17.49 69.61,17.77 69.03,17.77 68.78,18.01 68.78,19.3 67.99,20.09 62.88,20.09 61.38,21.59 58.12,21.59 56.99,22.73 53.18,22.73 52.45,23.46 49.96,23.46 49.21,24.21 47.51,24.21 45.64,26.08 45.64,27.64 44.18,29.11 43.36,29.11 42.77,29.7 42.77,30.74 42.6,30.91 v2(42.32,30.91) v1(41.4,30.91)
KSI2: length 58.7
  TOP w0.102: U2300.6 38.9,41.82 38.81,41.73 38.81,40.29 38.53,40.01 38.53,38.71 37.52,37.7 37.52,34.51 v1(37.66,34.36)
  BOTTOM w0.102: CON5102.26 69.63,12.82 68.42,14.03 68.07,14.03 C5121.1 67.64,14.46 67.29,14.81 67.29,14.82 67.24,14.86 67.24,16.24 67.54,16.53 RN5100.1 68.02,17.31 68.15,17.44 68.15,19.26 67.72,19.69 64.34,19.69 63.32,18.67 58.48,18.67 57.3,19.85 57.3,21.2 56.18,22.32 53.02,22.32 52.3,23.04 49.8,23.04 49.04,23.8 47.34,23.8 45.24,25.91 45.24,27.47 44.01,28.7 43.13,28.7 41.75,30.09 41.37,30.09 39.24,32.21 v2(39.24,32.62) 38.58,33.28 38.57,33.28 38.33,33.51 38.33,33.53 37.66,34.2 v1(37.66,34.36)
KSI3: length 61.8
  TOP w0.102: U2300.7 38.5,40.26 38.33,40.1 38.33,38.86 37.31,37.85 37.31,34.62 v1(37.05,34.36)
  BOTTOM w0.102: CON5102.23 72.03,12.91 71.76,13.19 70.89,13.19 70.62,13.46 C5117.1 70.16,14.85 70.16,15.54 70.13,15.57 70.13,16.54 70.39,16.8 RN5101.3 70.39,17.68 70.52,17.81 71.27,17.81 71.39,17.93 71.39,18.68 70.69,19.38 69,19.38 68.09,20.3 62.97,20.3 61.47,21.8 58.21,21.8 57.07,22.93 53.27,22.93 52.54,23.66 50.04,23.66 49.29,24.41 47.6,24.41 45.85,26.16 45.85,27.73 44.11,29.47 43.36,29.47 43.03,29.8 43.03,30.94 41.22,32.74 41.22,33.07 40.76,33.53 39.88,33.53 39.01,34.39 v2(38.89,34.39) 38.46,34.39 38.08,34.77 37.46,34.77 v1(37.05,34.36)
KSI4: length 51.1
  TOP w0.102: v1(38.58,31.73) 40.63,31.73 41.6,32.7 U2300.104
  BOTTOM w0.102: CON5102.27 68.83,12.91 67.87,13.87 67.41,13.87 66.89,14.4 C5110.1 66.33,14.85 66.33,15.54 66.4,15.61 66.4,16.33 66.93,16.87 RN5100.3 66.93,17.74 67.03,17.83 67.84,17.83 67.95,17.94 67.95,19.18 67.64,19.48 64.44,19.48 63.42,18.47 58.4,18.47 57.1,19.76 57.1,21.12 56.1,22.12 52.93,22.12 52.21,22.84 49.72,22.84 48.95,23.6 47.26,23.6 45.03,25.82 45.03,27.39 43.92,28.5 43,28.5 41.62,29.88 40.07,29.88 v2(39.7,30.25) 39.7,30.61 v1(38.58,31.73)
KSI5: length 47.9
  TOP w0.102: U2300.105 41.42,33.1 v1(40.72,32.39)
  BOTTOM w0.102: CON5102.25 70.43,12.98 69.77,13.64 69.11,13.64 68.74,14.01 C5108.1 68.28,14.86 68.28,15.88 69.29,16.89 RN5101.7 68.95,17.31 68.55,17.71 68.55,19.14 67.81,19.89 64.24,19.89 63.22,18.87 58.56,18.87 57.51,19.93 57.51,21.29 56.27,22.53 53.1,22.53 52.38,23.24 49.88,23.24 49.12,24.01 47.43,24.01 45.44,25.99 45.44,27.56 44.09,28.91 43.23,28.91 41.85,30.29 41.45,30.29 40.72,31.03 v2(40.72,31.7) v1(40.72,32.39)
KSI6: length 52.6
  TOP w0.102: v1(38.58,32.34) 40.14,33.9 U2300.107
  BOTTOM w0.102: v1(38.58,32.34) 38.18,31.93 38.18,30.95 39.51,29.62 41.55,29.62 42.88,28.3 43.84,28.3 44.83,27.31 44.83,25.74 47.17,23.4 48.87,23.4 49.66,22.61 52.15,22.61 52.85,21.92 55.97,21.92 56.9,20.99 56.9,19.04 60.43,15.5 63.06,15.5 63.68,16.12 63.68,17.84 64.11,18.27 65.07,18.27 65.56,17.77 66.29,17.77 66.43,17.63 RN5100.5 66.43,16.93 65.41,15.91 65.41,14.88 C5107.1 66.27,14.03 66.67,14.03 67.32,13.38 v2(67.68,13.38) 68.03,13.02 CON5102.28
KSI7: length 55
  TOP w0.102: v1(37.69,32.31) 39.67,34.3 U2300.108
  BOTTOM w0.102: v1(37.69,32.31) 37.06,31.68 v2(37.06,30.86) 37.67,30.86 39.14,29.39 41.45,29.39 42.75,28.09 43.75,28.09 44.6,27.25 44.6,24.74 44.58,24.72 44.58,23.66 46.42,21.82 49.12,21.82 49.17,21.87 52.51,21.87 52.67,21.71 55.85,21.71 56.69,20.87 56.69,18.95 60.35,15.29 63.15,15.29 63.89,16.03 63.89,16.27 64.67,17.05 65.2,17.05 65.47,17.31 RN5100.7 65.83,16.71 65.58,16.46 64.67,16.46 64.16,15.95 64.16,15.12 64.85,14.42 C5105.1 65.08,14.42 66.29,13.21 67.01,13.21 67.23,12.98 CON5102.29
KSO0: length 92.6
  TOP w0.102: v1(40.5,42.62) 40.5,42.62 U2300.2 ; v1(48.11,45.84) 48.11,44.77 v2(49.14,43.74) 50.11,42.76 50.11,40.77 50.32,40.57 50.32,39.68 50.11,39.47 50.11,24.45 56.56,18.01 56.56,13.74 57.35,12.94 59.45,12.94 60.68,11.71 60.68,5.62 61.48,4.83 72.26,4.83 74.07,6.64 74.07,9.79 74.34,10.06 74.34,10.86 75.54,12.07 81.27,12.07 82.91,10.43 82.91,10.21 83.53,9.59 C5120.1 v1(83.61,10.24)
  BOTTOM w0.102: CON5102.13 80.03,11.72 80.39,11.36 81.98,11.36 83.1,10.24 v1(83.61,10.24) ; v1(48.11,45.84) 46.09,45.84 42.48,42.23 40.89,42.23 40.5,42.62 v1(40.5,42.62)
KSO1: length 94
  TOP w0.102: v1(47.43,42.9) 47.63,43.11 48.39,43.11 49,42.5 49,40.9 v2(49.68,40.21) 49.71,40.19 49.71,24.29 56.15,17.84 56.15,13.57 57.22,12.5 59.32,12.5 60.27,11.54 60.27,6.45 59.53,5.71 59.53,5.35 60.45,4.42 72.43,4.42 74.52,6.52 74.52,9.67 74.74,9.89 74.74,10.69 75.71,11.66 79.92,11.66 81.18,10.41 81.18,10.06 81.65,9.59 C5119.1 81.75,10.1 v1(81.61,10.24) ; U2300.14 35.7,41.89 v1(36.2,41.39)
  BOTTOM w0.102: v1(47.43,42.9) 47.16,42.9 46.98,42.73 43.84,42.73 42.89,41.78 38.73,41.78 38.33,41.38 36.2,41.38 v1(36.2,41.39) ; v1(81.61,10.24) 80.9,10.95 79.78,10.95 79.12,11.61 78.56,11.61 78.43,11.74 CON5102.15
KSO2: length 95.1
  TOP w0.102: U2300.15 35.3,41.71 v1(35.58,41.43) ; v1(46.81,43.13) 46.99,43.31 48.77,43.31 49.43,42.65 v2(49.43,41.99) 49.43,41.17 50.11,40.48 50.11,39.76 49.91,39.56 49.91,24.37 56.35,17.93 56.35,13.65 57.28,12.73 59.38,12.73 60.48,11.63 60.48,5.54 61.39,4.63 72.34,4.63 74.32,6.6 74.32,9.75 74.54,9.97 74.54,10.78 75.63,11.86 80.56,11.86 82.02,10.41 82.02,10.16 82.59,9.59 C5118.1 82.68,10.09 v1(82.5,10.26)
  BOTTOM w0.102: v1(46.81,43.13) 43.94,43.13 42.79,41.98 38.64,41.98 38.24,41.58 36.88,41.58 36.53,41.94 36.09,41.94 v1(35.58,41.43) ; CON5102.14 79.23,11.8 79.88,11.15 81.61,11.15 v1(82.5,10.26)
KSO3: length 94
  TOP w0.102: v1(80.77,10.24) 80.77,9.96 80.82,9.91 C5116.1 80.71,9.61 80.24,10.09 80.24,10.46 79.24,11.46 75.8,11.46 74.95,10.61 74.95,9.81 74.73,9.59 74.73,6.43 72.51,4.22 60.04,4.22 59.23,5.02 59.23,5.75 60.07,6.59 60.07,11.46 59.23,12.3 57.13,12.3 55.95,13.48 55.95,16.98 v2(54.94,17.99) 54.94,18.77 49.5,24.2 49.5,39.71 49.1,40.12 49.1,40.48 v1(48.1,41.48) ; v1(37.35,39.79) 36.64,39.79 34.9,41.54 U2300.16
  BOTTOM w0.102: v1(48.1,41.48) 47.65,41.03 47.65,40.59 46.76,39.7 45.57,39.7 45.28,39.42 43.69,39.42 43.19,39.92 38.06,39.92 37.94,39.79 v1(37.35,39.79) ; CON5102.16 77.63,11.63 77.85,11.41 79.02,11.41 79.68,10.75 80.26,10.75 v1(80.77,10.24)
KSO4: length 108.8
  TOP w0.102: v1(77.13,10.34) 77.14,10.33 C5115.1 77.05,9.62 76.71,9.96 76.71,10.41 76.47,10.65 76.13,10.65 75.76,10.27 75.76,9.63 75.76,9.47 75.54,9.25 75.54,6.1 75.29,5.84 75.29,5.84 72.85,3.41 52.4,3.41 v2(50.09,5.72) 49.38,6.43 49.38,11.96 49.38,11.96 49.38,12.13 49.38,12.29 52.5,15.41 52.5,18.33 50.79,20.04 48.36,20.04 46.23,22.18 46.23,23.45 46.63,23.85 48.18,23.85 48.9,24.56 48.9,39.46 48.09,40.26 47.85,40.26 47.49,40.62 47.49,41.79 47.63,41.93 47.63,42.32 v1(48.01,42.7) ; v1(34.67,38.99) 34.98,39.3 34.98,40.09 34.69,40.38 28.35,40.38 28.03,40.7 U2300.37
  BOTTOM w0.102: CON5102.20 74.43,11.47 74.78,11.13 76.34,11.13 v1(77.13,10.34) ; v1(48.01,42.7) 47.63,42.32 47.63,42.17 46.33,40.87 45.26,40.87 44.79,40.4 36.08,40.4 v1(34.67,38.99)
KSO5: length 103.9
  TOP w0.102: v1(34.48,39.97) 33.61,39.09 29.35,39.09 28.14,40.3 U2300.38 ; v1(76.3,10.24) 76.22,10.15 C5114.1 76.22,9.62 76.22,9.3 76.09,9.17 75.87,9.17 75.74,9.04 75.74,6.01 72.94,3.2 51.99,3.2 49.66,5.54 49.66,5.84 49.17,6.33 49.17,11.87 49.17,11.87 49.17,12.21 49.17,12.21 49.17,12.37 51.71,14.91 51.71,18.83 50.71,19.84 48.18,19.84 46.03,22 46.03,23.55 46.56,24.08 47.57,24.08 48.69,25.2 48.69,39.28 47.94,40.03 47.79,40.03 47.27,40.55 47.27,42.27 v1(47.21,42.33)
  BOTTOM w0.102: v1(76.3,10.24) 74.9,10.24 73.63,11.51 CON5102.21 ; v1(47.21,42.33) 47.22,42.33 47.22,42.19 47.09,42.06 45.92,42.06 44.83,40.97 v2(42,40.97) 41.4,41.58 38.83,41.58 38.2,40.95 35.46,40.95 v1(34.48,39.97)
KSO6: length 107.7
  TOP w0.102: v1(48.1,40.87) 48.9,40.08 48.9,40.03 49.3,39.63 49.3,24.36 48.23,23.29 46.86,23.29 46.69,23.12 46.69,22.46 48.07,21.07 51.27,21.07 52.91,19.44 52.91,14.91 49.78,11.79 49.78,6.92 51.22,5.49 v2(52.55,5.49) 52.55,4.65 53.39,3.81 72.68,3.81 74.8,5.93 74.8,5.93 75.13,6.26 75.13,9.42 75.35,9.64 75.35,10.44 75.96,11.05 77.84,11.05 78.38,10.51 78.38,10.11 78.88,9.62 C5113.1 78.98,9.92 78.84,10.06 v1(78.84,10.31) ; U2300.39 27.9,39.9 29.28,38.52 v1(35.91,38.52)
  BOTTOM w0.102: CON5102.18 76.03,11.66 76.16,11.53 76.63,11.53 77.17,11 78.16,11 v1(78.84,10.31) ; v1(48.1,40.87) 48.11,40.87 48.11,40.62 46.23,38.74 43.94,38.74 43.18,39.49 39.57,39.49 39.18,39.11 38.26,39.11 38.06,39.31 36.7,39.31 v1(35.91,38.52)
KSO7: length 109
  TOP w0.102: U2300.50 27.87,35.5 27.97,35.59 28.3,35.59 29.48,36.76 30.46,37.75 34.47,37.75 v1(34.67,37.54) ; v1(48.09,42.1) 47.69,41.7 47.69,40.71 47.94,40.46 48.17,40.46 49.1,39.54 49.1,24.46 48.2,23.56 46.72,23.56 46.46,23.29 46.46,22.28 48.49,20.25 50.88,20.25 52.71,18.42 52.71,15.17 49.58,12.04 49.58,6.84 52.81,3.61 72.77,3.61 75.06,5.9 75.06,5.9 75.34,6.18 75.34,9.33 75.56,9.55 75.56,10.36 76.05,10.85 77.2,10.85 77.55,10.5 77.55,10.04 77.96,9.62 C5112.1 78.06,9.9 77.98,9.98 v1(77.98,10.34)
  BOTTOM w0.102: v1(34.67,37.54) 35,37.87 35,38.18 37.02,40.2 43.19,40.2 43.46,39.93 v2(44.63,39.93) 46.69,39.93 47.35,40.59 47.35,41.36 v1(48.09,42.1) ; v1(77.98,10.34) 77.52,10.8 77.04,10.8 76.51,11.33 75.62,11.33 75.23,11.72 CON5102.19
KSO8: length 91.6
  TOP w0.102: v1(47.18,22.82) 47.35,22.66 49.58,22.66 50.34,21.9 v2(50.7,21.9) 51.12,21.48 51.86,21.48 53.96,19.37 53.96,18.35 55.74,16.57 55.74,13.4 57.05,12.09 59.15,12.09 59.87,11.37 59.87,6.76 58.9,5.79 58.9,4.92 59.81,4.02 72.6,4.02 74.93,6.35 74.93,9.5 75.15,9.72 75.15,10.52 75.88,11.25 78.48,11.25 79.25,10.48 79.25,10.16 79.81,9.6 C5111.1 79.9,9.89 79.83,9.96 v1(79.83,10.29) ; v1(36.88,37.44) 36.6,37.72 36.3,38.03 35.79,38.03 35.56,38.25 30.28,38.25 29.12,37.1 U2300.46
  IN1 w0.102: v1(47.18,22.82) 47.18,23.13 44.53,25.78 43.92,25.78 43.62,26.08 43.62,26.58 42.52,27.69 42.52,28.5 39.32,31.7 39.32,33.28 37.6,35 35.75,35 35.41,35.34 35.41,35.97 v1(36.88,37.44)
  BOTTOM w0.102: v1(79.83,10.29) 78.92,11.2 77.27,11.2 76.83,11.64 CON5102.17
KSO9: length 83.8
  TOP w0.102: R2320.2 29.9,25.94 30.18,26.22 30.18,26.88 29.7,27.35 U2300.68 29.7,30 30.47,30.78 v1(31.17,30.78)
  BOTTOM w0.102: v1(31.17,30.78) 31.9,30.05 v2(32.56,30.05) 33.06,30.05 35.26,32.26 35.26,35.54 35.72,35.99 40.51,35.99 43.45,33.05 45.42,33.05 46.81,31.65 46.81,30.21 47.27,29.76 47.27,26.82 48.25,25.83 49.88,25.83 50.52,25.2 51.53,25.2 52.95,26.62 54.01,26.62 55.46,25.17 57.73,25.17 59.54,23.37 61.91,23.37 62.76,22.52 72.84,22.52 73.13,22.23 81.15,22.23 81.87,21.51 81.87,19.15 82.21,18.81 82.21,16.49 82.55,16.16 83.48,16.16 83.89,15.75 84.46,15.75 84.64,15.57 85.24,15.57 85.59,15.22 85.59,14.9 85.68,14.81 85.68,14.13 C5109.1 84.83,13.27 CON5102.7
KSO10: length 82.8
  TOP w0.102: U2300.72 31.3,29.2 v1(31.14,29.36)
  BOTTOM w0.102: CON5102.5 86.43,13.03 86.44,13.03 C5106.1 87.63,14.22 87.63,14.98 86.83,15.78 85.61,15.78 85.41,15.98 84.81,15.98 84.63,16.16 84.15,16.16 83.73,16.57 82.71,16.57 82.62,16.66 82.62,18.99 82.3,19.31 82.3,21.66 81.32,22.64 73.3,22.64 73.01,22.93 62.92,22.93 62.07,23.78 59.74,23.78 57.91,25.61 55.6,25.61 54.17,27.03 52.79,27.03 51.36,25.61 50.69,25.61 50.05,26.24 48.42,26.24 47.68,26.99 47.68,29.92 47.22,30.38 47.22,31.82 45.59,33.45 43.62,33.45 40.68,36.4 35.55,36.4 34.86,35.7 34.86,32.43 34.56,32.13 32.08,32.13 v2(31.98,32.03) 31.56,32.03 30.56,31.03 30.56,29.93 v1(31.14,29.36)
KSO11: length 82.1
  TOP w0.102: v1(31.14,29.97) 31.94,29.97 32.1,29.81 U2300.74
  BOTTOM w0.102: v1(31.14,29.97) 30.76,30.34 30.76,30.95 31.24,31.42 33.58,31.42 v2(33.78,31.63) 34.34,31.63 35.06,32.34 35.06,35.62 35.63,36.19 40.6,36.19 43.54,33.25 45.5,33.25 47.02,31.74 47.02,30.3 47.47,29.84 47.47,26.9 48.34,26.04 49.97,26.04 50.6,25.4 51.44,25.4 52.87,26.83 54.09,26.83 55.52,25.4 57.81,25.4 59.64,23.57 61.99,23.57 62.84,22.72 72.92,22.72 73.21,22.43 81.24,22.43 82.09,21.57 82.09,19.22 82.41,18.9 82.41,16.58 82.62,16.37 83.55,16.37 83.97,15.95 84.55,15.95 84.73,15.78 85.33,15.78 85.53,15.57 86.18,15.57 86.47,15.29 86.47,14.99 86.6,14.86 86.6,14.13 C5104.1 85.63,13.16 CON5102.6
KSO12: length 73.1
  TOP w0.102: v1(37.24,33.33) 36.94,33.33 36.2,34.06 34.1,34.06 32.5,32.46 U2300.75
  BOTTOM w0.102: v1(37.24,33.33) 36.65,33.92 36.65,34.53 37.09,34.97 39.27,34.97 40.23,34.01 v2(40.69,34.01) 41.56,33.15 41.56,32.84 43.46,30.94 44.65,30.94 46.25,29.33 46.25,26.4 47.83,24.82 49.46,24.82 50.21,24.07 53.71,24.07 54.44,23.34 57.27,23.34 58.35,22.25 61.59,22.25 62.94,20.89 72.3,20.89 72.61,21.21 80.51,21.21 80.78,20.94 80.78,18.81 81.09,18.49 81.09,15.81 80.15,14.86 80.15,14.02 C5103.1 80.83,13.34 CON5102.12
KSO13: length 75
  TOP w0.102: U2300.76 32.9,32.57 34.19,33.86 34.92,33.86 35.83,32.95 v1(36.08,32.95)
  BOTTOM w0.102: CON5102.9 83.23,12.75 83.34,12.86 83.34,13.62 C5102.1 83.85,14.13 83.85,14.81 83.77,14.89 83.77,15.29 83.31,15.75 82.38,15.75 81.79,16.34 81.79,18.66 81.44,19.01 81.44,21.19 80.81,21.82 72.96,21.82 72.67,22.11 62.59,22.11 61.79,22.91 58.67,22.91 57.64,23.95 54.69,23.95 53.96,24.68 50.46,24.68 49.71,25.43 48.08,25.43 46.86,26.65 46.86,29.59 44.7,31.75 v2(44.7,32.26) 44.35,32.62 43.31,32.62 40.34,35.58 36.84,35.58 35.69,34.43 35.69,33.35 v1(36.08,32.95)
KSO14: length 79.1
  TOP w0.102: v1(36.08,32.34) 34.76,33.66 34.27,33.66 33.3,32.68 U2300.77
  BOTTOM w0.102: v1(36.08,32.34) 35.48,32.93 35.48,34.52 36.75,35.79 40.43,35.79 43.4,32.82 45.03,32.82 v2(46.34,31.51) 46.34,30.39 47.07,29.67 47.07,26.73 48.17,25.63 49.8,25.63 50.43,25 51.65,25 53.07,26.42 53.79,26.42 54.41,25.81 54.41,24.72 54.97,24.15 57.74,24.15 58.78,23.12 61.87,23.12 62.67,22.32 72.75,22.32 73.04,22.03 81.07,22.03 81.67,21.42 81.67,19.07 82.01,18.73 82.01,16.41 82.46,15.95 83.39,15.95 83.8,15.55 84.38,15.55 84.67,15.26 84.67,15 84.77,14.9 84.77,14.13 C5101.1 84.03,13.39 CON5102.8
KSO15: length 71.3
  TOP w0.102: v1(36.05,30.23) 36.9,29.38 U2300.86
  BOTTOM w0.102: CON5102.10 82.43,12.75 82.36,12.83 82.36,13.17 82.48,13.29 C5100.1 82.94,14.13 82.94,15.26 82.65,15.55 82.3,15.55 81.59,16.26 81.59,18.58 81.24,18.93 81.24,21.11 80.73,21.62 72.44,21.62 72.13,21.3 63.11,21.3 61.75,22.66 58.6,22.66 57.51,23.74 54.61,23.74 53.88,24.47 50.38,24.47 49.63,25.22 48,25.22 46.66,26.56 46.66,29.5 44.74,31.42 43.87,31.42 42.77,32.52 42.77,32.87 40.26,35.38 36.92,35.38 36.24,34.7 36.24,33.4 36.49,33.15 36.49,30.67 v1(36.05,30.23) v2(35.23,30.23)
KSO16: length 69.8
  TOP w0.102: v1(37.21,32.72) 37.21,31.68 39.37,29.52 39.37,29.11 39.3,29.04 U2300.92
  BOTTOM w0.102: v1(37.21,32.72) 36.44,33.48 36.44,34.62 37.01,35.18 40.18,35.18 41.78,33.58 41.78,33.23 v2(42.22,32.79) 43.79,31.22 44.66,31.22 46.46,29.42 46.46,26.48 47.92,25.02 49.54,25.02 50.29,24.27 53.79,24.27 54.52,23.54 57.39,23.54 58.47,22.46 61.67,22.46 63.03,21.1 72.21,21.1 72.53,21.41 80.62,21.41 80.98,21.05 80.98,18.89 81.36,18.52 81.36,16.2 82.02,15.53 82.02,14.05 C5132.1 81.63,13.48 CON5102.11
L: length 2.4
  BOTTOM w0.432: C3808.1 13.87,41.76 14.73,42.62 R3829.1
L_BKLT_CTRL: length 156.1
  TOP w0.102: v1(81.97,22.74) v2(81.28,22.74) ; D3003.1 62.13,96.62 v1(62.33,96.42)
  IN2 w0.102: v1(81.97,22.74) 82.14,22.56 84.15,22.56 84.23,22.63 84.99,22.63 87,20.63 89.17,20.63 90.54,22 97.49,22 98.66,23.17 102.66,23.17 102.86,22.96 105.96,22.96 106.2,22.72 112.02,22.72 113.1,21.64 114.22,21.64 114.42,21.84 116.9,21.84 117.77,22.71 118.67,22.71 119.36,23.4 122.41,23.4 123.91,24.9 123.91,28.3 123.77,28.44 123.77,31.89 122.07,33.59 121.49,33.59 119.47,35.6 119.47,38.67 v3(119.83,39.02)
  BOTTOM w0.102: R3002.1 v1(62.33,96.42) 64.3,94.45 69.68,94.45 71.65,92.49 71.65,88.15 73.23,86.57 v2(73.23,63.6) 73.23,27.87 72.97,27.61 72.97,23.97 74.11,22.84 81.86,22.84 v1(81.97,22.74)
  BOTTOM w0.108: v3(119.83,39.02) 119.65,39.02 U0400.R11
L_BKLT_CTRL_R: length 14
  TOP w0.102: R3009.1 57.43,96.62 57.58,96.78 58.09,96.78 58.24,96.62 D3003.2 D3004.2 59.41,98.81 59.92,98.3 59.92,96.47 v1(59.84,96.38)
  BOTTOM w0.102: CON3000.12 61.58,100.14 61.72,100 61.72,99.21 62,98.94 C3011.1 61.42,98.07 61.42,97.74 60.93,97.26 R3002.2 60.36,96.38 v1(59.84,96.38) v2(59.84,95.68)
LAN_WAKE#: length 137
  TOP w0.102: v1(35.74,50.98) 34.3,50.98 34.02,50.7 32.69,50.7 32.29,50.3 31.69,50.3 31.41,50.59 30.76,50.59 30.18,50.02 27.56,50.02 25.68,48.14 21.16,48.14 20.7,47.68 v2(20.7,47.22) 20.7,44.81 22.25,43.26 22.5,43.26 23.65,42.12 R2345.2 ; v1(92.11,31.5) 92.11,31.33 91.75,30.97 91.67,30.97 C1204.1 91.69,30.69 91.75,30.69 92,30.43 92,29.64 92.08,29.57 92.08,29.56 92.09,29.55 92.09,29.1 91.8,28.81 R1209.2
  IN2 w0.102: v1(35.74,50.98) 37.36,49.35 37.36,41.84 39.62,39.58 39.62,38.65 40.16,38.11 40.16,35.3 42.14,33.33 42.14,25.9 43.59,24.45 43.59,24.11 44.94,22.76 45.72,22.76 46.43,23.47 50.74,23.47 51.99,22.23 56.06,22.23 56.58,21.7 63.99,21.7 64.27,21.42 70.98,21.42 71.1,21.3 74.85,21.3 75.21,21.66 77.85,21.66 82.16,25.96 83.2,25.96 83.45,25.71 84.87,25.71 85.33,26.16 85.63,26.16 85.95,26.49 85.95,26.68 86.33,27.05 86.89,27.05 89.63,29.79 90.4,29.79 v1(92.11,31.5) 92.52,31.9 93.3,31.9 94.32,32.92 101.57,32.92 106.83,38.18 106.83,39.7 107.21,40.08 109.6,40.08 109.68,40.01 110.18,40.01 v3(110.57,40.4)
  BOTTOM w0.102: U0400.AM15 110.58,40.4 v3(110.57,40.4) ; v1(92.11,31.5) 92.11,30.83 v2(92.19,30.75)
LANWAKE#: length 2.4
  TOP w0.102: U2300.35 v2(25.53,41.5) 25.43,41.5 25.29,41.63 R2345.1
LCD_CBL_DET#: length 223.3
  TOP w0.102: R1519.2 119.2,26.1 119.33,25.97 T1504.1 118.97,24.54 v1(118.62,24.54) ; v1(86.5,26.65) 86.5,26.33 84.51,24.34 84.51,22.86 83.97,22.33 83.97,21.69 84.28,21.39 85.19,21.39 85.95,20.63 85.95,20.38 88.51,17.82 88.51,14.75 v1(88.39,14.63)
  IN1 w0.102: v1(102.65,18.1) 102.65,16.6 102.31,16.26 94.31,16.26 92.91,14.86 92.41,14.86 91.64,14.09 88.93,14.09 v1(88.39,14.63)
  IN2 w0.102: v1(33.1,91.16) 33.43,90.84 33.43,89.64 36.08,86.99 36.08,85.54 32.72,82.18 32.72,70.11 30.84,68.23 30.84,67.57 30.28,67.01 30.28,66.68 31.24,65.71 31.24,64.42 30.91,64.09 30.91,59.5 33.15,57.26 33.15,53.67 34.47,52.35 34.47,51.57 36.3,49.74 36.3,47.73 36.53,47.5 36.53,44.63 35.87,43.97 35.87,42.63 38.2,40.3 38.2,39.7 39.93,37.97 39.93,35.21 40.26,34.88 40.26,27.46 43.26,24.46 43.26,24.12 44.84,22.53 45.85,22.53 46.56,23.24 50.65,23.24 51.89,22 55.94,22 56.47,21.47 63.9,21.47 64.18,21.19 70.89,21.19 71.01,21.07 74.94,21.07 75.3,21.43 77.95,21.43 82.25,25.73 83.1,25.73 83.36,25.48 84.96,25.48 85.42,25.94 85.79,25.94 v1(86.5,26.65) ; v1(118.62,24.54) 118.62,29.66 117.16,31.12 117.16,31.93 117.63,32.39 v3(117.63,34.78)
  IN3 w0.102: v1(57.58,101.63) 57.58,101.45 57.23,101.09 56.06,101.09 55.63,101.53 53.48,101.53 52.92,100.97 46.45,100.97 40.25,94.77 35.87,94.77 33.1,92.01 v1(33.1,91.16) ; v1(118.62,24.54) 117.58,23.5 117.58,21.69 117.64,21.63 117.64,19.71 117.37,19.43 113.09,19.43 112.06,18.4 109.24,18.4 109,18.64 106.49,18.64 105.53,17.69 103.05,17.69 v1(102.65,18.1)
  BOTTOM w0.102: v3(117.63,34.78) 117.51,34.66 U0400.W4 ; CON3000.4 v1(57.58,101.63)
LCD_TST: length 161.3
  TOP w0.102: v2(84.05,23.65) v1(83.36,22.96) ; v1(33.71,41.51) 32.54,41.51 30.9,43.15 U2300.26
  IN3 w0.102: v1(33.71,41.51) 33.71,36.65 36.8,33.56 36.8,32.03 41.66,27.18 41.77,27.18 44.06,24.89 48.74,24.89 53.56,20.08 53.56,19.62 55.07,18.11 64.22,18.11 64.47,18.37 71.65,18.37 71.76,18.47 72.24,18.47 72.87,19.1 72.87,19.67 76.37,23.17 80.9,23.17 81.84,22.23 82.63,22.23 v1(83.36,22.96)
  BOTTOM w0.102: v1(83.36,22.96) 83.36,23.01 80.64,25.74 80.64,26.96 74.47,33.13 74.47,67.16 v2(74.14,67.49) 74.14,86.63 72.34,88.44 72.34,92.66 69.94,95.06 65.21,95.06 64.01,96.27 64.01,96.81 64.36,97.17 64.36,97.71 64.4,97.75 64.4,99.45 63.93,99.93 63.35,99.93 63.08,100.19 CON3000.15
LCD_VCC_TEST_EN: length 109
  TOP w0.102: v1(43.76,36.46) 43.76,36.46 43.6,36.3 U2300.113 ; v1(67.13,96.47) 66.73,96.07 64.26,96.07 61.52,98.81 D3004.1
  IN2 w0.102: v1(43.76,36.46) 43.66,36.56 43.66,40.87 44.27,41.48 44.27,42.55 44.76,43.03 44.76,49.89 44.4,50.24 44.4,53.4 46.69,55.68 46.69,62.31 47.85,63.48 47.85,69.15 45.26,71.74 45.26,75.42 45.99,76.14 45.99,85.08 47.42,86.52 47.42,90.74 52.39,95.71 66.37,95.71 v1(67.13,96.47) 67.18,96.52 v1(72.75,96.52)
  BOTTOM w0.102: v2(42.93,36.3) 43.58,36.3 43.76,36.48 43.76,36.46 v1(43.76,36.46) ; v1(72.75,96.52) v2(75.4,99.17) 76.66,100.43 78.43,100.43 78.94,100.95 D3000.1
LID_CL_SIO#: length 54.4
  TOP w0.102: U2300.66 28.9,27.27 28.85,27.23 v1(28.85,26.75) ; U3702.1 2.41,55.27 3.48,56.34 R3707.2 8.1,56.7 7.85,56.95 v1(7.26,56.95)
  IN3 w0.102: v1(7.26,56.95) 14.19,56.95 15.18,55.96 15.6,55.96 16.05,55.5 16.05,55.09 16.64,54.5 16.64,51.39 16.76,51.26 16.76,42.5 16.92,42.35 v1(16.92,41.1)
  BOTTOM w0.102: v1(28.85,26.75) 28.85,27.49 v2(28.7,27.64) 28.7,28.15 26.44,30.41 26.44,31.2 24.25,33.39 24.25,35.65 23.83,36.07 22.73,36.07 21.08,37.72 19.56,37.72 19.14,38.14 19.14,38.88 v1(16.92,41.1)
LINE2_L: length 10
  TOP w0.381: v2(13.67,39.83) 13.67,38.97 v1(13.44,38.74)
  IN1 w0.381: v1(13.59,32.29) 13.59,38.58 v1(13.44,38.74)
  BOTTOM w0.229: 13.65,32 13.65,31.77 13.98,31.44 U3800.36
  BOTTOM w0.381: C3808.2 13.87,38.94 13.67,38.74 v1(13.44,38.74) ; v1(13.59,32.29) 13.65,32.23 13.65,32
LINE2_R: length 13.5
  TOP w0.381: v1(10.72,40.39) v2(10.11,39.78)
  IN1 w0.381: v1(12.96,32.29) 11.96,33.29 11.96,37.75 10.72,38.99 v1(10.72,40.39)
  BOTTOM w0.229: U3800.35 13.87,31.04 13.07,31.84 13.07,31.88
  BOTTOM w0.381: v1(10.72,40.39) 11.55,41.22 C3809.2 ; v1(12.96,32.29) 12.96,32 13.07,31.88
M2_LED#_R: length 8.6
  TOP w0.102: v1(224.89,15.24) 223.57,15.24 222.28,16.54 R3116.2
  BOTTOM w0.102: CON3100.10 224.63,18.6 224.89,18.34 v1(224.89,15.24)
M2_SSD_PEDET: length 16.1
  BOTTOM w0.076: U0400.G4 123.57,34.32 123.52,34.23 123.52,33.9 123.54,33.86 123.54,33.83 123.68,33.69 123.87,33.69 124.13,33.43 124.13,32.45
  BOTTOM w0.102: 124.13,32.45 124.69,31.89 124.69,30.83 126.34,29.18 126.34,27.79 126.17,27.63 126.17,26.61 126.87,25.91 126.87,23.65 127.08,23.45 127.08,22.48 127.41,22.15 v2(128.04,22.15) R1406.1
M2_SSD_PEDET_N: length 147.8
  TOP w0.102: R3105.2 217.07,4.45 217.04,4.42 R3106.2 v1(216.54,5.23)
  IN1 w0.102: v1(173.86,10.29) 174.49,9.66 201.83,9.66 204.17,12 204.17,14.76 209.02,19.61 210.54,19.61 215.82,14.33 215.82,5.95 v1(216.54,5.23) ; v1(177.7,21.9) 177.18,21.38 170.27,21.38 170.14,21.51 170.14,21.88 169.95,22.08 165.91,22.08 v1(163.47,24.51)
  IN2 w0.102: v1(134.87,22.66) 134.93,22.61 141.99,22.61 142.21,22.84 149.87,22.84 152.64,20.07 155.91,20.07 156.87,19.1 157.38,19.1 157.53,19.26 157.53,19.94 156.95,20.53 156.95,22.22 158.2,23.47 162.43,23.47 v1(163.47,24.51)
  IN3 w0.102: v1(173.86,10.29) 173.44,9.86 165.5,9.86 163.68,11.69 161.54,11.69 160.47,12.75 v1(159.89,12.75)
  BOTTOM w0.102: Q3100.3 159.84,12.8 v1(159.89,12.75) ; v1(177.7,21.9) 177.93,21.67 177.93,19.46 177.22,18.75 176.66,18.75 175.26,17.35 175.26,13.44 173.86,12.04 v1(173.86,10.29) ; v1(134.87,22.66) 134.8,22.58 131.93,22.58 v2(131.71,22.37) 131.24,21.9 130.56,21.9 130.3,22.15 R1406.2
M_A_A0: length 49.2
  TOP w0.165: v2(64.25,55.62) v1(64.72,56.09)
  IN1 w0.152: v1(64.72,56.09) 64.72,56.72 64.85,56.85 65.35,56.85 65.68,56.52 67.07,56.52 67.89,55.7 73.43,55.7 73.66,55.94 77.5,59.77 77.9,60.17 78.11,60.38 90.74,60.38 90.93,60.19 99.44,60.19 99.78,60.53 101.02,60.53 101.61,61.11 102.34,61.11 102.58,61.36 v3(102.58,61.77)
  BOTTOM w0.076: U0400.AY50 105.74,61.17 105.5,61.17 105.43,61.21 105.22,61.21 105.1,61.17 104.86,61.17 104.78,61.21 103.15,61.21 103.03,61.33
  BOTTOM w0.165: v1(64.72,56.09) 64.23,56.57 CON2000.144 ; 103.03,61.33 v3(102.58,61.77)
M_A_A1: length 51.9
  TOP w0.165: v2(68.61,59.43) 68.21,59.43 67.01,58.22 v1(67.01,58.07)
  IN1 w0.152: v1(101.45,61.6) 101.45,61.32 100.92,60.78 99.6,60.78 99.44,60.62 91.11,60.62 90.91,60.82 77.93,60.82 77.72,60.6 77.72,60.6 77.55,60.43 77.55,60.43 73.25,56.14 68.07,56.14 67.25,56.96 65.92,56.96 65.71,57.16 65.71,57.41 65.96,57.66 66.88,57.66 67.01,57.79 v1(67.01,58.07)
  BOTTOM w0.165: v1(67.01,58.07) 67.11,58.17 67.11,59.2 67.23,59.32 67.75,59.32 67.93,59.15 67.93,58.89 68.15,58.68 68.64,58.68 68.86,58.89 68.86,59.2 68.99,59.32 CON2000.133 ; U0400.BB50 104.61,61 102.88,61 102.67,61.22 101.6,61.22 101.45,61.37 v1(101.45,61.6)
M_A_A2: length 52.2
  TOP w0.165: v2(66.17,55.43) 66.19,55.43 v1(66.86,56.09)
  IN1 w0.152: v1(66.86,56.09) 67.68,55.27 73.61,55.27 77.68,59.34 78.08,59.74 78.08,59.74 78.29,59.95 90.56,59.95 90.77,59.74 99.41,59.74 99.95,60.28 101.13,60.28 101.58,60.73 103.23,60.73 103.45,60.96 103.45,61.51 v3(103.19,61.77)
  BOTTOM w0.076: U0400.AY51 106.06,61.34 106.06,61.34 105.55,61.34 105.49,61.36 105.46,61.37 105.2,61.37 105.08,61.34 104.9,61.34 104.81,61.37 103.58,61.37 103.51,61.45
  BOTTOM w0.165: CON2000.132 65.55,59.57 66.19,58.93 66.19,56.76 v1(66.86,56.09) ; v3(103.19,61.77) 103.43,61.53 103.43,61.52 103.51,61.45
M_A_A3: length 51.6
  TOP w0.165: v2(68.06,56.23) 67.89,56.39 v1(67.89,57.03)
  IN1 w0.152: v1(67.89,57.03) 67.89,56.93 68.25,56.57 69.79,56.57 69.96,56.75 70.26,56.75 70.43,56.57 73.05,56.57 73.42,56.94 74.08,57.59 74.08,57.82 74.27,58.01 74.5,58.01 75.3,58.82 75.3,59.02 75.52,59.24 75.72,59.24 76.53,60.05 76.53,60.22 76.77,60.47 76.95,60.47 77.73,61.25 91.1,61.25 91.3,61.06 91.79,61.06 91.97,61.24 92.28,61.24 92.46,61.06 92.78,61.06 92.97,61.25 93.39,61.25 93.58,61.06 94,61.06 94.19,61.25 94.61,61.25 94.8,61.06 95.22,61.06 95.41,61.25 95.83,61.25 96.02,61.06 100.83,61.06 101.01,61.24 101.01,61.42 100.86,61.57 v1(100.81,61.57)
  BOTTOM w0.076: 104.38,60.74 104.45,60.68 105.24,60.68 105.32,60.75 U0400.BA50
  BOTTOM w0.165: CON2000.131 66.83,59.82 66.52,59.51 66.52,57 66.88,56.64 67.51,56.64 v1(67.89,57.03) ; v1(100.81,61.57) 100.78,61.57 100.63,61.43 100.63,61.25 100.91,60.96 102.51,60.96 102.73,60.74 104.38,60.74
M_A_A4: length 52.1
  TOP w0.165: v1(65.2,61.62) 65.81,61.62 v2(65.86,61.67)
  IN1 w0.152: v1(65.2,61.62) 65.35,61.77 65.58,61.77 65.71,61.65 65.71,60.71 65.84,60.58 66.12,60.58 66.27,60.73 66.27,61.14 66.4,61.27 66.76,61.27 66.88,61.14 66.88,60.73 67.04,60.58 67.34,60.58 67.49,60.73 67.49,60.96 67.64,61.11 67.95,61.11 68.1,60.96 68.1,60.73 68.25,60.58 70.96,60.58 75.58,65.2 v1(87.89,65.2)
  BOTTOM w0.076: 100.79,62.59 100.81,62.59 100.9,62.5 101.01,62.5 104.11,62.5 104.34,62.27 U0400.BB52
  BOTTOM w0.165: v1(65.2,61.62) 65.2,61.57 65.76,61.01 65.76,60.78 65.56,60.57 CON2000.128 ; 100.79,62.59 100.78,62.6 99.21,62.6 98.75,63.06 92.93,63.06 90.93,65.05 90.93,65.56 90.65,65.84 88.02,65.84 87.89,65.71 v1(87.89,65.2)
M_A_A5: length 53.4
  TOP w0.165: v2(64.27,60.62) 63.96,60.94 v1(63.96,61.57)
  IN1 w0.152: v1(89.13,65.2) 88.68,64.75 86.96,64.75 86.75,64.54 86.35,64.54 86.14,64.75 85.74,64.75 85.53,64.54 85.13,64.54 84.92,64.75 84.52,64.75 84.32,64.54 83.91,64.54 83.71,64.75 83.3,64.75 83.1,64.54 82.69,64.54 82.49,64.75 82.08,64.75 81.88,64.54 81.47,64.54 81.27,64.75 75.74,64.75 75.3,64.31 75.3,63.89 75.08,63.67 74.66,63.67 74.44,63.45 74.44,63.02 74.22,62.8 73.8,62.8 73.58,62.58 73.58,62.16 73.35,61.94 72.93,61.94 72.71,61.72 72.71,61.3 72.49,61.08 72.07,61.08 71.14,60.15 64.97,60.15 63.96,61.16 v1(63.96,61.57)
  BOTTOM w0.076: 100.95,62.03 102.31,62.03 102.43,62.14 104,62.14 104.3,61.84 104.78,61.84 104.91,61.87 105.09,61.87 105.2,61.83 105.26,61.8 105.45,61.8 U0400.BA51
  BOTTOM w0.165: v1(89.13,65.2) 89.13,63.95 89.26,63.83 90.89,63.83 91.27,63.45 91.28,63.45 93.43,61.29 99.24,61.29 99.97,62.03 100.95,62.03 ; v1(63.96,61.57) 64.17,61.36 64.17,60.97 64.04,60.84 63.47,60.84 63.24,61.07 CON2000.126
M_A_A6: length 53
  TOP w0.165: v1(67.11,61.59) 67.26,61.45 67.26,60.96 v2(67.47,60.74)
  IN1 w0.152: v1(91.66,65.2) 90.8,66.06 75.22,66.06 71.65,62.49 66.15,62.49 66.04,62.38 66.04,62.03 66.17,61.9 66.81,61.9 v1(67.11,61.59)
  BOTTOM w0.076: U0400.BA52 105.13,62.27 104.86,62.53 104.31,62.53 104.18,62.66 101.27,62.66 101.17,62.77 100.99,62.77 100.98,62.78
  BOTTOM w0.165: 100.98,62.78 100.7,63.06 99.38,63.06 98.93,63.5 93.11,63.5 92.43,64.18 92.43,66.25 92.3,66.37 91.5,66.37 91.38,66.25 91.38,65.49 v1(91.66,65.2) ; CON2000.127 69.2,60.82 68.5,60.12 67.31,60.12 67.11,60.32 v1(67.11,61.59)
M_A_A7: length 53.9
  TOP w0.165: v1(65.38,62.82) v2(65.38,63.65)
  IN1 w0.152: v1(92.91,65.2) 92.91,64.67 92.78,64.54 92.28,64.54 92.09,64.73 92.09,66.01 91.61,66.5 75.04,66.5 71.47,62.92 66.17,62.92 66.04,63.05 66.04,63.78 65.88,63.93 65.1,63.93 64.97,63.81 64.97,63.48 65.1,63.35 65.25,63.35 65.38,63.22 v1(65.38,62.82)
  BOTTOM w0.076: 101.19,62.99 101.36,62.83 104.25,62.83 104.37,62.7 105.36,62.7 105.58,62.49 106.14,62.49 106.46,62.17 U0400.AW52
  BOTTOM w0.165: CON2000.122 65.15,62.07 65.38,62.3 v1(65.38,62.82) ; 101.19,62.99 100.86,63.32 99.74,63.32 99.03,64.04 v2(94.56,64.04) 93.21,64.04 92.91,64.34 v1(92.91,65.2)
M_A_A8: length 53.6
  TOP w0.165: v1(68.33,61.59) 68.33,62.63 v2(68.21,62.75)
  IN1 w0.152: v1(90.4,65.2) 89.97,65.63 75.4,65.63 71.82,62.05 71.48,62.05 71.37,61.95 71.37,61.62 71.16,61.41 70.85,61.41 70.74,61.52 70.74,61.9 70.61,62.03 70.26,62.03 70.15,61.92 70.15,61.17 70,61.01 69.69,61.01 69.54,61.17 69.54,61.9 69.39,62.05 68.43,62.05 68.33,61.96 v1(68.33,61.59)
  BOTTOM w0.076: U0400.AY52 105.78,61.98 105.26,61.98 105.12,62.04 104.87,62.04 104.75,62 104.37,62 104.05,62.32 100.66,62.32 100.64,62.33
  BOTTOM w0.165: CON2000.125 69.32,61.32 68.39,60.39 67.88,60.39 67.6,60.67 67.6,60.85 68.16,61.41 68.16,61.42 v1(68.33,61.59) ; 100.64,62.33 99.87,62.33 99.28,61.74 98.17,61.74 98,61.9 98,62.35 97.87,62.48 97.47,62.48 97.34,62.35 97.34,61.9 97.18,61.74 96.85,61.74 96.68,61.9 96.68,62.31 96.55,62.44 96.16,62.44 96.02,62.29 96.02,61.9 95.86,61.74 95.53,61.74 95.36,61.9 95.36,62.36 95.23,62.49 94.83,62.49 94.7,62.36 94.7,61.9 94.53,61.74 93.62,61.74 91.47,63.89 91.46,63.89 91.07,64.27 90.62,64.27 90.4,64.49 90.4,65.08 v1(90.4,65.2)
M_A_A9: length 50.9
  TOP w0.165: v1(68.05,64.85) 68.58,65.38 v2(68.66,65.38)
  IN1 w0.152: v1(68.05,64.85) 67.67,64.85 67.54,64.98 67.54,65.4 67.67,65.53 69.51,65.53 70.09,66.11 70.1,66.11 72.21,68.22 94.33,68.22 94.4,68.15 94.4,68.15 97.7,64.86 98.06,64.86 100.09,64.86 100.8,64.15 101.72,64.15 v3(102.13,63.73)
  BOTTOM w0.076: v3(102.13,63.73) 102.54,63.32 104.45,63.32 104.48,63.3 U0400.BB54
  BOTTOM w0.165: v1(68.05,64.85) 67.62,64.42 65.74,64.42 65.56,64.24 65.56,63.32 66.56,62.32 CON2000.121
M_A_A10: length 53.1
  TOP w0.165: v2(67.51,54.28) 67.13,54.28 v1(66.6,53.76)
  IN1 w0.152: v1(66.6,53.76) 73.93,53.76 78.83,58.66 90.02,58.66 90.23,58.45 104.44,58.45 105.7,59.7 105.7,60.96 106.57,61.83 107.68,61.83 107.81,61.71 v3(108.09,61.43)
  BOTTOM w0.089: U0400.AT50 108.09,61.32 v3(108.09,61.43)
  BOTTOM w0.165: v1(66.6,53.76) 65.32,55.03 64.05,55.03 63.09,54.07 CON2000.146
M_A_A11: length 51
  TOP w0.165: v1(63.4,62.87) 63.35,62.92 v2(63.35,63.86)
  IN1 w0.152: v3(101.57,63.71) 101.55,63.71 101.5,63.76 100.79,63.76 100.16,64.39 97.56,64.39 94.22,67.72 94.22,67.72 94.15,67.79 72.39,67.79 70.28,65.68 70.27,65.68 69.55,64.95 69.55,64.72 69.19,64.37 62.71,64.37 62.59,64.24 62.59,62.99 62.71,62.87 v1(63.4,62.87)
  BOTTOM w0.076: v3(101.57,63.71) 102.12,63.16 104.38,63.16 104.51,63.03 104.87,63.03 105.14,63.3 U0400.BA54
  BOTTOM w0.165: v1(63.4,62.87) 63.11,62.57 CON2000.120
M_A_A12: length 53
  TOP w0.165: v1(67.13,63.86) v2(67.13,64.49)
  IN1 w0.152: v1(67.13,63.86) 66.62,63.86 66.5,63.73 66.5,63.55 66.7,63.35 70.66,63.35 70.89,63.58 70.89,64.18 71,64.29 71.32,64.29 71.6,64.01 71.95,64.01 74.87,66.93 91.79,66.93 92.3,66.42 92.57,66.42 92.74,66.59 92.74,66.75 92.86,66.88 93.19,66.88 93.32,66.75 93.32,65.86 93.5,65.69 93.68,65.69 v1(94.16,65.2)
  BOTTOM w0.076: 101.32,63.38 101.7,62.99 104.31,62.99 104.44,62.86 105.32,62.86 105.57,63.11 105.81,63.11 105.83,63.1 106.16,63.1 106.46,63.4 U0400.AW54
  BOTTOM w0.165: CON2000.119 66.43,62.82 65.82,63.43 65.82,63.69 66,63.86 67.13,63.86 v1(67.13,63.86) ; 101.32,63.38 101.09,63.6 100.09,63.6 99.21,64.48 94.88,64.48 v1(94.16,65.2)
M_A_A13: length 54.8
  TOP w0.165: v1(65.58,52.07) v2(65.58,52.71)
  IN1 w0.152: v3(108.05,59.6) 107.4,59.6 104.11,56.31 99.49,56.31 99.34,56.47 99.34,56.54 99.19,56.7 98.58,56.7 98.43,56.54 98.43,56.47 98.28,56.31 97.67,56.31 97.51,56.47 97.51,56.54 97.36,56.7 96.75,56.7 96.6,56.54 96.6,56.47 96.45,56.31 78.98,56.31 77.39,54.72 77.39,54.51 77.49,54.41 77.49,54.19 77.27,53.98 77.06,53.98 76.96,54.07 76.74,54.07 76.44,53.77 76.44,53.55 76.53,53.45 76.53,53.24 76.32,53.02 76.1,53.02 76,53.12 75.79,53.12 75.57,52.91 75.57,52.69 75.67,52.59 75.67,52.38 75.46,52.16 75.24,52.16 75.14,52.26 74.93,52.26 74.71,52.04 74.71,51.83 74.81,51.73 74.81,51.51 74.59,51.3 74.38,51.3 74.28,51.39 74.07,51.39 73.83,51.16 73.83,51.16 73.67,51.01 70.98,51.01 70.34,51.64 66.01,51.64 v1(65.58,52.07)
  BOTTOM w0.076: U0400.AU46 107.78,59.48 107.91,59.6 v3(108.05,59.6)
  BOTTOM w0.165: CON2000.158 64.23,51.07 64.74,51.59 65.46,51.59 65.58,51.72 v1(65.58,52.07)
M_A_A14: length 52.5
  TOP w0.165: v1(67.56,51.16) 67.56,50.8 v2(67.89,50.47)
  IN1 w0.152: v1(67.56,51.16) 68.05,50.68 70.7,50.68 70.8,50.57 74.48,50.57 78.61,54.71 78.61,54.92 78.51,55.02 78.51,55.24 78.95,55.67 79.16,55.67 79.26,55.57 79.47,55.57 79.79,55.88 80.22,55.88 80.37,55.73 80.37,55.32 80.53,55.17 81.14,55.17 81.29,55.32 81.29,55.73 81.44,55.88 101.86,55.88 101.99,56.01 105.25,56.01 106.78,57.54 106.78,58.6 107.35,59.17 107.7,59.17 107.82,59.05 v3(108.18,58.69)
  BOTTOM w0.076: v3(108.18,58.69) 108.18,58.89 U0400.AT46
  BOTTOM w0.165: CON2000.151 67.82,52.82 67.69,52.7 67.69,51.86 67.56,51.74 v1(67.56,51.16)
M_A_A15: length 53.6
  TOP w0.165: v2(106.93,60.12) 107.12,60.12 v3(107.47,60.48)
  IN1 w0.152: v1(64.36,52.07) 64.54,52.24 64.54,52.25 64.79,52.5 70.75,52.5 71.39,51.87 73.32,51.87 78.62,57.18 79.24,57.79 81.75,57.79 81.87,57.67 81.87,57.33 82,57.2 82.81,57.2 82.97,57.36 82.97,57.67 83.09,57.79 83.75,57.79 83.88,57.67 83.88,57.36 84.03,57.2 84.64,57.2 84.8,57.36 84.8,57.67 84.92,57.79 85.6,57.79 85.73,57.67 85.73,57.3 85.85,57.18 89.64,57.18 90.04,57.58 101.55,57.58 101.72,57.76 104.55,57.76 104.55,57.76 104.75,57.76 v3(107.47,60.48)
  BOTTOM w0.089: U0400.AU48 107.59,60.25 107.47,60.37 v3(107.47,60.48)
  BOTTOM w0.165: CON2000.156 63.64,51.57 63.75,51.46 64.16,51.46 64.36,51.67 v1(64.36,52.07)
M_A_A16: length 53.9
  TOP w0.165: v3(107.45,61.43) 106.34,61.43 v2(105.79,61.98)
  IN1 w0.152: v1(65.33,53.76) 66.15,52.94 70.93,52.94 71.08,52.78 73.62,52.78 79.06,58.23 89.84,58.23 90.05,58.01 104.44,58.01 105.95,59.53 105.95,60.75 106.19,60.98 106.19,60.98 106.42,61.21 106.64,61.43 v3(107.45,61.43)
  BOTTOM w0.089: U0400.AU50 107.54,60.97 107.45,61.06 v3(107.45,61.43)
  BOTTOM w0.165: v1(65.33,53.76) 65.33,52.76 65.15,52.57 CON2000.152
M_A_ACT_N: length 50.4
  TOP w0.165: v2(65.76,66.5) v1(65.22,65.96)
  IN1 w0.152: v3(103.81,63.71) 103.81,63.73 103.07,64.47 101.43,64.47 101.22,64.47 101.22,64.47 100.99,64.47 100.17,65.29 97.88,65.29 94.58,68.59 94.58,68.59 94.51,68.66 72.03,68.66 69.92,66.54 69.92,66.54 69.33,65.96 67.15,65.96 67,65.81 67,65 66.85,64.85 66.24,64.85 66.08,65 66.08,65.81 65.93,65.96 v1(65.22,65.96)
  BOTTOM w0.076: U0400.BA55 105.41,64.19 105.18,64.19 105.1,64.23 104.9,64.23 104.5,64.11 104.22,64.11 v3(103.81,63.71)
  BOTTOM w0.165: CON2000.114 63.34,64.07 v1(65.22,65.96)
M_A_BA0: length 52.3
  TOP w0.165: v3(108.15,62.3) v2(107.47,62.3)
  IN1 w0.152: v1(64.01,53.76) 64.46,54.21 66.97,54.21 67.17,54.41 73.97,54.41 78.65,59.09 90.2,59.09 90.41,58.88 101.61,58.88 104.5,58.88 105.41,59.78 105.41,61.06 106.43,62.09 107.93,62.09 v3(108.15,62.3)
  BOTTOM w0.165: v1(64.01,53.76) 64.01,53.29 63.79,53.07 CON2000.150 ; v3(108.15,62.3) 108.15,62.25 U0400.AU52
M_A_BA1: length 53.5
  TOP w0.165: v1(66.9,52.07) 67.34,52.5 67.34,52.52 v2(67.35,52.52)
  IN1 w0.152: v1(66.9,52.07) 70.57,52.07 71.21,51.44 73.49,51.44 78.8,56.75 79.36,56.75 79.51,56.9 79.51,57.15 79.67,57.3 80.28,57.3 80.43,57.15 80.43,56.9 80.58,56.75 90.2,56.75 90.35,56.9 90.35,56.97 90.5,57.13 91.11,57.13 91.26,56.97 91.26,56.9 91.42,56.75 92.03,56.75 92.18,56.9 92.18,56.97 92.33,57.13 92.94,57.13 93.09,56.97 93.09,56.9 93.24,56.75 93.85,56.75 94.01,56.9 94.01,56.97 94.16,57.13 94.77,57.13 94.92,56.97 94.92,56.9 95.05,56.77 95.71,56.77 95.84,56.9 95.84,56.97 95.99,57.13 101.63,57.13 101.98,57.48 104.92,57.48 107.47,60.04 107.75,60.04 v3(108.19,60.48)
  BOTTOM w0.076: U0400.AT48 108.43,60.23 v3(108.19,60.48)
  BOTTOM w0.165: CON2000.145 67.89,54.32 66.9,53.34 v1(66.9,52.07)
M_A_BG0: length 51.2
  TOP w0.165: v2(69.7,64.09) 69.46,63.84 v1(69.04,63.84)
  IN1 w0.089: v3(103.25,63.71) 102.86,63.32 101.75,63.32 101.75,63.32 101.41,63.32 101.22,63.5
  IN1 w0.152: v1(69.04,63.84) 69.35,63.84 69.47,63.96 69.85,63.96 70,63.81 70.33,63.81 70.46,63.94 70.46,65.25 70.75,65.54 70.97,65.54 71.81,64.7 72.03,64.7 72.24,64.92 72.24,65.13 71.4,65.98 71.4,66.19 71.62,66.41 71.83,66.41 72.67,65.56 72.89,65.56 73.11,65.78 73.11,66 72.26,66.84 72.26,67.05 72.57,67.36 93.62,67.36 93.75,67.23 93.75,66.27 94.12,65.9 94.3,65.9 94.75,66.36 94.93,66.36 95.42,65.86 95.42,65.68 94.97,65.23 94.97,64.95 95.17,64.75 96.58,64.75 97.37,63.96 100.23,63.96 100.69,63.5 101.22,63.5
  BOTTOM w0.076: v3(103.25,63.71) 103.82,64.28 104.48,64.28 104.87,64.39 105.14,64.39 105.17,64.38 105.22,64.36 106,64.36 U0400.AY55
  BOTTOM w0.165: v1(69.04,63.84) 69.06,63.82 CON2000.115
M_A_BG1: length 52.3
  TOP w0.165: v3(106.25,65.05) v2(105.69,64.49)
  IN1 w0.152: v3(106.25,65.05) 105.42,65.05 104.83,64.47 103.81,64.47 103.56,64.72 101.24,64.72 100.21,65.75 98.03,65.75 94.71,69.07 94.71,69.07 94.35,69.42 89.9,69.42 89.56,69.09 71.83,69.09 69.13,66.39 67.07,66.39 v1(66.52,66.93)
  BOTTOM w0.076: U0400.AY54 106.04,63.4 106.61,63.96 106.61,64.16 106.33,64.44 106.33,64.98 v3(106.25,65.05)
  BOTTOM w0.165: CON2000.113 68.88,64.32 68.55,64.65 68.55,65.13 68.3,65.38 66.69,65.38 66.52,65.55 v1(66.52,66.93)
M_A_D0: length 64.9
  TOP w0.102: v1(64.01,90.3) 64.01,89.94 v2(63.68,89.61)
  IN1 w0.097: v1(64.01,90.3) 65.33,91.62 69.11,91.62 69.42,91.93 77.7,91.93 79.97,89.65 89.22,89.65 90.58,88.29 102.54,88.29 102.85,87.98 105.67,87.98 105.73,87.92 105.84,87.81 105.84,87.81 112.09,81.56 112.09,81.56 112.09,81.3 112.09,81.3 112.09,77.87 v1(112.54,77.42)
  BOTTOM w0.076: 111.9,75.26 111.9,74.02 111.63,73.76 111.63,73.48 U0400.AL71
  BOTTOM w0.102: v1(64.01,90.3) 63.6,90.71 63.17,90.71 63.04,90.57 CON2000.8 ; v1(112.54,77.42) 111.9,76.77 111.9,75.26
M_A_D1: length 65.1
  TOP w0.102: v2(68.48,93.35) v1(68.48,92.64)
  IN1 w0.097: v1(68.48,92.64) 68.83,92.28 69.67,92.28 69.78,92.39 69.78,92.51 69.88,92.61 70.08,92.61 70.19,92.51 70.19,92.39 70.29,92.29 70.49,92.29 70.59,92.39 70.59,92.51 70.69,92.61 70.9,92.61 71,92.51 71,92.39 71.1,92.29 71.42,92.29 71.52,92.39 71.52,92.57 71.62,92.67 71.82,92.67 71.93,92.57 71.93,92.39 72.03,92.29 72.35,92.29 72.45,92.39 72.45,92.53 72.55,92.64 72.75,92.64 72.85,92.53 72.85,92.39 72.96,92.29 77.78,92.29 80.1,89.96 89.35,89.96 90.71,88.61 102.67,88.61 102.98,88.29 105.8,88.29 105.86,88.23 105.86,88.23 105.97,88.12 105.97,88.12 105.98,88.12 105.99,88.12 112.54,81.56 v1(112.54,78.03)
  BOTTOM w0.076: 110.73,75.26 110.73,74.06 110.6,73.93 110.6,73.19 110.56,73.11 110.56,72.93 110.6,72.8 110.6,72.54 110.56,72.46 110.56,71.59 110.77,71.38 U0400.AL68
  BOTTOM w0.102: v1(68.48,92.64) 69.29,91.82 CON2000.3 ; v1(112.54,78.03) 112.12,77.6 112.12,77.45 110.73,76.06 110.73,75.26
M_A_D2: length 66
  TOP w0.102: v2(67.42,87.09) 67.18,87.33 v1(67.18,87.84)
  IN1 w0.097: v1(110.1,76.11) 109.68,76.53 109.68,79.48 103.27,85.88 101.98,85.88 101.72,86.14 89.78,86.14 88.42,87.51 84.22,87.51 84.22,87.5 79.16,87.5 77.05,89.62 73.41,89.62 73.31,89.52 73.31,89.18 73.21,89.08 73.02,89.08 72.92,89.18 72.92,89.52 72.83,89.62 72.63,89.62 72.54,89.52 72.54,88.68 72.44,88.58 72.25,88.58 72.15,88.68 72.15,89.52 72.05,89.62 71.86,89.62 71.77,89.52 71.77,88.68 71.67,88.58 71.48,88.58 71.38,88.68 71.38,89.52 71.28,89.62 71.09,89.62 70.99,89.52 70.99,88.68 70.9,88.58 70.56,88.58 70.47,88.68 70.47,88.88 70.37,88.98 70.18,88.98 70.08,88.88 70.08,88.68 69.98,88.58 68.7,88.58 68.65,88.52 67.87,88.52 v1(67.18,87.84)
  BOTTOM w0.076: 109.65,74.73 109.54,74.62 109.54,73.99 109.73,73.8 109.73,72.68 109.95,72.47 109.95,71.9 110.26,71.58 U0400.AN68
  BOTTOM w0.102: v1(110.1,76.11) 109.68,75.68 109.68,74.75 109.65,74.73 ; v1(67.18,87.84) 67.69,87.32 CON2000.21
M_A_D3: length 64.8
  TOP w0.102: v2(65.68,87.15) 65.68,87.35 v1(65.18,87.86)
  IN1 w0.097: v1(110.1,76.72) 110.1,79.55 108.21,81.45 108.21,81.58 108.3,81.68 108.3,81.81 108.16,81.95 108.03,81.95 107.93,81.86 107.8,81.86 107.66,81.99 107.66,82.13 107.75,82.22 107.75,82.36 107.62,82.5 107.48,82.5 107.39,82.4 107.25,82.4 107.11,82.54 107.11,82.68 107.21,82.77 107.21,82.91 107.07,83.04 106.93,83.04 106.84,82.95 106.7,82.95 106.57,83.09 106.57,83.22 106.66,83.32 106.66,83.45 106.52,83.59 106.39,83.59 106.29,83.49 106.16,83.49 106.02,83.63 106.02,83.77 106.11,83.86 106.11,84 105.98,84.13 105.84,84.13 105.75,84.04 105.61,84.04 105.47,84.18 105.47,84.31 105.57,84.41 105.57,84.81 104.18,86.19 102.11,86.19 101.85,86.46 89.91,86.46 88.51,87.86 79.24,87.86 77.17,89.93 70.49,89.93 69.46,88.89 66.21,88.89 v1(65.18,87.86)
  BOTTOM w0.076: U0400.AN69 110.4,72.17 110.4,72.5 110.43,72.58 110.43,72.78 110.41,72.86 110.4,72.87 110.4,73.15 110.43,73.23 110.43,74 110.54,74.11 110.54,75.19
  BOTTOM w0.102: CON2000.20 63.02,87.57 63.2,87.4 64.72,87.4 v1(65.18,87.86) ; v1(110.1,76.72) 110.54,76.29 110.54,75.19 110.54,75.19
M_A_D4: length 65.4
  TOP w0.102: v2(65.42,89.65) 65.25,89.82 v1(65.25,90.3)
  IN1 w0.097: v1(112.54,76.18) 111.78,76.94 111.78,81.43 105.54,87.67 102.72,87.67 102.41,87.98 90.45,87.98 89.09,89.34 79.84,89.34 77.57,91.61 70.1,91.61 69.49,91.01 65.96,91.01 v1(65.25,90.3)
  BOTTOM w0.076: U0400.AL70 111.49,72.83 111.66,73.01 111.72,73.13 111.76,73.25 111.76,73.35 111.81,73.4 111.81,73.71 112.06,73.95 112.06,75.18 112.14,75.26
  BOTTOM w0.102: 112.14,75.26 112.15,75.28 112.15,75.79 v1(112.54,76.18) ; v1(65.25,90.3) 65.25,90.66 64.33,91.57 CON2000.4
M_A_D5: length 65.1
  TOP w0.102: v1(67.77,92.05) v2(67.13,92.05)
  IN1 w0.097: v1(112.57,75.54) 112.96,75.92 112.96,81.6 107.05,87.5 107.04,87.5 105.63,88.92 90.84,88.92 89.48,90.28 80.23,90.28 77.31,93.2 68.13,93.2 67.77,92.83 v1(67.77,92.05)
  BOTTOM w0.076: 112.34,75.21 112.23,75.09 112.23,73.89 111.99,73.65 111.99,73.35 111.94,73.3 111.9,73.14 111.88,73.07 111.87,72.99 111.83,72.86 111.76,72.68 111.76,72.5 111.49,72.24 U0400.AL69
  BOTTOM w0.102: 112.34,75.21 112.57,75.44 v1(112.57,75.54) ; CON2000.7 68.68,90.82 68.58,90.93 68.28,90.93 67.77,91.44 v1(67.77,92.05)
M_A_D6: length 63.7
  TOP w0.102: v2(68.43,88.57) v1(68.43,87.86)
  IN1 w0.097: v1(68.43,87.86) 68.83,88.27 72.85,88.27 72.95,88.36 72.95,88.63 73.04,88.72 73.24,88.72 73.33,88.63 73.33,88.36 73.43,88.27 73.78,88.27 73.87,88.36 73.87,89.21 73.97,89.3 74.16,89.3 74.26,89.21 74.26,88.36 74.36,88.27 74.55,88.27 74.65,88.36 74.65,89.21 74.74,89.3 74.94,89.3 75.03,89.21 75.03,88.36 75.13,88.27 75.32,88.27 75.42,88.36 75.42,89.21 75.52,89.3 75.71,89.3 75.8,89.21 75.8,88.36 75.9,88.27 76.09,88.27 76.19,88.36 76.19,89.21 76.29,89.3 76.48,89.3 76.58,89.21 76.58,88.36 76.67,88.27 76.99,88.27 77.09,88.36 77.09,88.68 77.18,88.78 77.38,88.78 77.47,88.68 77.47,88.36 77.57,88.27 77.95,88.27 79.03,87.19 84.35,87.19 84.35,87.19 88.22,87.19 89.58,85.83 101.59,85.83 101.86,85.57 103.14,85.57 109.37,79.35 109.37,75.62 v3(110.1,74.88)
  BOTTOM w0.076: v3(110.1,74.88) 109.71,74.48 109.71,74.06 109.9,73.88 109.9,72.95 U0400.AN70
  BOTTOM w0.102: CON2000.17 68.89,88.32 v1(68.43,87.86)
M_A_D7: length 62.9
  TOP w0.102: v2(63.93,87.23) v1(63.93,87.86)
  IN1 w0.097: v3(110.1,74.24) 109.05,75.29 109.05,79.22 103.02,85.26 101.73,85.26 101.46,85.52 89.45,85.52 88.09,86.88 84.48,86.88 84.48,86.88 78.9,86.88 77.82,87.96 74.49,87.96 74.39,87.86 74.39,87.75 74.29,87.66 74.1,87.66 74,87.75 74,87.86 73.91,87.96 73.71,87.96 73.62,87.86 73.62,87.58 73.52,87.48 73.33,87.48 73.23,87.58 73.23,87.86 73.14,87.96 72.94,87.96 72.85,87.86 72.85,87.53 72.75,87.43 72.56,87.43 72.46,87.53 72.46,87.86 72.36,87.96 72.17,87.96 72.07,87.86 72.07,87.53 71.98,87.43 71.78,87.43 71.69,87.53 71.69,87.86 71.59,87.96 71.4,87.96 71.3,87.86 71.3,87.53 71.21,87.43 71.01,87.43 70.92,87.53 70.92,87.86 70.82,87.96 70.63,87.96 70.53,87.86 70.53,87.53 70.43,87.43 70.24,87.43 70.14,87.53 70.14,87.86 70.05,87.96 69.85,87.96 69.76,87.86 69.76,87.53 69.66,87.43 64.36,87.43 v1(63.93,87.86)
  BOTTOM w0.076: U0400.AN71 110.16,74.18 v3(110.1,74.24)
  BOTTOM w0.102: v1(63.93,87.86) 63.22,88.57 CON2000.16
M_A_D8: length 57.8
  TOP w0.102: v2(67.74,85.07) 67.74,85.27 67.16,85.85 v1(67.16,85.88)
  IN1 w0.097: v1(108.05,76.3) 108.05,77.61 101.06,84.6 89.07,84.6 87.71,85.96 78.52,85.96 77.97,86.51 71.76,86.51 71.66,86.42 71.66,86.06 71.56,85.96 71.37,85.96 71.27,86.06 71.27,86.42 71.18,86.51 70.99,86.51 70.89,86.42 70.89,86.06 70.79,85.96 70.6,85.96 70.5,86.06 70.5,86.42 70.41,86.51 70.21,86.51 70.12,86.42 70.12,86.06 70.02,85.96 69.83,85.96 69.73,86.06 69.73,86.39 69.6,86.51 67.28,86.51 67.16,86.39 v1(67.16,85.88)
  BOTTOM w0.076: U0400.AR70 109.4,72.95 109.4,73.66 109.21,73.84 109.21,74.33 108.48,75.06 108.48,75.16 108.38,75.26
  BOTTOM w0.102: CON2000.29 67.71,85.32 v1(67.16,85.88) ; 108.38,75.26 108.05,75.59 v1(108.05,76.3)
