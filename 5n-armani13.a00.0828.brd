# Allegro board 5n-armani13.a00.0828.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3P3V_CAM: length 4.4
  TOP w0.432: R3004.2 57.07,99.55 57.18,99.65 C3003.1 58.26,100.07 v2(58.42,100.23) 59.22,100.23 v1(59.53,99.93)
  BOTTOM w0.305: CON3000.8 59.58,99.98 v1(59.53,99.93)
+3P3V_CCG4: length 54.9
  TOP w0.254: v1(34.75,76.43) 35.06,76.74 R5807.1
  TOP w0.432: v1(32.89,90.07) v2(33.35,90.53) 33.5,90.68 33.86,90.68 33.88,90.71 33.91,90.71 R5817.1 ; R5809.1 47.17,75.44 v1(47.17,76.2) ; v1(36.21,83.53) 36.98,82.76 R5805.2 R5806.2 ; R5808.1 44.15,72.49 v1(44.49,72.84) ; R5818.1 v1(33.68,73.56) ; R5811.1 R5810.1 38.96,82.4 v1(39.14,82.58) 39.14,82.64 R5812.1
  IN1 w0.508: v1(41.45,84.05) 41.45,83.75 40.28,82.58 v1(39.14,82.58)
  IN2 w0.254: 33.32,76.43 34.75,76.43 v1(34.75,76.43)
  IN2 w0.508: v1(33.68,73.56) 33.32,73.92 33.32,82.17 34.68,83.53 v1(36.21,83.53)
  BOTTOM w0.432: v1(39.14,82.58) 39.14,82.61 38.44,83.31 v2(38.43,83.31) 36.43,83.31 v1(36.21,83.53) 36.12,83.62 36.12,86.6 32.92,89.8 32.92,90.05 v1(32.89,90.07)
  BOTTOM w0.508: v1(41.45,84.05) 41.45,83.09 43.92,80.62 43.92,79.45 45.68,77.69 46.87,77.69 47.23,77.33 47.23,76.26 v1(47.17,76.2) 47.17,74.21 46.4,73.43 45.09,73.43 v1(44.49,72.84)
+3P3V_DONGLE: length 3.8
  BOTTOM w0.229: U5702.13 17.68,78.51 17.09,77.93 C5724.1
  BOTTOM w0.432: v2(18.05,77.33) 17.78,77.6 C5724.1 R5712.2
+3P3V_DVDD: length 40.5
  TOP w0.508: R3826.1 v2(14.43,21.64) 14.86,22.07 L3800.2 18.52,22.07 C3801.1 18.47,23.27 18.09,23.27 v1(17.86,23.04)
  IN2 w0.508: v1(20.75,37.29) 20.47,37.01 v1(20.47,35.92) 20.47,27.08 18.69,25.3 18.69,23.88 v1(17.86,23.04)
  BOTTOM w0.229: 17.86,25.33 17.24,25.94 U3800.18 ; U3800.3 20.7,30.64
  BOTTOM w0.432: R3824.1 20.39,35.78 20.47,35.87 v1(20.47,35.92) ; 20.7,30.64 21.13,30.21 C3839.2 C3800.1 21.42,31.39 21.92,31.89 21.92,32 R3811.1 22.52,32.06 23.17,32.06 23.88,32.76 23.88,34.62 23.43,35.07 22.75,35.07 22.65,35.17 R3809.1 22.24,35.81 20.76,37.29 v1(20.75,37.29) ; 17.86,25.33 C3803.1 17.86,24.23 17.55,23.93 C3802.1 17.55,23.35 v1(17.86,23.04)
+3P3V_EMMC: length 16.3
  TOP w0.229: U2500.E6 v1(100.03,22.51) 99.8,22.51 U2500.F5
  TOP w0.254: U2500.J10 101.92,21.39 v1(101.42,21.39) 101.42,20.89 U2500.K9
  TOP w0.432: R2510.2 C2501.1 C2504.1 93.11,23.96 C2500.1 93.52,23.56 v1(93.52,23.32)
  IN1 w0.508: v1(100.03,22.51) 99.34,23.19 98.55,23.19 97.58,22.22 95.2,22.22 94.1,23.32 v1(93.52,23.32)
  BOTTOM w0.102: v2(94.34,25.25) 93.73,24.64 93.73,23.52 v1(93.52,23.32)
+3P3V_LAN: length 72.6
  IN1 w0.508: v1(213.19,40.32) 208.66,44.86 204.42,44.86 202.82,46.46 202.82,53.83 v1(202.39,54.26)
  IN2 w0.508: v1(213.19,40.32) 214.07,39.44 214.07,31.17 v1(213.23,30.33)
  IN3 w0.508: v1(190.41,20.31) 188.72,22 188.72,25.66 189.57,26.51 193.66,26.51 194.69,27.54 196.16,27.54 202.82,34.19 209.37,34.19 v1(213.23,30.33)
  BOTTOM w0.102: v1(190.41,20.31) 190.32,20.22 CON5104.1
  BOTTOM w0.508: PR9108.1 205.15,54.08 204.88,54.36 202.49,54.36 v1(202.39,54.26) ; v1(213.23,30.33) v2(213.89,30.33)
+3P3V_PAD: length 41.6
  TOP w0.432: R5104.1 52.67,6.92 v1(52.6,6.86) 53.23,6.24 54.24,6.24 54.72,6.72 R5102.1 R5108.1 55.65,6.73 56.1,6.29 57.11,6.29 57.52,6.69 R5105.1 C5126.1 R5106.1 ; R5103.1 51.74,7.01 51.61,6.88 v1(51.44,6.88) ; v1(42.16,8.28) 42.34,8.11 R5109.2
  TOP w0.508: v1(46.43,8.49) v2(47,7.91) 47.3,7.62 47.3,6.86 46.56,6.12 45.57,6.12 v1(44.67,5.22) 43.93,5.22 43.79,5.36 v1(42.95,5.36) ; v1(42.95,5.36) 41.53,5.36 41.12,5.77 41.12,7.9 41.5,8.28 v1(42.16,8.28) ; v1(42.95,5.36) R5107.1
  IN3 w0.508: v1(46.43,8.49) 49.99,8.49 51.44,7.04 v1(51.44,6.88)
  BOTTOM w0.356: v1(44.67,5.22) 45.24,5.8 Q5102.5 ; v1(46.43,8.49) 46.23,8.28 Q5103.5 ; Q5104.2 v1(42.95,5.36) Q5104.5 ; Q5103.2 v1(42.16,8.28)
  BOTTOM w0.432: CON5100.8 50.73,9.34
  BOTTOM w0.508: 50.73,9.34 51.44,8.64 v1(51.44,6.88) 52.15,6.88 52.17,6.86 v1(52.6,6.86)
+3P3V_PANEL: length 2.1
  BOTTOM w0.305: CON3000.29 70.08,101.42 ; CON3000.30 70.58,101.46 ; CON3000.28 69.58,101.44
  vias: v1(64.52,102.9) v1(65.13,102.9) v1(65.74,102.9) v1(69.82,102.14) v1(70.43,102.11) v2(64.97,101.81)
+3P3V_PANEL_O:
  vias: v1(50.93,100.48) v1(51.54,100.48) v1(52.15,100.48) v1(62,102.85) v1(62.61,102.85) v1(63.22,102.85) v2(62.6,101.83)
+3P3V_SENSOR: length 42.3
  TOP w0.254: U3701.10 155.33,22.24 ; U3701.9 155.37,21.74
  TOP w0.432: R3701.1 R3700.1 150.14,22 v1(149.71,21.57)
  IN2 w0.254: v1(149.71,21.57) 148.67,21.57 147.75,22.48 142.32,22.48 140.74,20.91 136.04,20.91 134.59,19.46 133.22,19.46 131.22,17.45 v1(124.92,17.45)
  IN3 w0.508: v1(155.7,21.92) 156.26,21.36 156.26,20.32 155.73,19.79 152.63,19.79 150.85,21.57 v1(149.71,21.57)
  BOTTOM w0.254: R3712.1 124.92,17.05 v1(124.92,17.45) 124.92,17.83 R3710.1 v2(124.59,19.03)
+3P3V_SSD: length 107.5
  TOP w0.254: v1(218.39,19.64) 218.98,20.22 219.43,20.22
  TOP w0.432: R3113.1 221.13,4.85 220.78,5.21 v1(220.78,5.39) ; C3118.1 223.57,3.81 223.67,3.91 C3119.1 ; C3116.1 C3117.1
  TOP w0.457: R3105.1 R3114.1 219.74,3.53 220.02,3.25 v1(222.17,3.25) 222.89,3.25 223.11,3.48 C3118.1 ; v1(222.3,2.49) C3116.1
  IN1 w0.254: v1(218.39,19.64) 218.39,19.81 216.73,21.48 210.49,21.48 203.89,14.88 203.89,12.11 202.98,11.2 201.93,11.2 v1(201.6,11.53)
  IN1 w0.762: v4(220.88,19.61) 220.88,18.54 223.75,15.67 223.75,2.87
  IN2 w0.254: v1(157.71,12.25) 158.7,13.24 160.17,13.24 161.11,12.3 165.4,12.3 166.22,11.48 172.05,11.48 172.86,12.3 179,12.3 179.86,11.44 181.54,11.44 181.93,11.05 201.12,11.05 v1(201.6,11.53)
  IN3 w0.508: v1(220.78,5.39) 220.78,5.29 220.8,5.26 220.8,4.65 222.17,3.28 v1(222.17,3.25)
  BOTTOM w0.254: Q3102.1 157.62,12.15 v1(157.71,12.25)
  BOTTOM w0.305: v1(222.3,2.49) 222.41,2.6 CON3100.74 ; CON3100.72 222.33,3.1 v1(222.17,3.25) 222.52,3.6 CON3100.70
  vias: v2(223.05,18.55) v4(222.1,20.4) v4(222.1,19.48) v4(222.12,18.52)
+3P3V_THERM: length 342.7
  TOP w0.432: R3706.2 155.4,27.13
  TOP w0.508: 155.4,27.13 155.72,27.13 156.54,26.31 156.54,23.83 158.42,21.95 158.42,20.5 159.39,19.54 v1(159.39,17.81) ; v1(19.56,45.93) v2(18.39,47.09) 18.21,47.09 v1(16.33,48.97)
  IN2 w0.508: v1(91.55,5.62) 90.39,4.45 51.46,4.45 48.56,7.34 47.93,7.34 47.54,7.74 44.49,7.74 44.43,7.67 41.48,7.67 40.69,8.46 34.9,8.46 21.62,21.75 21.62,37.65 20.5,38.77 20.5,42.5 19.56,43.44 v1(19.56,45.93) ; v1(153.66,14.9) 153.66,14.87 151.34,12.55 150.96,12.55 150.61,12.19 149.06,12.19 148.63,11.76 148.08,11.76 147.63,12.22 143.89,12.22 143.82,12.3 138.35,12.3 137.34,11.28 123.98,11.28 123.37,11.89 119.51,11.89 118.6,10.98 109.15,10.98 108.57,11.56 107.16,11.56 106.52,10.92 104.67,10.92 v1(102.95,9.2)
  IN3 w0.508: v1(91.55,5.62) 92.62,6.68 94.34,6.68 97.1,3.91 100.15,3.91 101.98,5.74 101.98,8.23 v1(102.95,9.2)
  BOTTOM w0.305: 127.23,89.24 127.02,89.45 126.76,89.45 C3700.1 ; 127.23,89.24 127.21,89.24 126.97,89 126.97,88.19 127.25,87.91 130.43,87.91 R3715.1 ; 127.23,89.24 U3700.1
  BOTTOM w0.432: C3700.1 127.15,90.68 127.15,92.94 127.69,93.47 R3708.1 ; R1911.1 16.89,49.53 v1(16.33,48.97) ; R1912.1 20.02,45.8 19.89,45.93 v1(19.56,45.93)
  BOTTOM w0.483: v1(91.55,5.62) 93.48,7.55 93.48,12.73 94.07,13.32 94.07,13.81 93.2,14.68 92.81,14.68 92.19,15.3 92.19,15.52 90.6,17.11 89.57,17.11 87.67,19.01 87.67,20.59 85.24,23.01 85.24,23.68 84.79,24.13 84.79,26.52 83.95,27.36 83.95,27.73 78.26,33.42 78.26,68.1 85.5,75.34
  BOTTOM w0.508: v1(159.39,17.81) 159.23,17.66 159.23,17.18 156.87,14.81 155.3,14.81 154.78,14.3 154.17,14.3 153.66,14.8 v1(153.66,14.9) ; C3700.1 114.96,89.87 110.62,85.52 101.65,85.52 100.61,84.48 100.61,80.67 97.05,77.12 87.27,77.12 85.5,75.34
+3P3V_TPM: length 2.5
  TOP w0.432: v2(36.8,66.55) R3915.1 R3901.2 R3917.1
+3P3V_TUSB546: length 64.7
  TOP w0.203: U5703.20 29.43,84.9 29.57,85.03
  TOP w0.229: U5703.28 25.31,85.74 24.92,86.13 ; C5702.1 23.42,78.56 24.63,78.56 25.31,79.24 U5703.1 ; U5703.6 27.31,79.18
  TOP w0.254: R5707.1 23.77,76.61 v1(23.77,76.25) 23.38,76.25 R5705.1
  TOP w0.432: C5700.1 23.11,86.57 22.83,86.85 22.83,87.4 23.17,87.73 23.8,87.73 23.83,87.71 R5711.1 ; C5700.1 23.11,85.78 23.52,85.37 v1(23.85,85.37) ; C5700.1 24.92,86.13 ; 29.57,85.03 29.92,85.38 C5701.1 C5704.1 31.17,85.8 32.46,85.8 32.61,85.96 v1(33.06,85.96) ; R5718.1 R5717.1 32.61,78.65 32.93,78.33 32.93,77.09 32,76.17 v1(32,75.8) ; v1(29.59,77.93) 29.46,77.8 R5714.2 C5703.1 27.94,78.19 27.31,78.82 27.31,79.18 ; v1(24.16,79.12) 23.47,79.12 C5702.1
  IN2 w0.508: v1(33.06,85.96) 33.06,85.46 31.37,83.77 31.37,76.43 v1(32,75.8) ; v1(29.59,77.93) 26.77,77.93 25.58,79.12 v1(24.16,79.12) 23.77,78.74 v1(23.77,76.25)
  BOTTOM w0.254: R5709.1 23.44,84.05 v2(23.72,84.33) 23.85,84.46 v1(23.85,85.37)
  BOTTOM w0.432: R5702.1 R5703.1 24.06,79.02 v1(24.16,79.12)
  BOTTOM w0.508: v1(23.85,85.37) 24.08,85.6 27.2,85.6 28.03,86.43 v2(28.99,86.43) 32.59,86.43 v1(33.06,85.96) ; v1(29.59,77.93) 30.38,77.93 32,76.3 v1(32,75.8)
+3P3VA: length 396.1
  TOP w0.254: v1(47.45,39.02) 47.21,39.25 47.21,39.27 R2306.2 ; v1(96.04,92.61) v2(96.04,90.17) 96.04,89.44 98.63,86.85 R3613.1
  TOP w0.432: R3827.1 15.98,38.2 19.44,41.66 v1(19.81,41.66) ; v1(213.21,38.1) 212.55,38.1 212.06,38.59 207.44,38.59 206.25,37.39 206.25,34.72 205.64,34.11 202.01,34.11 v1(201.63,34.5)
  TOP w0.508: v1(198.25,108.36) 197.46,109.15 186.02,109.15 181.36,104.48 177.06,104.48 174.83,106.72 157.85,106.72 156.54,105.41 155.91,105.41 154.66,106.66 146.53,106.66 143.26,103.38 143.26,102.11 v1(139.74,98.6)
  IN1 w0.254: v1(96.04,92.61) 95.56,92.13 94.62,92.13 93.48,93.26 82.83,93.26 77.52,98.58 62.76,98.58 61.11,96.93 61.11,95.35 60.35,94.59 58.78,94.59 56.62,92.43 55.17,92.43 54.46,91.72 54.46,91.7 54.18,91.42 53.67,91.42 51.84,89.59 50.22,89.59 49.15,88.52 49.15,71.71 46.08,68.63 46.08,63.68 45.77,63.38 45.77,59.06 44.98,58.27 44.98,55.93 44.93,55.88 44.93,52.17 46.05,51.06 46.05,50.17 v1(46.06,50.15)
  IN1 w0.508: v1(114.04,90.01) 114.38,89.68 128.36,89.68 128.62,89.42 130.97,89.42 132.23,90.68 132.23,93.52 135.39,96.67 137.82,96.67 v1(139.74,98.6) ; v1(213.21,38.1) 212.95,38.1 212.6,38.46 212.6,40.06 208.4,44.25 204.17,44.25 202.21,46.21 202.21,52.12 v1(201.42,52.91)
  IN3 w0.254: v1(47.45,39.02) 47.74,39.31 47.74,39.31 48.3,39.87 48.3,40.13 48.58,40.41 48.58,40.51 48.72,40.64 48.72,43.21 48.56,43.36 47.9,43.36 46.54,44.73 46.54,49.68 v1(46.06,50.15)
  IN3 w0.508: v1(198.25,108.36) 200.81,105.79 200.81,78.23 202.11,76.94 202.11,72.98 201.83,72.7 201.83,63.38 203.45,61.75 203.45,60.74 201.7,58.98 201.7,58.55 200.48,57.33 v1(200.48,56.82) 201.42,55.88 v1(201.42,52.91) ; v1(206.68,105.03) 207.14,105.03 207.62,105.51 207.62,106.94 205.33,109.22 v1(203.45,109.22)
  BOTTOM w0.229: PU8900.3 200.3,57.33
  BOTTOM w0.254: 200.3,57.33 199.95,56.97 199.95,56.58 PC8903.1 200.48,56.45 v1(200.48,56.82)
  BOTTOM w0.432: v1(201.63,34.5) 201.12,33.99 PR7702.1
  BOTTOM w0.508: v1(46.06,50.15) 46.06,50.69 44.93,51.82 42.14,51.82 40.39,53.57 30.73,53.57 24.97,47.81 24.97,44.29 22.49,41.81 19.96,41.81 v1(19.81,41.66) ; v1(203.45,109.22) 202.44,109.22 201.57,108.36 v1(198.25,108.36) ; R7204.1 v1(206.68,105.03) ; v1(96.04,92.61) 97.51,94.08 98.81,94.08 99.21,93.68 99.21,92.99 99.14,92.92 99.14,91.04 101.29,88.89 112.92,88.89 v1(114.04,90.01)
+3P3VA_CS2_A: length 2.7
  TOP w0.432: v2(198.68,57.33) 198.98,57.64 v1(198.98,57.91) 199.03,57.86 PR8912.2
  BOTTOM w0.229: PU8900.5 199.5,57.57 199.29,57.36 199.11,57.36 198.98,57.48 v1(198.98,57.91)
+3P3VSB: length 562.6
  TOP w0.254: 36.02,85.66 PU7600.4 ; R1017.1 123.86,25.09 124.09,25.09 125.1,26.09 125.1,28.15 R1100.1
  TOP w0.305: 42.14,60.38 41.94,60.57 J5301.1 41.08,60.57 40.91,60.74 40.91,61.33 41.15,61.57 J5301.3
  TOP w0.356: v1(46.96,70.61) 47.09,70.49 47.09,70.03 PC9005.1 47.64,70.22 PU9000.5
  TOP w0.432: v1(37.08,84.46) 37.03,84.51 36.12,84.51 35.92,84.71 PR7613.1 35.92,85.55 36.02,85.66 ; v1(72.08,11.04) 72.08,11.77 74.02,13.71 v1(74.02,14.01) ; R2424.1 C1800.1 C5131.1 12.47,15.85 12.98,15.34 v1(15.27,15.34) ; v1(63.27,9.91) 64.01,9.91 65.46,11.36 C1201.1 C1202.1 66.68,11.36 67.01,11.03 67.01,11.03 67.46,10.57 67.46,8.05 67.45,8.04 67.45,8.04 67.26,7.85 67.26,7.85 66.93,7.52 R1802.1 ; R2301.1 48.16,38.72 v1(48.1,38.78) ; C1205.1 93.93,27.18 94.26,27.51 v1(94.26,27.84) ; v1(111.51,26.09) 111.24,26.09 110.57,26.76 110.57,27.13 ; v1(28.68,76.33) 28.68,76.74 R5714.1 ; R1017.1 122.52,25.18 122.04,25.18 121.34,25.88 121.34,27.61 R1615.2 R1114.1 122.68,27.92 123.22,28.45 R1101.1 ; R1507.1 110.57,27.13 ; 110.57,27.13 R1106.1 ; v1(58.17,96.12) 58.47,95.81 63.04,95.81 v2(63.12,95.74) 63.27,95.58 67.06,95.58 67.92,96.45 PR7617.1 ; R3902.1 v1(35.48,56.19) ; v1(30.38,92.97) 30.45,92.89 R5004.1 ; 2.44,53.83 2.44,54.69 3.45,55.7 8.76,55.7 8.97,55.91 R3707.1 9.6,56.34 10.08,55.86 C3701.1 10.64,56.44 11.13,56.92 14.15,56.92 15.47,58.24 v1(15.47,59.13) 17.49,59.13 v1(20.89,55.74) ; 63.65,13.74 63.88,13.52 63.88,13.31 R1220.1 ; R5805.1 36.98,80.12 v1(37.52,79.59) ; PR9500.1 164.11,63.1 164.11,63.1 165.01,62.21 166.42,62.21 ; v1(116.76,24.08) 116.64,23.95 115.85,23.95 115.6,24.21 115.6,24.79 116.08,25.28 R1210.1 ; v1(40.61,57.38) 41.55,57.38 42.14,57.97 C5301.2 42.14,60.38
  TOP w0.457: PR9505.1 165.68,109.17 166.12,108.74 ; v1(106.59,100.5) 106.07,99.98 106.07,99.55 105.84,99.32 105.84,98.53 104.9,97.59 PR8606.2
  TOP w0.508: v1(106.22,18.95) 106.22,18.15 105.23,17.16 105.23,15.27 103.84,13.88 102.02,13.88 101.6,14.3 99.59,14.3 v1(99.14,13.85) 99.14,12.5 98.76,12.12 96.22,12.12 95.23,11.13 94.31,11.13 93.95,10.77 93.95,8.94 v1(92.89,7.88) ; v1(66.83,19.05) 66.83,17.55 65.77,16.5 64.68,16.5 63.88,15.7 63.88,14.86 63.65,14.63 v1(63.65,14.02) 63.65,13.74 ; v1(148.29,21.06) 147.42,21.06 146.76,21.72 146.76,24.74 151.08,29.06 151.08,30.02 151.92,30.86 158.47,30.86 161.01,28.32 169.75,28.32 170.05,28.63 173.15,28.63 v1(177.03,32.51) ; v1(44.81,10.04) 44.81,12.23 43.85,13.19 PR8814.2 39.95,13.19 38.63,14.51 v1(38.63,16.39) 38.63,19.64 39.78,20.78 PR8801.1 ; R1017.1 122.86,24.08 122.86,23.04 123.5,22.41 v1(123.75,22.41)
  TOP w1.016: 142.65,92.2 142.65,94.2 148.85,100.41 149.64,100.41 151.05,101.83 151.05,104.07 151.77,104.78 ; 167.36,108.49 167.79,108.06 173.44,108.06 175.01,109.63 175.01,111.23 176.17,112.4 177.23,112.4 178.22,113.39 181.41,113.39 183.26,111.53
  IN1 w0.508: v1(16.08,76.08) 16.08,76.66 16.23,76.81 19.05,76.81 20.03,75.83 21.93,75.83 23.24,77.14 27.87,77.14 v1(28.68,76.33) ; v1(63.27,9.91) 62.08,8.71 59.77,8.71 58.52,9.96 55.82,9.96 55.62,10.16 54.28,10.16 52.63,11.81 51.14,11.81 50.4,11.07 45.84,11.07 v1(44.81,10.04) ; v1(121.11,20.72) 121.11,20.01 121.54,19.59 122.04,19.59 122.17,19.71 127.15,19.71 131.67,15.19 138.88,15.19 139.41,14.67 142.13,14.67 v1(142.49,14.3) ; v1(177.03,32.51) 176.23,33.32 176.23,38.56 175.32,39.46 174.97,39.46 v1(174.65,39.78)
  IN2 w0.432: v1(37.08,84.46) 36.47,85.07 36.47,87.15 34.2,89.42 34.2,91.46 32.69,92.97 v1(30.38,92.97) ; v1(16.08,76.08) 16.08,73.04 17.12,72 17.12,60.78 v1(15.47,59.13)
  IN2 w0.508: v1(126.39,22.13) 126.29,22.23 126.21,22.23 126.04,22.41 v1(123.75,22.41) ; v1(148.29,21.06) 144.35,21.06 v1(143.84,21.57) ; v1(116.76,24.08) 116.64,23.95 115.88,23.95 114.4,25.43 112.7,25.43 112.04,26.09 v1(111.51,26.09) ; v1(63.65,14.02) 63.65,13.52 62.71,12.58 62.71,10.47 v1(63.27,9.91) ; 166.45,107.93 164.14,105.62 164.14,104.14 163.78,103.79 154.65,103.79 153.58,104.85 153.04,104.85 ; v1(106.22,18.95) 107.24,19.97 110.87,19.97 v1(111.2,19.64)
  IN3 w0.381: v1(111.51,26.09) 111.05,26.54 111.05,28.18 110.75,28.49 110.75,32.8 112.02,34.07 112.02,39.89
  IN3 w0.508: 166.42,107.9 164.14,105.62 164.14,104.14 163.78,103.79 154.65,103.79 153.58,104.85 153.04,104.85 ; v1(17.7,74.78) 17.37,74.78 v1(16.08,76.08) ; v1(69.62,18.98) 67.49,18.98 v1(67.44,19.03) ; v1(143.84,21.57) 143.94,21.47 143.94,17.2 142.49,15.75 v1(142.49,14.3) ; v1(111.2,19.64) 111.94,19.64 112.51,20.21 113.45,20.21 116,22.76 116,23.32 v1(116.76,24.08)
  IN3 w1.016: 191.54,107.98 189.99,109.53 185.9,109.53 184.4,111.03
  BOTTOM w0.254: CON5103.41 207.32,43.26 v1(207.59,42.98) ; R3711.1 124.18,21.97 v1(123.75,22.41) ; v1(126.39,22.13) 125.7,22.13 125.58,22 R3713.1
  BOTTOM w0.356: v1(99.14,13.85) 99.14,13.92 99.02,13.81 U1204.5 ; U1800.5 77.04,19.74 76.17,18.87 76.17,17.58 75.83,17.23 U1201.5 75.41,16.82 75.28,16.69 74.83,16.69 74.6,16.46 74.6,15.27 75.2,14.67 U1202.5 75.43,14.27 75.18,14.02 74.03,14.02 v1(74.02,14.01)
  BOTTOM w0.432: v1(94.26,27.84) 94.26,29.44 94.82,30 R1021.1 ; v1(20.89,55.74) 22.4,54.22 22.4,52.07 21.49,51.16 PR7619.1 ; R1515.1 R1516.1 112.12,20.98 111.2,20.06 v1(111.2,19.64) ; v1(174.65,39.78) 174.65,39.68 174.52,39.55 PR8705.2 ; v1(177.03,32.51) 177.47,32.08 PR8711.1 ; v1(116.76,24.08) 117.02,23.83 117.12,23.83 R1509.1 ; v1(16.08,76.08) 16.05,76.1 R5712.1 ; R5813.2 15.19,75.67 16.08,74.78 v1(17.7,74.78) ; R1504.1 R1105.1 ; R1105.1 R1104.1 ; R1105.1 123.77,23.24 123.72,23.19 123.72,22.43 v1(123.75,22.41) 123.71,22.37 R1103.1 R1109.1 R1102.1 R1510.1 ; R1901.1 106.11,20.07 106.24,19.94 106.24,18.95 v1(106.22,18.95)
  BOTTOM w0.457: R1102.1 121.13,20.75 v1(121.11,20.72) 120.35,19.97 118.69,19.97 117.91,20.75 117.91,21.19 117.4,21.69 117.4,22.56 117.42,22.58 R1509.1
  BOTTOM w0.508: 176.71,12.58 175.9,12.58 175.43,12.11 v1(175.43,10.28) ; v1(42.22,80.5) 39.22,77.5 38.48,77.5 33.93,72.95 32.19,72.95 28.81,76.33 v1(28.68,76.33) ; v1(72.08,11.04) 72.08,9.64 67.9,5.46 v1(66.61,5.46) ; v1(17.7,74.78) 17.7,75.67 18.22,76.19 D5800.1 ; v1(15.27,15.34) 17.2,13.41 30.57,13.41 33.54,16.39 v1(38.63,16.39) 38.63,15.14 38.25,14.76 38.25,5.62 v1(38.63,5.23) ; v1(142.49,14.3) 142.34,14.46 142.34,16.89 142.49,17.04 142.49,17.88 R3608.1 ; Q5101.2 45.25,10.48 v1(44.81,10.04) ; v1(65.98,5.49) 64.86,6.61 62.01,6.61 60.96,7.65 60.96,9.61 61.32,9.96 63.22,9.96 v1(63.27,9.91)
  vias: v1(143.03,91.57) v1(143.43,92.03) v1(152.48,105.06) v1(152.48,104.45) v1(166.55,108.51) v1(167.21,108.51) v1(173.94,61.85) v1(174.75,62.79) v1(175.59,64.48) v1(183.36,110.8) v1(184,110.82) v1(192.61,108.54) v1(193.19,108.08) v1(197.66,53.75) v1(197.78,54.36) v1(197.97,53.22) v1(198.48,54.74) v1(198.6,53.29) v4(45.42,94.69) v4(46.43,94.69) v4(113.28,109.27) v4(167.01,60.84) v4(167.92,60.89) v4(168.3,61.7) v4(168.33,62.59) v4(168.83,60.89) v4(169.19,61.7) v4(173.84,60.99) v4(174.7,62.03) v4(174.7,61.14) v4(175.57,63.74) v4(175.57,62.87) v4(175.56,62) v4(175.57,61.14) v4(183.04,13.24) v4(183.92,13.24) v4(184.81,13.24) v4(185.67,13.24) v4(207.04,52.86) v4(207.32,52.02) v4(207.32,51.13) v4(213.32,19.94) v4(213.8,20.79) v4(214.2,19.95)
+3P3VSB_BST1_C: length 1.1
  BOTTOM w0.508: v2(195.1,57.33) 195.1,58.17 195.28,58.35
+3P3VSB_BST_C: length 1.4
  BOTTOM w0.254: v2(196.88,60.84) 197.22,60.49 PR8914.1
+3P3VSB_FB_A: length 4.8
  BOTTOM w0.229: PU8900.4 199.9,57.46 199.35,56.91 PC8922.2 PR8921.1
  BOTTOM w0.254: PR8921.1 197.71,56.26 PR8922.1 v2(197.43,57.46)
+3P3VSB_FBR_A: length 23.2
  TOP w0.254: v2(184.4,60.53) v1(184.4,59.87)
  IN3 w0.254: v1(197.48,54.89) 194.97,54.89 194.17,55.69 194.17,59.55 193.78,59.95 190.68,59.95 189.51,61.11 185.65,61.11 v1(184.4,59.87)
  BOTTOM w0.203: 183.83,60.29 PJP8901.2
  BOTTOM w0.229: PC8922.1 PR8921.2 198.2,55.6 PC8923.1 197.43,54.93 v1(197.48,54.89)
  BOTTOM w0.254: 183.83,60.29 183.83,60.09 184.05,59.87 v1(184.4,59.87)
+3P3VSB_HG_D: length 14.6
  TOP w0.635: v4(198.19,60.28) 198.19,59.82 196.9,58.52 v2(196.9,56.77) 196.9,55.5 196.6,55.2 196.6,53.48 195.64,52.53 195.14,52.53 194.03,51.42 v4(194.03,50.6)
  BOTTOM w0.229: PU8900.10 198.66,60.01 198.39,60.28 v4(198.19,60.28)
  BOTTOM w0.635: v4(194.03,50.6) 194.03,50.27 193.51,49.74 PR8915.1
+3P3VSB_HGR_D:
  vias: v2(193.8,51.54)
+3P3VSB_LG_D: length 8.2
  BOTTOM w0.229: 198.78,61.11 199.03,61.11 199.5,60.65 PU8900.11
  BOTTOM w0.635: 198.78,61.11 198.65,61.24 197.87,61.24 197.21,61.9 196.62,61.9 196.05,61.33 v2(194.97,61.33) 194.72,61.33 193.88,60.49 193.88,59.87 193.83,59.82 PR8918.1
+3P3VSB_LGR_D: length 4.4
  BOTTOM w0.432: PQ8901.8 192.39,55.97 192.63,56.2
  BOTTOM w0.508: PR8918.2 193.97,57.44 194.69,56.72 PR8919.1 PC8920.1 192.66,56.24 192.63,56.2
+3P3VSB_PHASE2_S: length 11.5
  TOP w0.508: v1(189.61,54.87) 191.59,54.87 v2(194.02,57.29) 194.16,57.43 v1(195.94,57.43)
  BOTTOM w0.229: PC8900.2 197.1,58.27 197.45,58.61 197.65,58.61 197.92,58.88 198.24,58.88 198.57,59.21 PU8900.8
  BOTTOM w0.508: v1(195.94,57.43) 196.24,57.43 196.55,57.74 PC8900.2
+3P3VSB_SN_S:
  vias: v2(192.74,60.78)
+3P3VSB_TPM: length 34.1
  TOP w0.279: U3901.1 38.1,59.57 38.48,59.18
  TOP w0.432: R3918.1 38.54,64.27 v1(38.62,64.19) ; v1(31.01,56.37) 31.01,56.44 30.94,56.52 R3912.1 ; R3913.2 30.58,63.78 30.35,63.78 v1(30.18,63.96) ; 38.48,59.18 38.53,59.13 38.53,58.52 38.74,58.32 39.12,58.32 C3909.1 39.29,57.86 39.07,57.64 C3901.1 C3910.1 C3902.1 R3902.2 35.48,57.92 v1(35.77,58.21) ; R3916.1 v1(33.02,66.36) 32.98,66.36 v2(32.31,67.03)
  IN1 w0.508: v1(38.62,64.19) 35.77,61.33 v1(35.77,58.21) ; v1(33.02,66.36) 30.62,63.96 v1(30.18,63.96)
  IN3 w0.508: v1(31.01,56.37) 31.6,56.95 32.82,56.95 33.63,57.76 35.32,57.76 v1(35.77,58.21)
  BOTTOM w0.508: v1(33.02,66.36) 34.18,65.2 37.61,65.2 v1(38.62,64.19)
+AC_BAT_SYS: length 228.1
  TOP w0.432: 198.76,24.59 198.91,24.44 PR7711.2
  TOP w0.508: 201.37,41.35 201.37,37.37 200.57,36.56 200.57,26.99 v2(198.76,25.17) 198.76,24.59 ; PD7700.1 191.94,32.2 190.58,30.84 187.07,30.84 185.45,32.46 v4(185.45,35.26)
  TOP w0.762: v4(77.39,103.41) 77.37,103.43 77.37,107.47 76.38,108.46 76.38,109.94 76.88,110.44 80.7,110.44 82.07,111.81
  TOP w1.016: 82.07,111.81 91.49,111.81 94.74,108.56 110.26,108.56 113.68,111.98 114.95,111.98
  IN1 w1.524: 187.35,37.26 187.35,43.13 189.2,44.99 200.15,44.99 200.61,44.53
  IN1 w2.032: 119.18,113.62 140.44,113.62 146.22,107.84 156.95,107.84 157.09,107.69 163.06,107.69 166.57,111.2 168,111.2 ; 173.41,113.31 191.38,113.31 194.43,110.26 199.2,110.26 203.96,105.5 203.96,68.02 202.31,66.37
  vias: v2(154.66,44.88) v4(76.51,103.41) v4(114.86,110.98) v4(115.7,110.47) v4(115.75,111.5) v4(120.5,105.06) v4(120.52,104.19) v4(120.52,103.3) v4(154.08,57.91) v4(154.48,40.16) v4(154.48,39.14) v4(154.55,68.69) v4(155.09,57.89) v4(155.37,40.16) v4(155.37,39.22) v4(156.26,40.19) v4(156.26,39.19) v4(161.57,30.94) v4(161.58,30.01) v4(162.43,30.94) v4(162.45,30.03) v4(163.31,30.97) v4(163.31,30) v4(164.19,30.97) v4(164.22,30) v4(183.77,37.72) v4(184.23,36.98) v4(184.58,36.15) v4(184.58,35.26) v4(184.76,37.72) v4(185.17,36.96) v4(185.5,36.12) v4(199.59,66.19) v4(199.57,65.33) v4(200.46,66.19) v4(200.48,65.33) v4(200.69,42.22) v4(200.69,41.35) v4(200.71,43.08)
+BL_PWR: length 2
  BOTTOM w0.305: CON3000.1 56.08,101.35 v4(56.38,101.64) 56.58,101.43 CON3000.2
  vias: v2(57,101.02)
+BL_PWR_O: length 19
  TOP w0.508: v1(61.27,99.7) 61.21,99.7 v2(60.58,100.33)
  TOP w0.762: 60.91,103.36 61.8,104.24 68.71,104.24 69.55,103.41 71.89,103.41 v2(72.62,102.68) 74.1,102.68 75.13,103.71 v4(75.26,103.71)
  BOTTOM w0.432: C3002.1 60.22,98.28 60.72,98.77 C3001.1 61.27,99.19 v1(61.27,99.7)
+CPU_VIN1_A: length 19.5
  TOP w0.508: v1(161.46,33.06) v2(161.46,33.76)
  IN1 w0.254: v1(169.47,44.01) 170.11,43.37 170.11,38.67 169.03,37.59 166.04,37.59 161.51,33.06 v1(161.46,33.06)
  BOTTOM w0.152: 162.41,32.62 162.48,32.54 PJP7900.1
  BOTTOM w0.191: 162.41,32.62 161.9,32.62 v1(161.46,33.06)
  BOTTOM w0.254: v1(169.47,44.01) 169.47,44.45 PR7802.2
+DCIN_IN: length 530.5
  TOP w0.254: v4(39.6,110.24) 39.14,110.7 36.53,110.7 36.03,110.2 PQ7610.6 34.2,110.2 33.68,110.72 31.09,110.72 30.72,110.36 PQ7611.4
  TOP w0.356: v1(71.25,109.22) 71.25,108.28 71.52,108.01 PQ7606.4
  TOP w0.508: PD7701.1 v2(192.48,33.45) 190.59,33.45 v4(190.3,33.16)
  IN2 w2.032: 45.62,109.83 52.48,109.83 53.8,108.51 69.19,108.51 ; 172.95,113.34 191.31,113.34 194.36,110.29 199.16,110.29 203.96,105.49 203.96,63.78 205.49,62.26 205.49,55.63 204.17,54.31 204.17,53.52 203.2,52.56 203.2,52.17 202.64,51.62 202.64,48.19 199.62,45.16 188.95,45.16 187.43,43.64 187.43,37.04 188.44,36.02 188.44,33.61 ; 71.22,108.84 76.07,108.84 76.86,108.05 81.61,108.05 82.51,108.96 82.51,109.46 83.52,110.47 92.66,110.47 94.06,109.07 110.13,109.07 114.63,113.57 140.49,113.57 146.22,107.84 156.86,107.84 157.01,107.69 163.06,107.69 166.55,111.18 168.02,111.18
  IN3 w2.032: 188.42,33.73 188.42,36.05 187.43,37.04 187.43,43.64 188.95,45.16 199.62,45.16 202.64,48.19 202.64,51.62 203.2,52.17 203.2,52.56 204.17,53.52 204.17,54.31 205.48,55.62 205.48,62.26 203.96,63.78 203.96,105.46 199.14,110.29 194.36,110.29 191.33,113.32 172.91,113.32 ; 71.2,108.87 76.07,108.87 76.89,108.05 81.6,108.05 82.51,108.97 82.51,109.46 83.52,110.47 92.66,110.47 94.06,109.07 110.13,109.07 114.63,113.57 140.49,113.57 146.22,107.84 156.86,107.84 157.01,107.69 163.06,107.69 166.55,111.18 168.02,111.18 ; 45.62,109.83 52.43,109.83 53.77,108.49 68.91,108.49
  BOTTOM w0.229: 193.14,27.64 193.68,27.09 PU7700.16
  BOTTOM w0.254: PR7707.1 195,31.9 195,32.56 194.4,33.16 v4(190.3,33.16)
  BOTTOM w0.508: 193.14,27.64 192.3,28.48 191.61,28.48 190.68,29.41 190.68,31.6
  vias: v4(40.46,110.24) v4(41.33,110.24) v4(42.24,110.26) v4(42.72,109.53) v4(187.53,32.21) v4(188.42,32.21) v4(189.41,33.2) v4(189.33,32.21)
+FBVDDQ: length 203.8
  TOP w0.203: U6801.B12 188.58,93.36 187.74,93.36 U6801.B14
  TOP w0.254: U6801.G1 197.53,97.21 197.19,97.21 U6801.G2 196.96,96.86 196.28,96.18 U6801.F3 ; U6803.T3 188.97,74 v1(189.36,73.61)
  TOP w0.305: U6801.C10 v1(190.15,94.18) U6801.D11 189.64,94.46 189.08,94.46 U6801.D12 188.84,94.69 188.27,94.69 U6801.D13 ; U6803.F14 197.82,82 v1(198.22,82.4) ; U6803.P12 196.17,75.56 v1(195.78,75.17) 195.37,75.57 U6803.P11 ; v1(190.17,77.6) 189.77,78 U6803.L4 U6803.K3 ; U6801.G1 198.14,97.37 v1(198.16,97.37) 198.2,97.4 198.2,98.15 ; U6801.G11 189.41,97.33 ; 189.41,97.33 U6801.H12 ; 189.41,97.33 189.41,97.34 ; U6803.D14 198.13,83.24 v1(198.22,83.24) ; v1(196.56,73.6) U6803.T12 ; U6801.M14 186.83,100.45 v1(186.83,100.36) 187,100.18 U6801.L14 187.49,100.04 188.02,100.04 U6801.L13 ; 186.66,92.97 187.34,92.97 U6801.B14 ; U6803.F1 186.89,82 185.94,82.95 v1(185.94,83.26) ; U6801.T14 187.01,104.18 v1(186.66,104.52) ; v1(186.79,77.98) 186.81,78 U6803.L1 U6803.L2 ; v1(189.36,75.21) 188.97,75.6 U6803.P3 U6803.P2 U6803.P1 186.47,75.6 v1(185.78,76.29) ; v1(186.95,102.97) 187.34,102.58 U6801.P14 ; U6803.H3 U6803.G4 U6803.F3 ; U6803.H3 189.35,80.02 v1(189.36,80.02) ; U6803.H3 188.99,80.4 ; U6803.B14 197.77,85.19 v1(198.18,84.78) ; U6803.L11 195.38,78 v1(195.79,77.58) ; v1(198.25,81.6) 197.85,81.2 U6803.G14 ; U6801.C5 194.16,93.39 v1(194.07,93.39) ; U6801.K12 U6801.L11 ; U6803.B3 188.97,85.23 v1(189.36,85.62) ; v1(191.52,102.52) 191.29,102.52 U6801.N10 ; U6801.B3 v1(196.58,93.4) ; U6801.P1 198.12,102.95 v1(198.25,102.95) ; U6803.G2 U6803.G1 186.77,81.2 186.71,81.14 186.36,81.14 v1(185.99,81.52) ; U6801.T3 196.15,104.18 v1(195.78,104.56) ; v1(189.34,103.8) U6801.T12 ; v1(193.79,76.18) 193.97,76.36 ; U6803.G11 195.37,81.2 196.17,80.4 U6803.H12 196.58,80.81 v1(196.58,80.83) ; U6803.N5 191.13,76.4 v1(191.14,76.41) ; v1(196.54,85.61) 196.54,85.57 U6803.B12 ; U6801.P11 189.4,102.23 189.31,102.23 U6801.P12 ; v1(196.55,98.17) U6801.H3 U6801.G4 ; U6803.D13 196.6,83.23 v1(196.57,83.23) 196.53,83.23 U6803.D12 ; v1(193.22,95.21) 193.39,95.38 U6801.E5 ; U6801.N5 193.9,101.78 v1(193.64,102.05) ; U6803.D1 187,83.6 v1(186.07,84.52) ; v1(198.19,100.53) 198.11,100.53 U6801.L1 ; U6803.P14 198.21,75.6 v1(198.31,75.49) ; U6801.D14 186.7,94.58 v1(186.66,94.62) ; 194.01,76.4 U6803.N10 ; U6803.B1 187.05,85.2 v1(186.86,85.39) ; v1(188.56,83.24) 188.92,83.6 U6803.D3 ; U6801.M1 v1(198.18,101.4) ; v1(195.75,102.16) 195.75,102.17 U6801.P3 196.28,102.46 196.84,102.46 U6801.P2 ; U6803.D11 U6803.E10 194.38,82.8 v1(194.04,83.14) ; U6803.F12 196.19,82 196.58,81.61 ; v1(196.58,77.59) 196.97,77.98 U6803.L13 U6803.L14 197.81,78 v1(198.27,77.54) ; U6803.R10 193.95,74.18 v1(193.82,74.18) ; v1(196.55,78.41) 196.55,78.42 U6803.K12 ; U6801.K3 195.78,99.76 v1(195.77,99.76) 195.77,99.77 U6801.L4 ; U6803.C10 194.11,84.4 v1(193.97,84.54) ; 196.58,81.62 196.58,81.61 ; 196.58,81.61 196.97,81.22 U6803.G13 196.97,81.19 v1(197.36,80.8) ; U6801.B1 198.15,93.37 v1(198.21,93.37) ; U6801.T1 198.14,104.56 v1(198.15,104.56) ; v1(193.88,104.06) 194.56,103.39 U6801.R5 ; U6801.G13 v1(188.54,96.6) U6801.F12 ; U6803.T14 198.03,73.74 v1(198.26,73.74) ; U6801.D3 v1(195.77,94.2) ; U6801.M3 U6801.L2 196.97,100.18 v1(197.36,99.79) ; 186.41,77.2 U6803.M1 ; U6803.E5 190.57,82.8 v1(190.17,82.4) ; v1(198.24,96.47) 198.04,96.47 U6801.F1 ; U6803.C5 190.56,84.4 v1(190.18,84.78) ; 198.19,98.15 U6801.J1
  TOP w0.432: v1(169.82,87.63) 170.24,88.05 C6753.1 ; v1(169.24,85.11) 169.24,85.12 169.04,85.32 C6749.1 ; R6808.1 182.52,97.69 v1(182.52,97.28)
  TOP w0.508: 182.09,101.83 181.58,101.32 174.42,101.32 173.51,100.41 173.51,98.43 ; 169.06,96.67 170.79,96.67 171.69,97.58
  IN1 w0.254: v1(167.82,105.08) 166.99,104.25 166.99,96.13 167.08,96.04
  IN2 w0.508: v1(174.88,69.5) 173.41,69.5 172.85,68.94 169.58,68.94 169.31,68.67 166.79,68.67 165.68,69.78 164.85,69.78 163.15,71.48 159.87,71.48 156.92,74.42 154.48,74.42 152.11,76.79 v1(149.91,76.79)
  BOTTOM w0.203: U6801.B12 188.58,93.36 ; 188.58,93.37 187.74,93.37 ; 187.74,93.36 U6801.B14
  BOTTOM w0.254: v1(169.82,87.63) 169.82,88.02 U6000.H16 ; v1(185.78,76.29) 186.47,75.6 U6803.P1 ; U6000.H13 169.24,85.43 v1(169.24,85.11) ; U6803.P3 188.97,75.6 v1(189.36,75.21) ; U6000.H19 169.63,91.21 v1(169.62,91.21) ; R6304.1 168,105.26 v1(167.82,105.08) 167.44,104.7 R6306.1 ; 186.2,74 U6803.T1 ; U6803.T3 188.97,74 v1(189.36,73.61)
  BOTTOM w0.305: U6802.J1 186.98,79.22 v1(186.89,79.22) ; U6801.B1 198.15,93.37 v1(198.21,93.37) ; U6802.P2 188.2,83.6 v1(188.56,83.24) 188.92,83.6 U6803.D3 ; v1(196.58,93.4) U6801.B3 ; U6801.F3 U6801.G2 ; U6801.C10 v1(190.15,94.18) U6801.D11 ; v1(198.25,102.95) 198.12,102.95 U6801.P1 ; U6803.G11 U6803.H12 196.58,80.81 v1(196.58,80.83) ; U6801.L4 195.77,99.77 v1(195.77,99.76) 196.15,99.38 U6801.K3 ; U6801.N10 191.29,102.52 v1(191.52,102.52) ; U6803.C5 190.56,84.4 v1(190.18,84.78) ; 195.75,102.17 195.75,102.26 196.08,102.58 U6801.P3 ; U6801.M14 186.83,100.45 v1(186.83,100.36) 187,100.18 U6801.L14 ; v1(193.97,84.54) 194.11,84.4 U6803.C10 ; U6801.K12 U6801.L11 189.39,100.55 v1(189.35,100.55) 189.35,100.59 U6801.M12 ; v1(186.86,85.39) 187.05,85.2 U6803.B1 ; U6803.G2 U6803.G1 186.3,81.2 v1(185.99,81.52) ; v1(198.19,100.53) 198.11,100.53 U6801.L1 ; v1(196.57,83.23) 196.53,83.23 U6803.D12 ; v1(198.27,77.54) 197.81,78 U6803.L14 U6803.L13 196.58,77.61 v1(196.58,77.59) ; U6801.F1 198.04,96.47 v1(198.24,96.47) ; U6803.G14 197.85,81.2 v1(198.25,81.6) ; U6803.L11 195.38,78 v1(195.79,77.58) ; U6803.D11 U6803.E10 194.38,82.8 v1(194.04,83.14) ; U6801.E10 190.85,95.67 v1(191.03,95.67) ; v1(198.22,82.4) 197.82,82 U6803.F14 ; v1(186.64,92.92) 186.7,92.98 U6801.B14 ; v1(198.26,73.74) 198.03,73.74 U6803.T14 ; U6801.G1 197.78,96.98 v1(198.16,97.37) ; U6801.F14 187.09,96.18 v1(186.8,96.47) 187.31,96.98 U6801.G14 ; v1(194.07,93.39) 194.16,93.39 U6801.C5 ; U6801.H12 189.32,97.41 v1(189.35,97.41) 189.35,97.38 U6801.G11 ; v1(198.15,104.56) 197.77,104.18 U6801.T1 ; U6801.R5 194.56,103.39 v1(193.88,104.06) ; v1(186.66,94.62) 186.7,94.58 U6801.D14 ; v1(186.79,77.98) 186.81,78 U6803.L1 U6803.L2 ; U6803.B12 196.17,85.24 v1(196.54,85.61) ; v1(198.18,84.78) 198.18,84.79 U6803.B14 ; v1(186.95,102.97) 186.97,102.97 U6801.P14 ; U6801.D1 197.99,94.58 v1(198.25,94.83) ; v1(196.55,98.17) U6801.H3 U6801.G4 ; v1(198.18,101.4) U6801.M1 ; v1(198.31,75.49) 198.21,75.6 U6803.P14 U6802.D13 ; U6803.N5 191.13,76.4 v1(191.14,76.41) ; 196.58,81.62 196.58,81.61 ; 196.58,81.61 196.97,81.22 U6803.G13 196.97,81.19 v1(197.36,80.8) ; 196.58,81.61 196.19,82 U6803.F12 ; U6803.P12 196.17,75.56 v1(195.78,75.17) 195.37,75.57 U6803.P11 ; U6801.G13 v1(188.54,96.6) U6801.F12 ; U6803.D14 198.13,83.24 v1(198.22,83.24) ; U6803.K12 196.17,78.79 v1(196.55,78.41) ; v1(197.36,99.79) 196.97,100.18 U6801.L2 U6801.M3 ; v1(196.56,73.6) U6803.T12 ; U6803.B3 188.97,85.23 v1(189.36,85.62) ; U6801.T12 v1(189.34,103.8) ; U6801.T14 187.01,104.18 v1(186.66,104.52) ; U6803.E5 190.57,82.8 v1(190.17,82.4) ; 195.78,104.56 U6801.T3 ; U6803.M1 186.35,77.2 v1(185.63,77.93) ; U6803.F3 U6803.G4 U6803.H3 189.35,80.02 v1(189.36,80.02) ; U6801.N5 193.9,101.78 v1(193.64,102.05) ; v1(195.77,94.2) U6801.D3
  BOTTOM w0.356: v1(149.91,76.79) v2(148.92,76.79) 148.46,76.79 R6804.1
  BOTTOM w0.432: C6623.1 199.47,74.09
  BOTTOM w0.508: v1(182.52,97.28) 182.52,96.85 183.08,96.29 R6806.1
  vias: v1(166.62,85.91) v1(166.62,84.94) v1(166.75,91.59) v1(167.61,93.69) v1(167.67,94.42) v1(168.4,96.01) v1(168.41,83.24) v1(168.43,94.41) v1(183.48,80.72) v1(184.11,80.72) v1(184.93,79.22) v1(185.56,79.22) v1(185.7,74.83) v1(188.95,107.29) v1(190.18,102.98) v1(191.08,73.61) v1(195.78,76.83) v1(198.2,76.8) v1(201.93,81.49) v1(201.93,80.72) v4(173.44,73.47) v4(174.18,72.38) v4(174.35,73.48) v4(175.09,72.37)
+FBVDDQ_BOOT1_D: length 2.2
  TOP w0.432: PC9804.1 PR9801.2 192.76,67.72 v2(193.17,67.31)
+FBVDDQ_BOOT_D: length 2.5
  TOP w0.432: PR9801.1 190.63,68.4 v1(190.63,68.51) 191.92,68.51 v2(192.05,68.63)
+FBVDDQ_DISCH_A: length 11.1
  BOTTOM w0.254: Q7200.3 204.14,113.06 203.64,112.56 203.64,111.26 v2(202.69,110.31) 201.66,109.29 199.94,109.29 199.52,108.87 R7200.1
+FBVDDQ_MODE: length 2.8
  TOP w0.457: v2(190.55,65.05) v1(190.55,65.69) PR9805.2
  BOTTOM w0.254: v1(190.55,65.69) 190.55,66.25 190.89,66.58 PU9800.7
+FBVDDQ_PHASE: length 1.6
  TOP w0.457: v2(190.56,67.59) 190.56,66.96 v1(190.53,66.93) 190.81,66.65 PC9804.2
+FBVDDQ_SENSE_R: length 1
  BOTTOM w0.432: PR9810.2 PR9811.1
+FBVDDQ_VCC: length 3.5
  TOP w0.432: v2(193.37,69.83) PR9809.2 192.33,69.93 191.52,69.93 PC9808.1 191.41,69.75 191.26,69.6 v1(191.26,69.24)
  BOTTOM w0.254: PU9800.10 191.43,69.08 v1(191.26,69.24)
+FBVDDQ_VIN:
  vias: v2(197.13,68.84)
+FBVDDQ_VOUT: length 3.5
  BOTTOM w0.254: PU9800.12 192.43,69.12 192.58,69.27
  BOTTOM w0.432: 192.58,69.27 PR9810.1 PR9812.2 v2(194.64,69.95)
+FBVDDQ_VOUT_R: length 23.3
  IN1 w0.305: v1(190.2,69.52) 190.2,70.13 189.46,70.87 180.14,70.87 177.27,68 175.57,68 v1(175.34,68.22)
  BOTTOM w0.102: v2(174.3,65.31) 174.3,66.98 175.34,68.03 v1(175.34,68.22)
  BOTTOM w0.229: v1(175.34,68.22) 176.1,67.46 PJP9801.2
  BOTTOM w0.254: PR9811.2 191.24,69.95 190.81,69.52 v1(190.2,69.52)
+RTC_CELL_VBAT: length 6
  TOP w0.229: R2308.2 43.46,39.9 U2300.122
  TOP w0.254: v2(46.6,42.5) 46.6,42.26 46.76,42.09 C2308.1 46.3,41.74 46.28,41.76 45.87,41.76 45.64,41.53 44.73,41.53 44.53,41.33 R2308.2
+USB_TYPEC: length 58.1
  TOP w0.432: v1(42.11,84.25) R5803.1
  TOP w0.508: v4(32.77,97.79) v2(31.55,97.79)
  IN1 w0.508: v1(37.29,93.52) 36.29,94.52 30.33,94.52 ; CON5700.B9 6.86,85.97 7.86,85.97 v1(8.48,85.35) ; v1(20.93,77.17) 20.93,78.26 20.75,78.44 20.75,82.04 20.45,82.35 20.45,83.34 20.75,83.64 20.75,84.46 20.29,84.91 19.15,84.91 18.31,85.76 17.75,85.76 16.23,87.28 v1(16.23,88.24) ; CON5700.B4 6.86,88.03 7.84,88.03 v1(8.43,88.62)
  IN2 w0.508: v1(37.29,93.52) 40.41,90.4 40.41,85.95 v1(42.11,84.25)
  IN3 w0.508: v1(20.93,77.17) 20.93,76.03 16.94,72.04 16.94,70.59 16.59,70.23 16.28,70.23 v1(15.14,69.09) ; CON5700.B4 7.3,88.3 ; CON5700.B9 7.36,85.7
  BOTTOM w0.203: CON5700.A4 7.95,85.75 8.36,85.35 v1(8.48,85.35) ; CON5700.A9 7.96,88.25 8.33,88.62 v1(8.43,88.62)
  BOTTOM w0.305: CON5700.B4 6.64,88.25 CON5700.A9 ; CON5700.A4 7.13,85.75 7.08,85.7 CON5700.B9
  BOTTOM w0.432: v1(15.14,69.09) 15.47,68.76 R5814.1
  BOTTOM w0.508: v4(27.1,92.2) v2(27.1,92.97)
  vias: v1(10.74,89.28) v1(30.1,91.72) v4(13.56,90.22) v4(13.59,89.31) v4(13.82,91.06) v4(14.38,91.72) v4(14.43,90.22) v4(14.45,89.33) v4(25.83,91.44) v4(26.7,91.44) v4(27.56,91.47) v4(27.99,92.23) v4(28.42,91.47) v4(28.93,92.2) v4(32.33,97.03) v4(32.61,98.66) v4(33.22,97.01) v4(33.53,98.66) v4(33.66,97.79)
+USB_TYPEC_LDO: length 4.4
  BOTTOM w0.254: R5815.1 17.2,70.16 17.35,70 C5808.1 ; C5808.1 v2(18.34,69.62) 18.64,69.92 U5802.1 ; C5808.1 R5814.2
+VCORE: length 2.9
  TOP w0.432: C0706.1 127.58,51.34 v3(127.91,51.34)
  BOTTOM w0.203: v3(127.42,55.15) 127.19,55.15 U0400.A39 ; U0400.A44 126.97,57.85 128.39,57.85 v3(128.51,57.97)
  vias: v2(141.63,46.97) v3(112.47,52.35) v3(112.47,51.79) v3(112.5,51.23) v3(112.59,54.92) v3(112.52,54.36) v3(112.52,53.8) v3(112.61,55.48) v3(113.11,52.35) v3(113.08,51.79) v3(113.06,51.23) v3(113.18,55.5) v3(113.18,54.94) v3(113.13,54.38) v3(113.13,53.83) v3(113.34,56.19) v3(113.52,50.88) v3(113.52,49.61) v3(113.89,56.21) v3(113.97,55.65) v3(114.08,50.9) v3(114.08,49.61) v3(114.45,56.23) v3(114.45,54.89) v3(114.41,52.24) v3(114.63,50.89) v3(114.64,49.61) v3(114.99,52.22) v3(115.01,56.21) v3(115.01,54.89) v3(115.19,50.89) v3(115.19,49.61) v3(115.54,52.22) v3(115.75,50.89) v3(115.75,49.61) v3(116.52,56.23) v3(116.56,54.94) v3(116.75,52.2) v3(116.75,50.89) v3(116.8,49.59) v3(117.1,56.23) v3(117.12,54.94) v3(117.31,52.2) v3(117.31,50.9) v3(117.36,49.59) v3(117.67,56.23) v3(117.68,54.94) v3(117.87,52.2) v3(117.87,50.88) v3(117.92,49.59) v3(118.23,56.23) v3(118.24,54.94) v3(118.42,52.2) v3(118.42,50.9) v3(118.48,49.59) v3(118.8,56.24) v3(118.8,54.94) v3(119.41,56.77) v3(119.35,56.21) v3(119.35,54.94) v3(119.41,52.2) v3(119.4,50.88) v3(119.42,49.58) v3(119.88,55.63) v3(119.81,51.46) v3(119.97,56.76) v3(119.91,56.2) v3(119.91,55.07) v3(119.96,52.2) v3(119.96,50.88) v3(119.98,49.59) v3(120.49,56.21) v3(120.44,55.65) v3(120.47,55.1) v3(120.42,51.46) v3(120.54,56.77) v3(120.52,52.2) v3(120.52,50.89) v3(120.54,49.59) v3(120.97,55.48) v3(120.96,51.79) v3(121.03,56.03) v3(121.08,53.77) v3(121.11,52.86) v3(121.18,57.15) v3(121.18,56.59) v3(121.13,50.85) v3(121.23,54.97) v3(121.29,52.25) v3(121.39,51.41) v3(121.49,53.29) v3(121.59,56.01) v3(121.53,55.45) v3(121.67,52.71) v3(121.69,50.93) v3(121.74,57.15) v3(121.74,56.59) v3(121.74,51.87) v3(121.84,53.85) v3(122.15,55.93) v3(122.15,52.28) v3(123.55,55.91) v3(123.55,54.05) v3(123.57,52.28) v3(124.89,54.13) v4(138.48,49.94) v4(138.63,49.02) v4(138.63,48.11) v4(138.63,47.22) v4(138.63,46.28) v4(138.66,45.39) v4(139.14,50.68) v4(139.5,58.12) v4(139.47,57.2) v4(139.5,49.05) v4(139.5,48.14) v4(139.5,47.22) v4(139.5,46.33) v4(139.52,45.47) v4(139.67,59.9) v4(139.65,59.03) v4(139.67,49.96) v4(139.65,44.58) v4(140.13,55.53) v4(140.36,58.09) v4(140.36,57.23) v4(140.41,56.37) v4(140.44,45.44) v4(140.56,59.79) v4(140.59,58.93) v4(140.54,49.96) v4(140.59,44.58) v4(141,55.5) v4(141.22,58.07) v4(141.25,57.2) v4(141.3,56.34) v4(141.4,45.44) v4(141.45,59.79) v4(141.48,58.93) v4(141.5,49.96) v4(141.48,44.58) v4(141.86,55.5) v4(142.37,50.17) v4(142.32,45.47) v4(142.42,44.6) v4(143.31,50.17) v4(143.31,49.28) v4(143.31,48.31)
+VCORE1_FCCM: length 1.5
  BOTTOM w0.254: PR7917.2 159.46,43.21 159.95,43.7 PU7900.7
+VCORE1_HG_D: length 5.7
  IN1 w0.635: v1(159.08,48.77) 159.08,46.13 v4(158.8,45.85)
  BOTTOM w0.432: v2(160.93,49.81) PR7900.1 160.01,49.08 159.7,48.77 v1(159.08,48.77)
+VCORE1_LG_D: length 18.9
  TOP w0.635: v4(151.56,50.8) 151.56,51.72 151.24,52.05 149.17,52.05 v2(148.23,51.11) 147.74,50.61 PR7914.1
  IN1 w0.635: v4(151.56,50.8) 153.57,50.8 154.42,49.95 159.52,49.95 161.72,47.75 v4(161.72,47.04)
+VCORE1_PHASE_D: length 5.4
  TOP w0.127: v4(156.9,48.14) v2(157.47,48.71)
  IN1 w0.635: v4(156.9,48.14) 156.96,48.14 157.68,47.41 157.68,45.19 158.04,44.83 v4(158.83,44.83)
+VCORE1_PWM: length 3.4
  BOTTOM w0.102: v2(162.13,48.19) 161.6,48.19 161.11,47.7 PR7918.2
  BOTTOM w0.279: PU7900.3 160.45,46.41 160.36,46.5 160.36,46.8 160.81,47.25 PR7918.2
+VCORE1_R_HG_D:
  vias: v2(157.2,50.7)
+VCORE1_R_LG_D: length 1.2
  TOP w0.635: PR7914.2 v2(149.45,48.08)
  vias: v4(150.72,51.21)
+VCORE2_FCCM: length 2.1
  BOTTOM w0.254: v2(159.84,51.36) PR7919.2 159.84,52.78 159.9,52.84 PU7901.7
+VCORE2_HG_D: length 6.9
  TOP w0.635: v4(158.62,60.3) 159.33,59.59 v2(159.33,58.83) 159.33,55.96 v4(158.78,55.4)
  BOTTOM w0.635: PR7907.1 158.62,61.21 v4(158.62,60.3)
+VCORE2_LG_D: length 19.1
  TOP w0.635: v2(161.68,55.27) 162.06,54.89 v4(162.43,54.89) ; v4(148.72,58.75) 147.98,59.49 PR7916.1
  IN1 w0.635: v4(148.72,58.75) 150.98,56.49 159.94,56.49 161.54,54.89 v4(162.43,54.89)
+VCORE2_PHASE_D: length 8.7
  TOP w0.635: v4(158.8,54.05) 158.27,54.05 157.73,54.59 157.73,59.13 157.35,59.51 157.35,61.34 v4(157,61.7)
  vias: v2(157.79,53.09)
+VCORE2_PWM: length 2.8
  BOTTOM w0.254: v2(162.28,56.62) PR7920.2 161.14,56.34 161.14,56.11 160.86,55.83 160.63,55.83 160.4,55.6 PU7901.3
+VCORE2_R_BT_D:
  vias: v2(157.43,56.64)
+VCORE2_R_HG_D:
  vias: v2(156.03,64.26)
+VCORE2_R_LG_D: length 3.1
  TOP w0.635: v4(147.5,64.95) v2(147.5,65.92)
  BOTTOM w0.635: PQ7901.8 148.53,63.91 v4(147.5,64.95)
+VCORE/GT: length 2.2
  BOTTOM w0.254: v3(123.6,60.51) U0400.J48 ; U0400.A48 127.15,60.15 v3(127.45,60.15) ; v3(127.78,62.84) 127,62.84 U0400.A53
  vias: v2(111.84,57.76) v3(112.64,60.43) v3(112.62,59.87) v3(112.62,59.31) v3(112.62,58.75) v3(112.62,58.19) v3(112.62,57.64) v3(113.2,60.4) v3(113.18,59.84) v3(113.18,59.29) v3(113.18,58.73) v3(113.18,58.17) v3(113.18,57.61) v3(121.01,60) v3(121.03,59.44) v3(121.03,58.88) v3(121.03,58.32) v3(121.06,57.76) v3(121.59,60) v3(121.59,59.44) v3(121.59,58.88) v3(121.62,58.32) v3(121.62,57.76)
+VCORE_CSN1_A: length 77.3
  TOP w0.254: v1(177.67,55.45) 177.14,55.45 177.01,55.32 177.01,54.59 v2(176.96,54.54) 176.61,54.18 PC7808.2 177.09,53.57 177.13,53.61 PC7807.2 178.02,53.61 178.05,53.65 PR7853.1
  IN1 w0.254: v1(143.82,42.24) 144.75,43.18 148.14,43.18 149.34,44.39 149.34,50 148.98,50.36 148.98,51.43 148.19,52.22 146.44,52.22 144.63,54.04 144.63,55.63 144.27,55.98 v1(144.27,56.37) 144.55,56.64 144.55,57.2 144.88,57.53 145.75,57.53 146.1,57.18 146.1,55.03 147.76,53.37 149.53,53.37 149.89,53.01 155.97,53.01 156.66,52.33 159.13,52.33 159.59,52.78 161.65,52.78 161.87,52.56 162.92,52.56 163.55,53.19 166.73,53.19 166.8,53.27 169.39,53.27 169.98,53.85 175.74,53.85 175.9,53.7 177.75,53.7 178.03,53.98 178.03,55.1 v1(177.67,55.45)
  BOTTOM w0.254: PR7905.2 143.71,42.34 v1(143.82,42.24) ; PC7840.2 178.43,56.11 178.44,56.11 PC7839.2 179.02,55.91 PC7806.1 PR7806.1 PR7804.1 ; PC7840.2 177.38,56.11 PR7803.2 PC7803.2 176.96,54.28 176.97,54.27 PC7800.1 ; PC7840.2 177.88,55.66 v1(177.67,55.45) ; v1(144.27,56.37) 144.27,56.67 PRT7800.2 PR7912.2
+VCORE_CSP1_A: length 71.8
  TOP w0.254: v2(175.54,57.58) 175.54,57.13 v1(176.2,56.47)
  IN1 w0.254: v1(144.83,42.29) 145.36,42.83 148.28,42.83 149.7,44.24 149.7,50.15 149.34,50.51 149.34,51.57 148.33,52.58 146.76,52.58 144.98,54.36 144.98,55.64 ; 144.98,55.64 v1(144.98,56.31) ; 144.98,55.64 147.61,53.01 149.38,53.01 149.73,52.66 155.82,52.66 156.51,51.97 159.39,51.97 159.79,52.38 161.49,52.38 161.67,52.2 163.07,52.2 163.7,52.83 166.88,52.83 166.95,52.91 169.55,52.91 170.13,53.49 175.49,53.49 175.64,53.34 177.9,53.34 178.38,53.82 178.38,55.42 177.82,55.98 176.68,55.98 v1(176.2,56.47)
  BOTTOM w0.229: PC7800.2 175.86,53.57 175.86,52.31 175.5,51.96 PU7800.7
  BOTTOM w0.254: PC7800.2 176.11,54.24 176.1,54.26 PC7803.1 PR7803.1 176.1,56.37 v1(176.2,56.47) 176.3,56.57 PR7800.1 177.48,56.57 PC7840.1 178.81,56.97 PC7839.1 ; v1(144.98,56.31) 144.88,56.42 PR7910.2 ; v1(144.83,42.29) 144.81,42.29 144.63,42.47 PR7904.2
+VCORE_ISEN1_A: length 83.1
  TOP w0.229: 178.75,52.95 179.07,53.27 179.07,55.53 178.56,56.03 PR7808.2
  TOP w0.254: v1(177.67,52.17) 177.55,52.3 PC7807.1 v2(178.46,52.75) 178.55,52.75 178.75,52.95
  IN1 w0.254: v1(177.67,52.17) 178.08,51.77 178.08,51.03 177.75,50.7 176.99,50.7 176.66,51.03 175.41,51.03 173.69,52.76 170.49,52.76 169.93,52.2 167.26,52.2 167.18,52.12 164.03,52.12 162.51,50.6 160.22,50.6 159.92,50.9 157.07,50.9 156.16,51.82 150.47,51.82 150.06,51.41 150.06,44.1 147.62,41.66 142.85,41.66 v1(142.67,41.84) 142.62,41.89 142.62,42.42 144.15,43.94 147.89,43.94 148.63,44.68 148.63,49.63 148.27,49.99 148.27,51.13 147.89,51.51 145.9,51.51 143.03,54.39 143.03,55.5 142.11,56.42 v1(142.11,56.47)
  BOTTOM w0.229: v1(177.67,52.17) 177.58,52.26 176.85,52.26 176.3,51.72 PU7800.9
  BOTTOM w0.254: PR7922.2 v1(142.11,56.47) ; PR7906.2 145.54,41.96 145.24,41.66 142.85,41.66 v1(142.67,41.84)
+VCORE_ISEN2_A: length 79.7
  TOP w0.229: PR7811.2 175.95,55.96 v2(175.87,55.88) 175.72,55.73 175.72,54.97 176.07,54.61 176.07,53.24 PC7808.1 176.61,52.35 v1(177.16,51.79)
  IN1 w0.254: v1(177.16,51.79) 177.16,52.35 177.57,52.76 177.88,52.76 178.74,53.62 178.74,55.57 177.95,56.36 177.4,56.36 176.81,56.95 175.95,56.95 175.74,57.15 174.47,57.15 172.49,55.17 170.74,55.17 169.19,53.62 166.65,53.62 166.57,53.55 161.8,53.55 161.44,53.19 159.44,53.19 158.93,52.68 156.8,52.68 156.12,53.37 150.04,53.37 149.68,53.72 148.27,53.72 146.61,55.38 146.61,57.17 145.89,57.89 144.53,57.89 143.51,56.87 v1(143.51,56.39) 143.51,55.58 143.38,55.45 143.38,54.54 146.05,51.87 148.04,51.87 148.63,51.28 148.63,50.2 148.99,49.85 148.99,44.54 148.01,43.56 144.45,43.56 v1(143.15,42.27)
  BOTTOM w0.229: v1(177.16,51.79) 176.89,51.79 176.7,51.61 PU7800.10
  BOTTOM w0.254: PR7911.2 145.82,56.31 145.34,55.83 144.07,55.83 v1(143.51,56.39) ; PR7921.2 142.77,42.5 143,42.27 v1(143.15,42.27)
+VDC_IN: length 96.8
  TOP w0.432: PR7615.1 65.84,101.96 66.4,102.52 v1(66.4,102.85) 66.55,103 v2(67.23,103) ; R2406.1 22.38,51.82 22.53,51.97 R2407.1 22.53,52.84
  TOP w0.508: v1(37.16,90.53) 37.62,90.07 PR7611.1 ; v1(40.95,54.74) 40.47,54.26 23.95,54.26 22.53,52.84
  IN1 w0.508: v1(37.52,92.26) 39.04,92.26 43.99,97.21 45.92,97.21 46.38,97.67 46.38,99.24 v4(50.98,103.84)
  IN2 w0.508: v1(66.4,102.85) 66.4,103.56 66.04,103.91 v1(57.51,103.91) ; v1(40.95,54.74) 43.49,57.27 43.49,65.38 41.58,67.29 41.58,70.65 40.72,71.51 40.72,74.79 36.91,78.61 36.91,80.23 38.03,81.36 38.78,81.36 39.75,82.33 39.75,83.06 39.19,83.62 39.19,88.5 v1(37.16,90.53) 37.16,91.9 v1(37.52,92.26)
  vias: v4(50.95,105.64) v4(50.95,104.73) v4(51.87,104.93) v4(51.84,104.02)
+VREF_PINSET: length 69.8
  TOP w0.102: v2(104.55,100.74) v1(103.84,100.74)
  IN2 w0.254: v1(131.72,85.55) 131.36,85.92 126.55,85.92 125.69,86.78 119.01,86.78 115.93,89.87 114.58,89.87 114.05,89.33 112.14,89.33 108.43,93.04 105.62,93.04 104.19,94.47 104.19,99.52 103.76,99.95 103.76,100.66 v1(103.84,100.74)
  BOTTOM w0.222: PU9400.15 109.95,100.41
  BOTTOM w0.254: v1(131.72,85.55) 131.72,85.93 134.51,88.71 134.51,94.29 136.18,95.96 137.38,95.96 PRT9401.1 ; 109.95,100.41 109.22,101.15 108.74,101.15 108.05,100.46 107.45,100.46 107.01,100.02 106.39,100.02 106.17,100.23 PR9446.1 105.53,100.23 104.72,101.04 104.72,101.7 PR9448.1 104.27,101.55 104.27,101.17 v1(103.84,100.74) 103.15,101.42 v2(102.82,101.42) 102.13,100.74 102.13,100.21 101.45,99.52 101.45,98.94 101.91,98.48 PR9434.1 PR9439.1
+VRTC_BATT: length 115.8
  TOP w0.432: 60.93,22.18 R3612.1 61.19,23.24 R3609.1 62.36,23.24 62.45,23.15 63.64,23.15 64.01,23.53 v1(64.01,23.73)
  TOP w0.508: v1(60.48,16.68) 60.48,17.5 60.93,17.96 v2(60.93,20.14) 60.93,22.18
  IN2 w0.432: v1(84.79,27.38) 84.58,27.59 81.48,27.59 77.06,23.17 72.82,23.17 72.54,23.45 69.81,23.45 69.3,22.93 64.79,22.93 64.65,23.08 64.4,23.08 64.01,23.47 v1(64.01,23.73)
  BOTTOM w0.432: v1(84.79,27.38) 84.79,27.68 79.1,33.37 79.1,68.13 87.45,76.48 97.31,76.48 101.75,80.93 105.13,80.93 108.34,77.72 Q3601.1
  BOTTOM w0.508: v1(60.48,16.68) 60.48,16.41 60.99,15.9 61.68,15.9 62.36,16.57 CON3602.2
+VSUS_ROM: length 21.4
  IN1 w0.508: v1(101.8,18.1) 100.8,17.1 94.54,17.1 v1(93.22,18.42)
  BOTTOM w0.432: R1902.1 93.45,18.01 93.22,18.24 v1(93.22,18.42) 93.22,18.85 92.14,19.93 92.14,20.63 92.34,20.83 92.34,21.37 92.62,21.65 v2(92.62,22.16) 92.89,22.43 R1903.1
  BOTTOM w0.508: v1(101.8,18.1) 101.8,18.08 102.4,17.49 103.67,17.49 104.18,16.98 105.1,16.98 105.32,17.21 105.32,18.31
+VTT_A_DDR_VTTSNS: length 2
  TOP w0.229: PU8600.2 100.08,95.51 v2(100.05,95.48) 100,95.43 PR8612.1
+VTT_A_REF: length 3.5
  TOP w0.229: PU8600.4 100.88,96.07 101.09,95.86 101.09,94.72 PC8616.1 100.81,94.44
  TOP w0.254: 100.81,94.44 100.03,93.65 v2(99.9,93.65)
+VTT_DDR: length 143.4
  TOP w0.432: C2208.1 C2223.1 C2222.1 C2100.1 v2(47.12,26.85) 47.12,27.36 v1(48.08,28.32) ; C2220.1 C2221.1 C2209.1 ; C2220.1 62.92,26.22 63.13,26 63.13,25.03 63.4,24.77 v1(63.4,23.73) ; C2220.1 62.56,26.29 C2000.1
  IN2 w0.508: 64.81,22.21 64.47,22.21 64.19,22.48 63.93,22.48 63.4,23.01 ; 63.4,23.01 v1(63.4,23.73) ; 63.4,23.01 63.4,22.82 63.03,22.45 56.91,22.45 56.41,22.94 52.21,22.94 48.08,27.07 v1(48.08,28.32)
  IN2 w0.762: v4(83.79,26.48) 83.52,26.75 81.83,26.75 77.53,22.44 72.35,22.44 72.12,22.67 70.53,22.67 70.06,22.21 64.81,22.21
  BOTTOM w0.305: CON2000.258 63.03,26.07 63.26,25.85 63.26,25.01 63.4,24.87 v1(63.4,23.73) ; CON2100.258 48.32,27.07 48.08,27.31 v1(48.08,28.32)
  BOTTOM w0.762: v4(83.79,26.48) 83.2,27.07 83.2,27.45 77.53,33.12 77.53,68.47 83.31,74.25 83.31,90.63 84.02,91.34 96.65,91.34 96.9,91.09
AC_DIS: length 149.3
  TOP w0.102: v1(30.77,23.13) 30.77,23.76 30.38,24.16 30.38,25.53 30.79,25.94 R2423.1 31.06,26.06 31.06,26.37 30.61,26.82 v1(30.58,26.82) 30.1,27.31 U2300.69 ; v2(68.17,106.17) 68.35,106.35 PR7627.1 68.35,107.75 67.77,108.34 67.77,110.21 v1(67.59,110.39) ; Q2401.5 28.98,21.24 v1(29.29,21.54)
  IN1 w0.102: v1(29.29,21.54) 29.74,22 29.74,22.1 v1(30.77,23.13) ; v1(28.05,98.29) 28.63,98.29 33.93,103.59 33.93,105.91 36.36,108.33 39.22,108.33 39.73,107.83 47.87,107.83 49.11,109.07 66.27,109.07 v1(67.59,110.39) ; v1(30.58,26.82) 30.58,26.85 29.11,28.32 29.11,34.77 28.85,35.03 28.85,38.73 28.5,39.08 28.5,41.24 28.06,41.68 26.42,41.68 23.7,44.4 23.7,55.5 v1(22.1,57.1)
  IN2 w0.102: v1(22.1,57.1) 21.16,58.04 21.16,70.36 19.02,72.49 19.02,77.32 20.85,79.15 20.85,88.42 21.79,89.36 27.86,89.36 v1(28.5,88.72)
  BOTTOM w0.102: v2(22.2,56.47) 22.1,56.58 v1(22.1,57.1) ; v1(28.5,88.72) 29.57,89.79 29.57,92.84 26.67,95.74 26.67,97.39 27.57,98.29 v1(28.05,98.29)
AC_IN#_G: length 3.8
  TOP w0.102: v2(38.46,89.66) 38.46,89.41 38.13,89.08 PR7611.2 PR7612.1 36.6,88.45 36.82,88.22 PU7600.1
AC_PRESENT: length 137
  TOP w0.102: v1(33.76,52.17) 33.49,52.44 29.94,52.44 29.24,51.74 26.12,51.74 25.66,51.29 v2(23.9,51.29) 23.9,51.13 23.17,50.4 23.17,50.22 22.43,49.48 v1(20.55,49.48) ; D2400.1 15.98,50.22 16.22,49.98 v1(16.36,49.98)
  IN1 w0.102: v1(20.55,49.48) 20.17,49.1 17.23,49.1 v1(16.36,49.98)
  IN3 w0.102: v1(98.04,31.5) 97.52,32.03 94.6,32.03 94.36,31.79 94.36,31.16 92.06,28.86 90.11,28.86 89.19,27.94 84.42,27.94 80.46,23.98 76.11,23.98 72.6,20.47 70.92,20.47 70.29,19.84 64.84,19.84 63.88,18.87 55.58,18.87 54.55,19.9 54.55,20.21 48.67,26.09 45.57,26.09 44.5,27.16 44.23,27.16 39.5,31.89 39.5,36.93 39.7,37.14 39.7,37.86 39.07,38.5 37.15,38.5 36.6,39.04 36.6,41.63 35.28,42.95 35.28,45.43 32.79,47.92 32.79,49.05 34.23,50.49 34.23,51.7 v1(33.76,52.17)
  BOTTOM w0.076: U0400.AY15 105.63,40.97 104.5,40.97 104.36,41.11 104.05,41.11 103.84,40.9 103.61,40.67
  BOTTOM w0.102: v1(98.04,31.5) 98.32,31.78 98.32,32.54 R1207.1 98.78,33.28 98.65,33.4 98.45,33.4 97.99,32.95 R1203.2 97.71,32.95 97.45,33.21 97.38,33.28 97.23,33.28 96.88,33.63 96.88,34.24 97.13,34.5 98.71,34.5 98.91,34.3 101.07,34.3 102.67,35.9 102.67,38.2 101.97,38.9 101.97,40.42 102.22,40.67 103.61,40.67
