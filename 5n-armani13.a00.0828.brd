# Allegro board 5n-armani13.a00.0828.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V0.85A_VID0: length 18.3
  TOP w0.102: v3(110.81,39.45) 111.26,39.01 111.59,39.01 112.77,37.83 112.77,34.71 115.14,32.34 115.14,29.57 116.99,27.72 116.99,27.38 116.79,27.18 116.79,26.16 117.01,25.95 R1607.1 117.65,25.61 v2(117.86,25.4)
  BOTTOM w0.076: U0400.AN11 v3(110.81,39.45)
V0.85A_VID1: length 9.4
  TOP w0.102: v3(110.17,39.45) 110.56,39.06 110.76,39.06 111.09,38.74 111.09,35.55 110.8,35.26 110.8,33.69 112.23,32.26 R1608.1
  BOTTOM w0.076: v3(110.17,39.45) 110.17,39.72 U0400.AN13
VBUS_C_CTRL_P1: length 37.8
  TOP w0.102: U5800.12 42.16,79.94 42.31,80.09 42.43,80.09 42.62,80.28 42.62,80.42 42.98,80.77 R5827.1 43.08,81.16 43.43,81.51 43.43,83.75 42.65,84.53 42.65,85.88 43.54,86.77 43.54,89.89 40.95,92.48 40.95,92.84 v2(40.03,93.75) 37.52,96.27 32.04,96.27 31.12,97.19 31.12,98.25 31.62,98.76 31.62,99.75 31.47,99.9 28.35,99.9 28.17,100.08 28.17,103.47 28.3,103.6 PQ7608.5
VBUS_DISCHARGE_P1: length 30
  TOP w0.102: U5800.20 38.16,79.98 v1(37.87,80.27)
  BOTTOM w0.102: v1(37.87,80.27) 36.58,80.27 34.9,81.94 34.9,83.14 v2(34.4,83.63) 33.78,84.25 33.78,86.23 31.96,88.05 29.4,88.05 29.34,87.99 27.89,87.99 27.63,88.25 23.86,88.25 22.81,87.2 22.81,86.79 22.45,86.44 20.5,86.44 20.22,86.72 R5900.1 R5905.1 19.76,88.14 19.69,88.22 18.26,88.22 18.01,88.47 v2(17.48,88.47) 17.48,88.7 17.68,88.9 U5900.9
VBUS_P_CTRL_P1: length 60.1
  TOP w0.102: PQ7608.2 30.62,103.6 v1(29.41,102.39) ; v1(27.41,96.42) 28.12,96.42 v2(28.32,96.22) ; R5826.1 43.92,80.52 43.61,80.21 v1(43.03,80.21) 42.93,80.21 42.66,79.95 U5800.11
  IN1 w0.102: v1(43.03,80.22) 43.03,80.55 42.66,80.91 36.76,80.91 34.28,78.44 30.17,78.44 28.23,80.38 28.23,84.69 24.83,88.09 22,88.09 v1(21.74,87.84) ; v1(27.41,96.42) 27.41,98.25 28.37,99.22 28.37,101.97 28.79,102.39 v1(29.41,102.39)
  IN3 w0.102: v1(21.74,87.84) 23.11,89.21 23.11,92.69 23.65,93.22 24.21,93.22 v1(27.41,96.42)
  BOTTOM w0.102: R5902.1 23.6,90.12 24.08,89.64 24.08,88.8 22.66,87.38 22.2,87.38 v1(21.74,87.84) ; v2(43.03,79.58) v1(43.03,80.22)
VCC_SENSE: length 72
  TOP w0.229: PR7819.1 174.52,56.21 174.63,56.11 174.78,56.11 PC7819.1 174.57,55.5 174.18,55.5 174.05,55.37 v2(174.05,55.25) v1(174.05,54.58)
  TOP w0.254: v3(124.35,51.36) 124.35,51.45 R0606.1
  IN3 w0.254: v1(174.05,54.58) 174.05,52.7 172.51,51.16 171.94,51.16 170.38,49.6 170.38,49.15 169.44,48.21 168.25,48.21 164.29,52.17 162.13,52.17 161.07,53.24 161.07,55.75 159.8,57.01 158.46,57.01 158.01,56.57 147.37,56.57 144.68,53.88 139.96,53.88 139.2,54.63 139.2,56.16 136.89,58.47 131.95,58.47 130.96,57.48 128.59,57.48 126.3,55.19 126.3,52.58 125.97,52.25 125.17,52.25 124.35,51.43 v3(124.35,51.36)
  BOTTOM w0.254: U0400.E32 124.35,51.13 v3(124.35,51.36)
VCC_SENSE_R: length 5.8
  TOP w0.229: PR7819.2 174.04,57.64 v2(173.83,57.85) 173.18,58.5 v1(173.18,59.03)
  BOTTOM w0.254: v1(173.18,59.03) 173.18,59.61 173.36,59.79 PR7855.1 PR7820.1 175.13,59.79 PC7817.2
VCC_SENSE_RR: length 2.3
  BOTTOM w0.102: PC7817.1 176.58,59.31 175.82,60.07 v2(175.62,60.07)
  BOTTOM w0.254: PC7817.1 PR7814.1
VCC_VCPU: length 5.9
  BOTTOM w0.203: PU7800.34 172.02,48.45 171.93,48.36 171.27,48.36 171.22,48.41
  BOTTOM w0.457: PC7801.1 170.76,48.41 170.28,47.93 169.55,47.93 169.54,47.94 PC7802.1 168.05,47.5 168,47.45 PR7801.1
  BOTTOM w0.508: PC7801.1 171.07,48.57 171.22,48.41
VCCAMPHYPLL_1P0: length 22.8
  IN2 w0.254: v3(120.89,40.22) 121.07,40.22 121.34,39.96 121.34,36.48 122.9,34.91 122.9,33.86 123.93,32.83 124.72,32.03 127.51,32.03 128.27,31.27 v3(128.73,31.27)
  BOTTOM w0.254: v3(120.89,40.22) 121.02,40.35 U0400.L15 U0400.K15
  BOTTOM w0.305: v3(128.73,31.27) 129.45,30.55 C1610.1 131.33,30.55 131.57,30.3 131.57,29.8 131.95,29.42 132.92,29.42 133.25,29.75 133.25,30.17 133.45,30.38 134.16,30.38
VCCAPLL_1P0: length 20.4
  TOP w0.432: C1615.1 118.36,41.68 118.1,41.42 v3(118.1,41.1)
  IN2 w0.254: v3(118.1,41.1) 118.19,41.1 118.57,40.72 121.12,40.72 121.72,40.12 121.72,36.72 122.16,36.27 125.4,36.27 127.69,33.99 v3(127.81,33.99)
  BOTTOM w0.254: U0400.V15 117.93,41.1 v3(118.1,41.1) ; v3(127.81,33.99) 129.74,33.99 130.12,33.61 131.57,33.61
  vias: v2(133.12,33.81)
VCCAPLLEBB: length 23.4
  TOP w0.254: R1612.2 129.24,27.79 v2(129.01,28.02) 128.42,28.6 128.42,29.09 127.76,29.75 127.76,30.74 v3(127.58,30.91)
  IN3 w0.254: v3(119.77,43.11) 119.88,43.11 120.42,42.57 124.97,42.57 126.47,41.07 126.47,37.39 126.8,37.06 126.8,32.72 127.48,32.03 127.48,31.02 v3(127.58,30.91)
  BOTTOM w0.254: v3(119.77,43.11) 119.85,43.11 U0400.N18
VCCCLK1_CLK6_R: length 54.2
  TOP w0.356: R1611.2 127.48,43.77 127.79,44.07 127.79,44.73 128.32,45.27 v3(128.32,45.29)
  TOP w0.381: R1610.2 127.53,46.46 128.32,45.67 v3(128.32,45.29) ; v3(119.86,45.44) 120.05,45.44 120.23,45.27 C1626.1 120.8,45.27 v3(121.47,45.93) ; v1(130.94,22.33) 131.57,22.96 131.57,24.63 v2(131.51,24.69) 131.51,25.72 131.95,26.16 ; v3(128.16,40.06) 128.16,40.93 127.1,41.99 126.8,41.99 R1606.2 127.03,42.88 R1611.2
  IN1 w0.381: v3(121.47,45.93) 122.87,45.93 123.41,46.47 125.82,46.47 127.43,44.86 128.14,44.86 128.32,45.04 v3(128.32,45.29)
  IN3 w0.381: v1(130.94,22.33) 130.68,22.33 130.48,22.13 127.33,22.13 126.57,22.89 126.57,28.73 128.11,30.27 128.11,32.07 127.23,32.95 127.23,37.34 126.91,37.66 126.91,38.81 v3(128.16,40.06)
  BOTTOM w0.102: U0400.A10 127.2,37.8 128.01,37.8 128.47,38.26 128.47,39.45 128.16,39.76 v3(128.16,40.06) 128.16,40.09 127.74,40.51 U0400.A14
  BOTTOM w0.254: U0400.L21 120.31,45.44 v3(119.86,45.44)
VCCCLK2_R: length 5.1
  TOP w0.254: v3(121.4,43.08) 121.64,43.08 122.12,42.6 v2(122.73,42.6) 123.36,42.6 123.36,42.59 123.6,42.36 C1621.1 125.23,42.36 125.27,42.32 R1606.1
  BOTTOM w0.254: v3(121.4,43.08) 121.51,43.08 U0400.K19
VCCCLK4_R: length 6.9
  TOP w0.254: R1610.1 125.58,46.02 124.79,45.23 C1623.1 123.52,45.23 123.43,45.14 122.2,45.14 v2(121.39,44.33) 120.88,43.82 v3(120.6,43.82)
  BOTTOM w0.254: U0400.N20 120.44,43.82 v3(120.6,43.82)
VCCCLK5_R: length 21.4
  TOP w0.254: v3(128.07,52.3) 127.66,52.3 R1005.1 ; R1611.1 126.59,44.63 126.55,44.59 C1624.1 123.46,44.59 v2(123.42,44.63) 122.34,44.63 121.9,44.19 121.9,43.87 121.72,43.69 v3(121.44,43.69)
  IN1 w0.254: v3(128.07,52.3) 127.51,52.3 127.1,51.89 127.1,50.73 125.97,49.6 125.97,48.73 125.32,48.08 125.32,47.52 124.87,47.07 123.32,47.07 122.67,46.42 121.23,46.42 120.8,45.99 120.8,44.88 121.44,44.25 v3(121.44,43.69)
  BOTTOM w0.254: U0400.L19 121.28,43.69 v3(121.44,43.69)
VCCDSW_EN: length 196.1
  TOP w0.102: v1(177.77,39.91) 177.77,32.43 173.57,28.22 170.22,28.22 170,28.01 170,22.58 v1(168.98,21.55) ; U2300.88 37.7,26.95 38.61,26.04 38.61,23.7 v1(38.56,23.65) v2(38.06,23.15)
  IN2 w0.102: v1(94.92,15.34) 95.1,15.52 110,15.52 110.31,15.22 119.52,15.22 120.66,16.36 133.45,16.36 134.49,17.4 137.41,17.4 138.3,18.29 150.46,18.29 151.55,19.38 154.64,19.38 v1(155.04,18.98)
  IN3 w0.102: v1(94.92,15.34) 93.68,14.1 92.1,14.1 91.73,13.73 84.56,13.73 83.77,14.52 78.39,14.52 77.59,13.72 76.64,13.72 73.54,10.62 71.19,10.62 70.88,10.92 69.11,10.92 68.66,11.38 61.69,11.38 60.87,10.56 54.99,10.56 54.75,10.8 53.03,10.8 51.3,12.53 50.22,12.53 49.2,13.55 49.2,16.17 46.63,18.75 43.08,18.75 42.75,18.42 40.19,18.42 38.15,20.46 38.15,23.24 v1(38.56,23.65)
  BOTTOM w0.102: v1(155.04,18.98) 155.45,19.38 155.61,19.38 156.38,20.14 165.07,20.14 166.7,21.77 168.76,21.77 v1(168.98,21.55) 168.98,13.63 172.73,9.88 176.14,9.88 177.44,11.18 PR9103.1 ; PR8712.1 177.76,39.92 v1(177.77,39.91)
VCCGT_SENSE: length 91.4
  TOP w0.254: PC7821.1 181.2,50.07 181.38,50.24 R0703.1 182.07,51.01 v1(182.09,50.98) ; v1(162.1,59.79) 162.1,59.87 162.75,60.52 164.38,60.52 165.38,59.51 v1(177.17,59.51)
  IN3 w0.254: v1(177.17,59.51) 177.65,59.03 179.12,59.03 179.43,58.73 179.43,53.16 179.98,52.6 179.98,51.56 180.57,50.98 v1(182.09,50.98) ; v1(130.84,78.82) 133.63,78.82 136.54,75.91 145.64,75.91 147.45,74.11 147.45,73.94 148.54,72.85 150.6,72.85 151.11,73.36 152.53,73.36 155.83,70.06 155.83,63.74 157,62.56 160.91,62.56 161.65,61.83 161.65,60.61 162.1,60.15 v1(162.1,59.79)
  BOTTOM w0.076: 122.53,74.48 122.44,74.39 122.44,73.78 122.15,73.49 122.15,73.25 arc(122.16,73.18) 122.2,73.13 122.41,72.91 U0400.J70
  BOTTOM w0.229: v1(182.09,50.98) 182.47,50.98 182.7,50.75 182.7,49.84 v2(182.37,49.51) PR7817.2
  BOTTOM w0.254: 122.53,74.48 122.53,75.36 122.85,75.68 124.6,75.68 125.86,76.94 125.86,78.27 126.08,78.49 129.95,78.49 130.28,78.82 v1(130.84,78.82)
VCCGTSENSE_VCPU: length 4
  BOTTOM w0.102: PR7821.2 180.46,46.54 181.03,45.98 v2(181.25,45.98)
  BOTTOM w0.229: 182.37,47.53 182.3,47.53 181.94,47.17 181.36,47.17 181,47.53 PR7816.2 180.75,46.99 180.46,46.71 PR7821.2
VCCGTSENSE_VCPU_R: length 1.9
  BOTTOM w0.254: v2(178.66,46.1) 178.77,46.21 PC7818.1 179.4,46.92 179.6,46.72 PR7821.1
VCCGTSENSE_VCPU_RR: length 1.7
  BOTTOM w0.229: PR7822.2 PC7822.1 181.43,47.81 v2(181.53,47.7)
VCCHDA: length 25.2
  TOP w0.254: R1604.2 119.96,27.43 118.97,27.43 118.42,27.99 C1629.1 117.81,28.07 117.54,28.34 117.54,30.02 117.26,30.3 116.1,30.3 115.94,30.46 115.94,33.24 115.62,33.56 115.62,34.62 116.05,35.05 116.05,38.42 114.74,39.73 113.92,39.73 113.36,40.29 113.36,41.28 113.84,41.76 114.03,41.76 114.53,42.26 v2(114.53,42.47) 114.53,42.65 114.25,42.93 114.25,43.39 C1620.1 112.96,43.84 112.24,43.13 v3(112.24,43.13)
  BOTTOM w0.254: U0400.AJ19 112.33,43.13 v3(112.24,43.13)
VCCMPHYGT_1P0: length 0.4
  TOP w0.127: 124.05,37.16 124.46,37.16
  vias: v1(130.91,29.11) v1(131.37,28.7) v1(131.98,28.8) v1(132.54,28.53) v2(131.5,29.42) v3(119.74,41.79) v3(119.76,41.17) v3(120.6,41.79) v3(120.6,41.21)
VCCPRIM: length 9.6
  TOP w0.432: v3(116.43,43.72) 116.33,43.82 115.98,43.82 C1600.1
  IN3 w0.254: v3(116.43,43.72) 116.13,43.72 115.32,44.53 113.92,44.53 113.34,43.94 112.7,43.94 v3(112.23,44.41)
  BOTTOM w0.254: U0400.AB19 116.15,43.43 v3(116.43,43.72) 116.36,43.72 U0400.AB20 ; U0400.P18 119.02,42.46 v3(118.98,42.46) ; U0400.AK20 112.13,44.41 v3(112.23,44.41) ; v3(119.18,32.51) 119.14,32.55 U0400.T1 ; U0400.Y18 116.47,42.42 v3(116.41,42.42) 116.28,42.42 U0400.AB17
  vias: v1(132.11,30.07) v1(132.7,29.93) v2(131.7,31.3)
VCCRTC: length 69.9
  TOP w0.102: v2(110.49,21.95) 110.49,22.38 109.83,23.04 109.83,24.13 109.68,24.28 R1623.1
  TOP w0.254: R1623.1 109.32,25.08 v1(109.59,25.34) ; v3(104.2,40.74) 105.21,39.74 105.21,36.38 101.68,32.84 97.28,32.84 C1618.1 96.98,31.75 v1(96.7,31.47) ; v3(112.22,43.75) 111.76,44.21 111.76,44.61 112.03,44.88 112.83,44.88 113.18,45.24 C1619.1
  IN1 w0.254: v3(104.2,40.74) 104.74,40.21 107.11,40.21 107.87,40.97 109.02,40.97 109.91,41.86 109.91,42.12 110.52,42.73 111.49,42.73 111.77,43.01 111.77,43.31 112.21,43.75 v3(112.22,43.75)
  IN2 w0.254: v1(109.59,25.34) 109.55,25.38 108.59,25.38 108.28,25.07 108.28,24.57 108.01,24.3 105.25,24.3 104.93,24.62 101.46,24.62 100.85,25.22 98.04,25.22 96.88,24.06 90.14,24.06 89.26,24.95 89.26,26.6 v1(89.59,26.93)
  IN3 w0.254: v1(89.59,26.93) 89.38,27.13 89.38,27.74 90.22,28.58 92.17,28.58 94.1,30.51 95.71,30.51 96.67,31.47 v1(96.7,31.47)
  BOTTOM w0.203: v3(104.2,40.74) 104.23,40.72 104.96,40.72 U0400.BB14
  BOTTOM w0.254: v3(112.22,43.75) 112.12,43.75 U0400.AK19
VCCSA_SENSE: length 76.3
  TOP w0.254: v1(166.27,47.37) 166.07,47.58 PR7844.1 v2(165.46,48.44)
  IN3 w0.254: v1(170.15,44.02) 170.74,44.02 171.64,44.93 171.64,45.79 170.72,46.71 166.93,46.71 v1(166.27,47.37) 166.27,48.77 163.86,51.18 162.06,51.18 161.27,50.39 159.46,50.39 159.18,50.66 159.18,51.88 158.48,52.58 157.21,52.58 156.07,53.72 145.97,53.72 145.31,53.06 139.59,53.06 138.42,54.22 138.42,55.93 136.66,57.7 132.22,57.7 131.29,56.77 128.94,56.77 127.89,55.72 127.89,54.6 127.15,53.86 127.15,52.42 125.14,50.42 123.47,50.42 122.79,49.73 122.79,45.42 121.91,44.55 121.91,43.46 v3(122.24,43.13)
  BOTTOM w0.229: v1(170.15,44.02) 170.28,43.89 PC7833.1 171.25,43.51 R0608.1
  BOTTOM w0.254: U0400.H20 122.62,43.52 v3(122.24,43.13)
VCCSA_SENSE_VCPU: length 37
  TOP w0.229: v2(175.34,40.95) 174.27,40.95 PR7845.1 PR7848.1
  TOP w0.254: PR7844.2 163.14,47.58 161.11,45.54 161.11,44.94 159.46,43.28 159.46,42.22 160.6,41.07 160.6,37.97 v1(161.16,37.41) ; v1(175.51,43.51) 175.51,42.88 174.42,41.79 PR7848.1
  IN2 w0.254: v1(175.51,43.51) 174.35,42.34 174.35,40.94 170.81,37.41 v1(161.16,37.41)
VCCSA_SENSE_VCPU_R: length 2.5
  TOP w0.102: v2(175.36,44.15) 175.36,44.12 v1(174.84,43.6)
  TOP w0.229: v1(174.84,43.6) 174.4,43.16 PR7848.2
  BOTTOM w0.229: PC7834.2 175.03,43.79 v1(174.84,43.6)
VCCSRAM_1P0: length 2.8
  BOTTOM w0.254: U0400.AF20 114.63,43.77 v3(114.76,43.77) 114.76,44.29 U0400.AF21 ; U0400.T19 118.57,43.43 v3(118.92,43.79) 118.8,43.79 U0400.T20
  vias: v3(126.92,31.5) v3(127,30.89)
VCCST_PWRGD: length 300.5
  IN1 w0.097: v1(130.82,78.21) 130.35,78.68 130.35,82.98 125.5,87.84 114.88,87.84 114,88.72 112.93,88.72 107.7,93.96 107.7,94.64 106.35,95.99 106.35,97.21 103.63,99.93 103.63,100.33 103.33,100.64 103.33,100.94 103.1,101.17 103.05,101.17 102.72,101.5 101.7,101.5 101.02,102.19 101.02,103.25 99.57,104.7 99.57,104.73 99.34,104.96 99.31,104.96 v1(99.11,105.16) ; v1(82.77,12.99) 80.62,10.85 76.34,10.85 74.81,9.32 70.23,9.32 68.12,11.43 60.55,11.43 59.41,12.58 58.38,12.58 55.73,15.23 48.72,15.23 45.33,18.62 43.73,18.62 38.96,23.39 38.96,23.82 35.55,27.23 34.63,27.23 32.82,29.05 32.82,39.81 32.11,40.52 32.11,42.23 28.85,45.48 28.85,49.38 27.95,50.29 27.95,53.6 28.84,54.5 28.84,58.7 27,60.54 27,65.82 24.45,68.38 23.42,68.38 22.5,69.3 16.58,69.3 v1(14.45,71.42)
  IN3 w0.127: v1(96.62,13.92) 96.05,13.92 94.34,12.22 90.81,12.22 90.53,12.5 83.87,12.5 83.38,12.99 v1(82.77,12.99) ; v1(99.11,105.16) 99.12,105.16 99.12,105.15 98.4,104.42 98.4,104.11 92.85,98.57 83.87,98.57 80.3,102.14 75.03,102.14 73.73,103.44 53.04,103.44 52.23,102.63 45.76,102.63 43.92,100.8 31.16,100.8 28.2,97.84 27.56,97.84 23.73,94.01 22.28,94.01 20.68,92.41 20.68,90.9 18.71,88.93 16.31,88.93 15.38,88 13.95,88 13.28,87.34 13.28,85.19 12.71,84.62 12.71,82.87 12.02,82.17 12.02,80.45 11.61,80.04 11.61,78.61 14.03,76.2 14.03,71.85 v1(14.45,71.42)
  BOTTOM w0.102: R1202.1 130.42,77.8 v1(130.82,78.21) ; v1(96.62,13.92) 96.62,14.43 96.77,14.58 96.77,16.18 v2(96.78,16.19) R1224.2 98.07,16.61 98.07,16.54 C1206.1 98.17,15.77 U1204.4
VCCST_PWRGD_R: length 13.6
  BOTTOM w0.076: 128.73,69.47 128.33,69.87 127.35,69.87 127.33,69.85 127.21,69.85 126.93,69.7 126.78,69.7 U0400.B65
  BOTTOM w0.102: 128.73,69.47 129.67,69.47 130.12,69.01 130.77,69.01 130.96,69.21 130.96,73.28 v2(130.51,73.74) 129.21,75.03 129.21,76.53 129.62,76.94 R1202.2
VDD1: length 8.9
  TOP w0.279: C3911.1 38.87,60.89 38.51,61.25 38.51,62.74 38.18,63.07 U3901.8
  TOP w0.432: v2(40.16,65.76) R3917.2 R3918.2 39.41,64.3 39.27,64.16 C3906.1 C3908.1 C3904.1 C3911.1
VDDC_BOOT1: length 4
  BOTTOM w0.222: 117.15,99.8 116.76,99.8 v2(116.51,99.55) 116.13,99.55 116.06,99.61 115.48,99.61
  BOTTOM w0.229: 115.48,99.61 PU9400.38
  BOTTOM w0.508: PR9410.1 118.37,100.21 117.96,99.8 117.15,99.8
VDDC_BOOT2: length 3
  BOTTOM w0.222: PU9400.2 114.07,97.51 v2(114.3,97.28) 114.83,96.76 115.54,96.76
  BOTTOM w0.508: 115.54,96.76 115.75,96.76 PR9417.1
VDDC_EN: length 6.7
  TOP w0.102: v1(117.25,105.64) v2(117.25,104.98)
  BOTTOM w0.102: PU9400.29 114.07,103.99 PC9413.1 114.33,104.74 PR9427.2 115.3,104.96 116.13,104.96 116.25,104.83 PD9400.1 117.12,105.51 v1(117.25,105.64)
VDDC_LG1: length 26.9
  TOP w0.635: v4(116.13,101.71) 116.13,101.82 116.36,102.05 122.74,102.05 124.08,103.38 126.74,103.38 129.77,100.34 129.78,100.34 129.78,99.1 130.66,98.22 v2(132.49,98.22) 132.98,97.73 132.98,96.34 131.93,95.29 v4(131.93,94.85)
  BOTTOM w0.222: PU9400.35 115.4,100.81 116.13,101.55 v4(116.13,101.71)
  BOTTOM w0.635: PR9605.1 132.7,95.26 132.28,94.85 v4(131.93,94.85)
VDDC_LG2: length 18.8
  TOP w0.102: v4(129.41,104.65) v2(129.41,105.44)
  IN1 w0.635: v4(129.41,104.65) 129.13,104.93 126.57,104.93 123.01,101.37 119.77,101.37 117.42,99.02 v4(115.8,99.02)
  BOTTOM w0.222: PU9400.39 115.61,99.21 v4(115.8,99.02)
  BOTTOM w0.635: PR9609.1 129.13,104.93 v4(129.41,104.65)
VDDC_PH1: length 18.6
  TOP w0.508: v1(127.56,95.2) 127.56,99.75 125.88,101.42 v2(125.48,101.42) 125.1,101.42 124.08,100.41 v1(117.65,100.41)
  BOTTOM w0.222: PU9400.36 115.46,100.41 115.99,100.95 116.5,100.95 116.56,100.89
  BOTTOM w0.432: 116.56,100.89 116.64,100.82 PC9407.2 117.25,100.82 v1(117.65,100.41)
VDDC_PH2: length 17.5
  TOP w0.508: v1(117.81,107.83) 114.81,104.83 v2(114.81,100.33) 114.81,98.97 115.6,98.17 v1(117.83,98.17)
  BOTTOM w0.222: PU9400.40 115.17,98.81 115.56,98.42 116.25,98.42
  BOTTOM w0.432: v1(117.83,98.17) 117.45,98.55 PC9409.2 116.97,99.14 116.25,98.42
VDDC_PVCC: length 4.5
  BOTTOM w0.222: v2(116.13,102.52) 115.85,102.52 115.54,102.2 115.54,101.41 115.34,101.21 PU9400.34
  BOTTOM w0.432: PR9414.2 117.6,103.02 117.22,102.64 PC9406.2 v2(116.13,102.52)
VDDC_RTN: length 13.2
  BOTTOM w0.222: PU9400.4 113.27,97.85 113.31,97.82 113.31,97.06 114.36,96 114.97,96
  BOTTOM w0.432: PR9453.1 116.59,91.65 117.01,91.23 v2(117.78,91.23) ; PR9453.1 PC9417.2 ; PR9453.1 PC9419.1 117.76,92.1 118.24,92.58 118.24,93.23 118.06,93.4 118.06,93.72 117.39,94.39 117.19,94.39 116.51,95.07 PR9436.1 115.9,95.07 114.97,96
VDDC_SVC: length 67.9
  IN3 w0.102: v1(143.97,81.51) 143.4,81.51 143.1,81.81 143.1,84.07 139.17,88.01 139.17,89.09 138.69,89.56 134.72,89.56 131.93,92.36 130.99,92.36 128.32,95.03 128.32,99.64 125.88,102.09 123.13,102.09 121.62,103.6 121.62,105.47 120.94,106.14 115.56,106.14 115.25,105.83 109.51,105.83 109.46,105.88 105.37,105.88 v1(105.26,106)
  BOTTOM w0.102: PU9400.19 109.85,102.01 109.04,102.82 109.04,103.48 PR9402.2 107.95,104.85 107.61,105.2 106.06,105.2 PT9402.1 v1(105.26,106) ; v1(143.97,81.51) 143.97,80.9 144.4,80.47 144.4,78.74 144.82,78.32 PC9423.1 145.2,78.76 145.19,78.77 PR9460.1 145.19,79.76 145.18,79.76 PR9451.1
VDDC_SVD: length 64.4
  IN3 w0.102: v1(105.64,106.53) 109.5,106.53 109.72,106.31 115.05,106.31 115.36,106.62 121.14,106.62 122.1,105.67 122.1,103.8 123.33,102.57 126.08,102.57 128.55,100.1 128.55,95.13 131.09,92.59 132,92.59 134.8,89.79 138.75,89.79 139.37,89.17 139.37,88.17 143.56,83.98 v1(143.56,82.12)
  BOTTOM w0.102: PU9400.20 110.11,102.41 109.86,102.67 109.86,103.72 PT9400.1 107.84,105.74 PR9403.2 106.43,105.74 v1(105.64,106.53) ; v1(143.56,82.12) 144.48,82.12 144.53,82.07 PC9421.1 PR9449.1 PR9458.1
VDDC_SVT: length 2.9
  BOTTOM w0.222: 110.87,103.71 PU9400.21
  BOTTOM w0.432: 110.87,103.71 110.77,103.81 PT9401.1 110.77,105.29 PR9450.1
VDDC_UG1: length 21.1
  TOP w0.635: v4(116.16,100.25) 117.22,101.31 123.62,101.31 124.7,102.39 126.11,102.39 128.64,99.86 128.64,98.39 v2(129.93,97.1) 131.04,95.99 v4(131.04,95.38)
  BOTTOM w0.222: v4(116.16,100.25) 115.93,100.01 PU9400.37
VDDC_UG2: length 11.9
  TOP w0.102: v2(118.01,103.18) v4(118.77,103.18)
  IN1 w0.635: v4(115.07,97.36) 114.88,97.54 114.88,101.6 116.46,103.18 v4(118.77,103.18)
  BOTTOM w0.222: PU9400.1 114.47,97.85 114.96,97.36 v4(115.07,97.36)
  BOTTOM w0.635: PR9607.1 118.95,103.36 v4(118.77,103.18)
VDDC_VCC: length 18.9
  TOP w0.102: v1(106.1,101.75) 105.89,101.75 105.77,101.88 v2(105.77,102.75)
  IN1 w0.508: v1(106.1,101.75) 105.84,102.01 105.84,105.23 107.07,106.47 112.12,106.47 v1(112.73,107.08)
  BOTTOM w0.222: PU9400.17 109.66,101.21 109.25,101.63 108.79,101.63
  BOTTOM w0.432: v1(112.73,107.08) PR9423.1 ; 108.79,101.63 PC9405.2 108.15,101.5 107.65,100.99 106.96,100.99 106.88,101.07 PR9413.1 105.82,101.48 v1(106.1,101.75)
VDDC_VCCSENSE: length 48.5
  TOP w0.254: v1(144.88,90.55) 144.81,90.63 141.73,90.63 138.63,87.53 134.9,87.53 133.05,89.39 131.31,89.39 131.12,89.19 131.1,89.19 116.86,89.19 v2(115.56,90.49) 115.06,90.99 v1(115.06,91.53)
  IN1 w0.254: v1(157.05,92.35) 157.06,92.35 156.53,91.82 156.16,91.82 154.61,90.27 153.77,90.27 153.09,89.59 145.85,89.59 v1(144.88,90.55)
  BOTTOM w0.254: v1(157.05,92.35) 157.1,92.35 U6000.AC20 ; PR9452.2 115.06,91.75 115.06,91.54 v1(115.06,91.53)
VDDC_VDDIO: length 9
  BOTTOM w0.102: v2(108.56,109.17) 109.78,109.17 111.02,107.93 PR9409.2
  BOTTOM w0.222: 111.47,103.72 111.27,103.53 PU9400.22
  BOTTOM w0.432: 111.47,103.72 112.07,104.32 112.07,106.28 111.84,106.5 PC9404.1 111.02,106.86 PR9409.2
VDDC_VRHOT: length 2.9
  BOTTOM w0.222: 110.33,98.58 PU9400.11
  BOTTOM w0.254: PR9416.2 109.13,97.2 109.14,97.18 PT9403.1 110.33,97.99 110.33,98.58
VDDC_VSEN: length 6.8
  TOP w0.102: v2(112.71,94.35) 112.71,93.92 v1(112.45,93.65)
  IN2 w0.432: v1(111.43,97.28) 111.53,97.28 112.45,96.37 v1(112.45,93.65)
  BOTTOM w0.222: PU9400.8 111.67,97.86 111.63,97.82 111.63,97.49 v1(111.43,97.28)
  BOTTOM w0.432: PR9455.1 112.19,93.86 112.4,93.65 v1(112.45,93.65)
VDDC_VSEN_R: length 6.5
  BOTTOM w0.381: PR9433.2 112.33,94.72 PR9455.2
  BOTTOM w0.432: PR9433.2 PC9416.1 113.58,93.97 112.83,93.22 PC9418.1 PR9430.1 PR9452.1 PC9417.1
VDDC_VSSSENSE: length 48.6
  TOP w0.254: v1(116.17,93.58) 116.17,90.99 117.62,89.55 130.97,89.55 131.17,89.74 133.45,89.74 v2(134.37,88.83) 135.31,87.89 138.48,87.89 141.63,91.04 145.31,91.04 v1(145.47,90.88)
  IN1 w0.254: v1(156.34,92.31) 156.09,92.31 154.41,90.63 153.57,90.63 152.88,89.94 146,89.94 145.47,90.48 v1(145.47,90.88)
  BOTTOM w0.254: U6000.AD20 156.7,91.95 v1(156.34,92.31) ; PR9453.2 116.59,93.17 v1(116.17,93.58)
VDDQC: length 0.6
  BOTTOM w0.152: v3(110.77,55.93) 111.04,55.66 U0400.AM40
VIN_VCPU: length 3.9
  BOTTOM w0.229: PU7800.33 172.15,48.05 171.88,47.78 171.35,47.78
  BOTTOM w0.508: 171.35,47.78 171.02,47.45 PC7804.2 170.64,46.74 170.54,46.74 169.85,46.05 PR7802.1
VSS_SENSE: length 73.8
  TOP w0.229: PC7819.2 174.98,54.28 174.78,54.08 174.78,53.34 PR7823.1 174.9,52.81 v1(174.63,52.53)
  TOP w0.254: v1(174.63,52.53) 174.63,52.53 175.16,52 v2(175.69,52) ; v3(124.91,51.35) 125.12,51.13 125.12,50.7
  IN3 w0.254: v3(124.91,51.35) 125.57,51.35 126.68,52.46 126.68,55.07 128.74,57.13 131.14,57.13 132.11,58.09 136.77,58.09 138.85,56.01 138.85,54.49 139.82,53.52 144.83,53.52 147.52,56.21 158.19,56.21 158.64,56.66 159.66,56.66 160.71,55.6 160.71,53.09 161.98,51.82 164.01,51.82 167.97,47.86 169.59,47.86 170.74,49.01 170.74,49.45 172.09,50.8 172.9,50.8 v1(174.63,52.53)
  BOTTOM w0.229: PU7800.6 175.1,52.03 175.26,52.18 PC7823.1
  BOTTOM w0.254: U0400.E33 124.91,51.49 v3(124.91,51.35) ; PC7823.1 174.99,52.9 v1(174.63,52.53)
VSSGT_SENSE: length 92.2
  TOP w0.229: v1(178.08,47.91) 178.92,47.91 179.55,48.54 PC7826.1
  TOP w0.254: PC7826.1 179.76,48.62 PC7821.2 179.76,50.68 R0702.1 ; v1(169.67,58.02) v2(168.88,58.81) 168.56,59.13 165.2,59.13 164.17,60.16 163.08,60.16 v1(162.74,59.82)
  IN3 w0.254: v1(162.74,59.82) 162.74,60.02 162.03,60.73 162.03,61.95 161.06,62.92 157.15,62.92 156.21,63.86 156.21,70.18 152.67,73.72 150.96,73.72 150.45,73.21 148.69,73.21 147.8,74.09 147.8,74.26 145.79,76.27 136.69,76.27 133.48,79.48 v1(130.83,79.48) ; v1(178.08,47.91) 178.16,47.91 179.42,49.17 179.63,49.37 179.63,52.45 179.07,53.01 179.07,55.76 176.81,58.02 v1(169.67,58.02)
  BOTTOM w0.076: 122.18,74.1 122.18,73.76 121.98,73.56 121.98,73.19 arc(122,73.12) 122.04,73.05 122.08,73.01 arc(122.13,72.94) 122.15,72.86 122.15,72.85 122.15,72.53 122.41,72.26 U0400.J69
  BOTTOM w0.229: v1(178.08,47.91) 177.94,48.05 PU7800.18
  BOTTOM w0.254: v1(130.83,79.48) 130.43,79.48 129.79,78.84 125.93,78.84 125.5,78.41 125.5,77.09 124.44,76.02 122.7,76.02 122.18,75.5 122.18,74.1
VSSSA_SENSE: length 74.7
  IN3 w0.254: v1(170.51,45.54) 169.7,46.36 166.4,46.36 165.79,46.97 165.79,48.75 163.71,50.83 162.27,50.83 161.48,50.04 159.31,50.04 158.83,50.52 158.83,51.73 158.34,52.22 157.06,52.22 155.92,53.37 146.13,53.37 145.47,52.71 139.39,52.71 138.07,54.03 138.07,55.79 136.51,57.34 132.37,57.34 131.44,56.41 129.08,56.41 128.24,55.57 128.24,54.45 127.51,53.72 127.51,52.28 125.29,50.06 123.62,50.06 123.14,49.58 123.14,45.27 122.38,44.51 v3(122.38,44.02)
  BOTTOM w0.229: PC7833.2 R0609.1 172.29,44.76 172.64,44.4 PC7837.1 173.01,44.4 173.44,44.83 174,44.83 174.37,45.21 174.37,45.8 174.7,46.13 PU7800.26
  BOTTOM w0.254: v3(122.38,44.02) 122.62,44.27 U0400.H21 ; v2(170.84,46.1) 170.51,45.77 v1(170.51,45.54) 170.51,45.11 PC7833.2
3P3VSB_EN2: length 226.5
  TOP w0.102: v1(38.56,22.63) 38.07,22.15 36.09,22.15 v2(35.79,21.85) 33.25,21.85 32.39,22.71 30.1,22.71 28.47,24.34 R2409.1
  TOP w0.254: v1(202.31,57.94) 201.65,58.6 PC8921.1
  IN2 w0.102: v1(38.56,22.63) 39.4,22.63 43.28,18.75 46.69,18.75 47.05,18.39 54.2,18.39 55.27,17.33 61.39,17.33 61.99,16.72 63.58,16.72 63.97,16.33 66.95,16.33 67.26,16.03 67.26,15.77 68.98,14.05 71.45,14.05 71.91,13.59 74.48,13.59 75.4,14.51 78.82,14.51 81.85,17.53 94.84,17.53 95.94,18.62 104.38,18.62 104.91,18.09 106.62,18.09 106.94,18.41 109.95,18.41 110.47,17.9 112.73,17.9 113.3,17.33 115.12,17.33 115.73,17.93 117.96,17.93 118.8,18.77 121.78,18.77 122.19,19.18 128.12,19.18 129.44,20.5 130.2,20.5 131.83,22.13 131.83,25.1 132.61,25.88 133.71,25.88 134.06,26.24 135.79,26.24 135.84,26.19 139.07,26.19 141.76,28.88 146.84,28.88 149.08,31.12 156.77,31.12 159.39,33.74 159.39,40.87 154.56,45.7 154.56,49.6 155.23,50.27 159.55,50.27 159.88,49.94 164.26,49.94 165.43,48.77 167.92,48.77 168.45,48.24 171.34,48.24 171.38,48.19 172.03,48.19 172.59,47.63 172.59,47.5 175.56,44.53 178,44.53 182.3,48.83 182.89,48.83 185.04,50.98 191.09,50.98 194.72,54.61 194.72,56.79 195.77,57.84 197.38,57.84 197.49,57.74 198.07,57.74 v1(198.37,58.04) 198.57,57.85 198.57,57.56 198.85,57.28 200.36,57.28 201.42,58.35 201.9,58.35 v1(202.31,57.94)
  BOTTOM w0.102: PU8900.6 198.74,58.41 v1(198.37,58.04)
+0P95VGA_EN: length 5.4
  TOP w0.254: PC9515.1 169.77,110.47 PR9508.2 ; PC9515.1 168.12,110.47 167.67,110.92 v2(167.67,111.33) ; PC9515.1 168.71,109.96 168.91,109.76 v1(169.37,109.76)
  BOTTOM w0.254: v1(169.37,109.76) 169.37,109.83 169.46,109.92 PU9501.5
+0P95VGA_FB_R: length 4.7
  BOTTOM w0.203: 167.54,112.75 167.93,112.75 v2(168.35,112.33) 168.73,111.95 168.73,110.92 168.5,110.7 PJP9505.2
  BOTTOM w0.406: 167.54,112.75 PR9509.2 PC9517.2
+0P95VGA_LX: length 3.9
  TOP w0.508: PR9506.2 172.73,112.41 172.16,111.84 v1(172.16,109.76)
+0P95VGA_RC: length 2.7
  TOP w0.508: PC9516.1 174.77,113.72 PR9506.1 174.44,112.62 v2(173.94,112.12)
+0P95VGA_VIN:
  vias: v2(176.89,112.32)
+1P2V_DUAL: length 174.5
  TOP w0.381: C2201.1 69.21,61.86 v1(68.94,61.59)
  TOP w0.432: 70.11,45.74 C2204.1 ; C2204.1 70.11,46.96 ; C2204.1 70.58,46.35 ; 57.88,74.72 C2237.1 ; C2237.1 57.88,75.84 ; C2237.1 58.35,75.28 ; 53.3,45.32 C2219.1 53.77,44.71 ; C2228.1 62.48,38.81 ; C2207.1 71.18,60.81 ; C2207.1 70.71,60.2 ; C2207.1 70.71,61.42 ; C2224.1 70.51,75.21 ; C2224.1 70.98,74.65 ; C2224.1 70.51,74.09 ; C2241.1 57.74,43.15 ; C2241.1 57.74,42.04 ; C2241.1 58.21,42.6 ; C2226.1 70.76,59.39 ; C2226.1 70.76,58.27 ; C2226.1 71.23,58.83 ; C2240.1 60.64,30.38 ; C2240.1 60.17,29.82 ; C2240.1 60.17,30.94 ; 57.01,62.36 C2234.1 57.48,61.8 ; C2211.1 52.77,49.35 ; C2211.1 53.24,48.74 ; C2211.1 52.77,48.13 ; 57.6,85.02 C2218.1 58.07,85.62 ; C2201.1 69.82,62.28 ; R2100.1 50.39,56.48 ; R2100.1 50.39,55.37 ; R2100.1 50.86,55.93 ; 56.85,63.38 C2217.1 ; C2206.1 61.97,70.44 ; C2206.1 61.5,69.83 ; C2206.1 61.97,69.22 ; 69.85,50.55 C2205.1 ; C2205.1 70.32,51.16 ; C2205.1 69.85,51.77 ; C2200.1 61.98,78.49 ; C2200.1 61.51,77.88 ; C2200.1 61.98,77.27 ; v1(56.27,50.86) 56.38,50.75 C2235.1 ; C2229.1 71.18,85.28 ; C2229.1 70.71,85.84 ; C2229.1 70.71,84.73 ; 60.81,87.18 C2227.1 60.34,87.73
  TOP w0.508: 49.56,70.26 48.29,68.99 46.46,68.99 45.99,68.52 44.07,68.52 42.86,67.31 38.56,67.31 ; v1(56.29,51.84) 56.39,51.74 C2212.1
  IN2 w0.508: v1(50.93,46.97) 50.32,46.97 49.48,47.81 49.48,50.43 v1(50.65,51.6)
  IN3 w0.508: v1(98.86,105.92) 98.27,106.5 96.17,106.5 93.78,104.12 v4(93.78,103.02)
  BOTTOM w0.127: v3(104.07,55.51) 104.08,55.5 104.86,55.5 104.86,55.49 U0400.BB41
  BOTTOM w0.178: U0400.BB32 104.89,50.54 104.88,50.53 103.86,50.53 v3(103.71,50.37)
  BOTTOM w0.203: U0400.BB23 104.94,45.55 104.75,45.36 104.14,45.36 104.05,45.27 v3(103.99,45.27) ; v3(103.8,61.77) 103.97,61.6 U0400.BB51 ; U0400.BB47 104.67,59.15 104.46,59.35 104.46,59.37 104.45,59.39 v3(104.44,59.39)
  BOTTOM w0.254: v3(107.49,45.9) 107.49,46.05 U0400.AU23 ; v3(107.46,48.57) 107.46,48.66 107.66,48.85 107.66,48.95 U0400.AU28
  BOTTOM w0.305: CON2100.33 58.76,85.32 v1(58.8,85.28) 59.79,86.27 59.79,88.62 60.74,89.57 CON2000.12 ; v1(67.77,63.86) 67.77,63.64 68.13,63.27 69.19,63.27 69.24,63.32 CON2000.117 ; v1(59.23,53.01) 58.92,53.32 CON2100.153 ; CON2000.54 61.01,79.07 60.68,78.74 v1(60.68,78.67) ; CON2000.241 69.16,30.32 v1(69.04,30.44) ; CON2100.241 58.92,31.32 59.97,30.28 v1(59.97,29.14) ; CON2100.142 50.49,58.07 v1(50.69,58.27) ; CON2100.75 58.78,74.82 58.94,74.99 58.94,75.33 v1(58.93,75.34) ; CON2100.129 59.05,61.32 59.08,61.29 ; CON2000.124 63.3,61.57 v1(63.32,61.59) ; CON2000.147 71.83,53.82 72.19,53.47 v1(72.19,52.35) ; CON2000.154 63.75,52.07 v1(63.75,52.07) ; v1(50.65,51.6) 50.63,51.57 CON2100.160 ; 59.13,59.82 59.13,59.82 CON2100.135 ; CON2100.136 50.89,59.57 v1(50.98,59.49) ; v1(72.21,58.04) 72.21,58.37 71.76,58.82 CON2000.135 ; v1(51.16,69.57) 50.79,69.57 50.78,69.58 50.36,69.58 50.35,69.57 CON2100.96 ; v1(56.27,50.86) 56.31,50.82 CON2100.163 ; v3(107.46,55.93) 107.46,56.08 U0400.AU42 ; v1(69.01,64.84) 69.03,64.82 CON2000.111 ; CON2000.153 71.51,52.32 v1(71.53,52.34) ; CON2000.112 60.68,64.57 59.97,65.28 v1(59.97,66.04) ; CON2000.96 61.13,68.57 v1(60.68,68.13) ; CON2000.199 71.28,40.82 71.6,41.15 v1(71.6,41.6) ; v1(51.13,80.07) 51.08,80.02 50.42,80.02 50.37,80.07 CON2100.54 ; v1(60.63,38.84) 60.63,35.89 60.95,35.57 CON2000.220 ; v1(72.8,52.3) 72.8,51.95 71.67,50.82 CON2000.159 ; v1(48.08,90.57) CON2100.12 ; CON2100.130 v1(50.7,61.07) ; v1(50.62,64.09) 50.6,64.07 CON2100.118 ; v1(50.93,46.97) 50.83,47.07 CON2100.178 ; v1(60.58,62.87) 60.79,63.07 CON2000.118 ; v1(63.32,50.59) 63.3,50.57 CON2000.160 ; CON2100.220 51.88,36.57 52.32,36.13 v1(52.32,36.12) ; CON2000.178 63.71,46.07 v1(63.86,45.93) ; v1(50.62,53.09) 50.6,53.07 CON2100.154 ; v1(71.65,73.43) 71.65,73.66 71.49,73.82 CON2000.75 ; v1(58.78,42.61) 58.78,42.1 58.5,41.82 CON2100.199 ; v1(56.21,64.27) 56.26,64.32 CON2100.117 ; CON2100.112 50.6,65.57 v1(50.62,65.59) ; 60.83,58.57 CON2000.136 ; v1(56.19,62.72) 56.29,62.82 CON2100.123 ; v1(71.6,58.02) 71.6,57.63 71.3,57.32 CON2000.141 ; CON2100.148 v1(50.6,54.57) ; 60.83,57.08 60.83,57.07 CON2000.142 ; v1(71.6,84.58) 71.34,84.32 CON2000.33 ; CON2000.129 71.43,60.32 v1(71.69,60.06) ; v1(50.57,62.59) 50.55,62.57 CON2100.124 ; CON2100.147 59.53,54.82 ; CON2000.123 69.17,61.82 v1(68.94,61.59) ; v1(56.29,51.84) 56.31,51.82 CON2100.159 ; v1(63.4,53.75) 63.22,53.57 CON2000.148 ; U0400.AU35 107.46,53.06 v3(107.46,53.22) ; CON2100.141 56.11,58.32 55.76,57.97 v1(55.76,57.97) ; v1(71.55,48.85) 71.55,49.52 71.25,49.82 CON2000.163 ; CON2100.111 56.31,65.82 v1(56.29,65.84) ; 60.32,60.07 CON2000.130
  BOTTOM w0.356: U0500.5 95.39,110.02 95.08,109.72 C0500.1 95.76,109.02 v1(98.86,105.92)
  vias: v1(59.84,53.75) v1(60.3,53.32) v1(60.78,53.72) v2(57.18,77.47) v2(88.52,98.4) v4(90.09,101.88) v4(90.75,101.27) v4(91.44,101.88) v4(92.1,101.25) v4(92.91,103.02) v4(92.91,102.14) v4(93.78,102.16)
+1P2V_DUAL_A_CS: length 5.2
  TOP w0.229: PU8600.13 100.48,99.9 100.41,99.98
  TOP w0.254: PR8611.2 99.67,100.56 99.54,100.69 99.54,102.09 v2(100.66,103.2)
  TOP w0.508: PR8611.2 100.41,100.31 100.41,99.98
+1P2V_DUAL_A_FB_A: length 5.3
  TOP w0.229: PR8609.1 101.96,95.15 101.85,95.25 101.85,95.74 102,95.89 102.44,95.89 v2(102.79,96.24) 102.79,96.27 102.34,96.73 102.34,96.8 102.12,97.02 PU8600.6
  TOP w0.254: PR8610.1 103.48,94.97 103.35,94.85 PC8611.2 PR8609.1
+1P2V_DUAL_A_S3: length 5.8
  TOP w0.229: PR8603.2 105.51,95.4 v2(104.83,96.09) 104.24,96.67 PC8605.1 103.05,96.67 102.31,97.42 PU8600.7
  TOP w0.254: PR8603.2 PR8604.2
+1P2V_DUAL_A_TON: length 2.2
  TOP w0.229: PR8602.2 103.55,98.22 v2(103.07,98.22) PU8600.9
+1P2V_DUAL_A_V5IN: length 2.8
  TOP w0.229: PU8600.12 100.88,99.82 101.12,100.05
  TOP w0.457: 101.12,100.05 PC8600.1 101.8,100.56 PR8600.2
+1P2V_DUAL_A_VOUT_R_A: length 25.6
  TOP w0.229: PC8612.1 103.35,94.06 103.28,93.98 PC8611.1 PR8609.2 101.55,93.98 101.42,94.11 101.42,96.07 101.28,96.21 PU8600.5
  TOP w0.254: v2(96.04,106.89) 96.42,106.5 v1(96.42,105.9) ; PC8612.1 103.73,93.62 103.83,93.53 105.41,93.53 v1(105.64,93.75)
  IN1 w0.254: v1(105.64,93.75) 105.74,93.86 105.74,94.3 105.4,94.64 104.85,94.64 104.34,95.15 104.04,95.15 102.87,96.32 102.87,97.18 101.55,98.5 101.55,99.04 101.47,99.11 101.47,99.14 97.54,103.08 97.54,103.61 96.42,104.73 v1(96.42,105.9)
  BOTTOM w0.203: v1(96.42,105.9) 96.22,106.1 PJP8600.1
+1P2V_DUAL_BST:
  vias: v2(98.17,97.79)
+1P2V_DUAL_BST_RC: length 3.2
  TOP w0.432: 95.99,99.34 PC8601.2
  TOP w0.508: v2(94.62,97.92) 94.74,98.05 PR8601.2 95.56,98.92 95.99,99.34
+1P2V_DUAL_FB_VOUT_R_A:
  vias: v1(96.93,96.62) v1(97.54,96.62) v2(96.27,96.62)
+1P2V_DUAL_HG: length 23.7
  TOP w0.229: v1(98.15,98.45) 98.43,98.45 98.66,98.22 PU8600.17
  TOP w0.635: v2(78.61,105.18) 79.19,104.6 v4(79.2,104.6)
  IN1 w0.635: v4(79.2,104.6) 84.23,99.58 84.23,99.55 85.63,98.15 97.84,98.15 v1(98.15,98.45)
+1P2V_DUAL_HGR: length 0.9
  TOP w0.102: v2(83.08,105.97) v4(82.42,105.31)
+1P2V_DUAL_LG: length 23.2
  TOP w0.229: v1(98.93,99.37) 99.56,99.37 99.68,99.24 PU8600.15
  IN1 w0.635: v1(98.93,99.37) 98.93,99.72 98.73,99.93 85.5,99.93 80.09,105.34 v4(80.09,106.1)
  vias: v2(80.01,107.11)
+1P2V_DUAL_LGR: length 1
  TOP w0.102: v1(83.88,108.89) 84.48,108.3 v2(84.48,108.18)
+1P2V_DUAL_PHASE: length 23.2
  TOP w0.229: PU8600.16 98.82,98.62 98.5,98.94
  TOP w0.432: 98.5,98.94 98.1,99.34 PC8601.1 97.56,100 ; v1(84.31,103.56) 84.28,103.53 PR8605.2 PC8604.2
  TOP w0.635: 97.56,100 97.13,100.43 v2(94.89,100.43) 94.11,100.43 v1(93.19,101.35)
  IN3 w0.635: v1(93.19,101.35) 93.19,100.99 92.65,100.45 84.07,100.45 83.11,101.41 83.11,102.8 83.87,103.56 v1(84.31,103.56)
+1P2V_DUAL_VIN: length 37.6
  TOP w0.432: PR8602.1 105.07,98.53 105.28,98.74 105.28,99.57 105.51,99.8 105.51,100.69 103.47,102.73 103.47,103.52 v2(102.54,104.45) 99.74,107.25 97.88,107.25 97.03,106.4 v1(97.03,105.87)
  IN2 w0.508: v1(80.9,105.56) 80.9,103.91 84.3,100.51 93.22,100.51 97.03,104.32 v1(97.03,105.87)
+1P8V: length 188.6
  TOP w0.432: v1(13.16,22.61) 12.62,22.61 R3821.1 ; v4(93.26,25.88) 93.26,26.19 93.55,26.47 R2511.1
  IN1 w0.762: v4(88.54,22.56) 88.54,20.54 90.77,18.32 v4(92.2,18.32)
  IN2 w0.508: v4(20.14,15.45) 18.69,16.89 18.69,17.22 13.31,22.61 v1(13.16,22.61)
  IN2 w0.762: v4(30.98,71.45) 28.23,68.71 27.84,68.71 26.8,67.67 26.8,65.2 25.81,64.21 25.81,59.91 27.58,58.13 27.58,56.14 26.72,55.27 26.72,44.86 27.28,44.3 27.28,33.2 29.1,31.38 29.1,28.15 28.12,27.17 28.12,26.44 29.87,24.69 29.87,22.38 30.33,21.92 v4(30.33,21.8) ; v4(20.14,15.45) 26.52,15.45 35.81,6.15 46.38,6.15 48.84,3.69 92.15,3.69 93.64,5.18 v4(93.64,5.49)
  IN3 w0.762: v4(88.54,22.56) 89.41,22.56 89.86,23.01 89.86,23.8 90.21,24.15 90.52,24.46 90.54,24.46 90.54,24.46 91.49,24.46 91.49,24.46 91.51,24.46 92.73,24.46 93.39,25.12 93.39,25.76 v4(93.26,25.88)
  BOTTOM w0.762: v4(92.2,18.32) 92.2,17.17 93.55,15.83 93.55,15.36 94.79,14.11 94.79,13.02 94.21,12.43 94.21,7.25 93.64,6.68 v4(93.64,5.49) ; v4(30.33,21.8) 30.23,21.69 30.23,20.53 29.72,20.02 27.36,20.02 22.78,15.45 v4(20.14,15.45)
  vias: v2(31.27,73.84)
+1P8V_CPVDD: length 6.3
  TOP w0.432: R3821.2 v1(12.42,24.34)
  BOTTOM w0.229: U3800.20 16.44,25.16
  BOTTOM w0.432: 16.44,25.16 16.44,25.05 16.32,24.92 v2(16.31,24.92) 16.23,24.84 C3826.1 C3825.1 12.92,24.84 v1(12.42,24.34)
+1P8V_EMMC: length 48.3
  TOP w0.203: U2500.N4 U2500.P3
  TOP w0.229: 98.3,18.19 98.86,17.63 99.21,17.63 99.53,17.95 U2500.P5 ; U2500.M4 U2500.N4 ; v1(100.31,23.85) 100.31,24 U2500.C6 ; U2500.P3 98.53,18.5
  TOP w0.432: R2508.1 R2503.1 R2507.1 R2502.1 R2506.1 R2501.1 R2505.1 R2504.1 94.28,30.88 93.62,30.23 ; 97.89,14.84 97.89,16.23 97.61,16.51 97.61,17.35 96.6,18.37 96.6,19.54 95.95,20.18 v2(93.38,20.18) 93.17,20.4 91.9,20.4 91.77,20.53 91.77,21.06 v1(91.77,21.07) 91.29,21.55 R2514.2 90.97,22 90.79,22 90.6,22.19 R2513.1 ; 98.53,18.5 98.53,18.42 98.3,18.19 98.3,16.77 98.43,16.64 98.43,14.99 ; 95.02,25.4 94.82,25.61 R2511.2
  TOP w0.508: v1(96.18,24.54) 96.18,25 96.02,25.16 95.26,25.16 95.02,25.4 95.61,25.99 95.61,26.93 95.53,27 95.53,27.51 93.62,29.41 C2505.1 93.62,30.23
  IN3 w0.508: v1(91.77,21.07) 93.29,22.58 95.05,22.58 96.18,23.72 v1(96.18,24.54) 96.19,24.55 99.8,24.55 100.31,24.04 v1(100.31,23.85)
+1P8VSB: length 222.5
  TOP w0.254: v1(22.96,36.48) 23.36,36.08 24.44,36.08 24.56,35.96 R2336.1
  TOP w0.432: R1026.1 R1025.1 R1024.1 R1022.1 112.32,25.76 111.4,24.84 111.4,23.78 111.2,23.57 111.2,22.33 111.4,22.13 v1(111.4,21.19)
  TOP w0.762: v4(114.12,18.82) 114.12,18.75 112.62,17.25 111.55,17.25 110.9,16.59 110.9,15.75 v4(109.35,14.2) ; v4(82.73,24.95) 82.41,24.95 80.49,23.03 80.49,22.12 81.31,21.3 81.31,20.07 81.18,19.95 81.18,18.05 80.82,17.69 80.82,16.01 80.24,15.42 80.24,14.48 v2(82.73,11.99) 83.39,11.33 v4(83.46,11.33)
  IN1 w0.508: v4(114.12,18.82) 111.76,21.19 v1(111.4,21.19)
  IN1 w0.762: v4(104.25,106.55) 101.99,108.82 99.14,108.82 97.43,110.53 97.43,111.46 96.9,111.99 v4(96.04,111.99)
  IN2 w0.508: v1(23.85,57.58) 23.85,56.26 22.25,54.66 22.25,45.72 23.27,44.71 23.27,40.03 23.8,39.5 23.8,37.19 23.19,36.58 23.17,36.58 23.06,36.48 v1(22.96,36.48)
  IN2 w0.762: v4(83.46,11.33) 84.23,11.33 85.35,10.21 90.1,10.21 91.37,11.48 96.66,11.48 97.24,12.07 100.76,12.07 102.11,13.41 102.55,13.41 103,13.87 104.93,13.87 105.56,14.51 109.04,14.51 v4(109.35,14.2) ; v4(104.25,106.55) 102.32,106.55 93.69,97.92 83.49,97.92 81.61,99.8 78.59,99.8
  BOTTOM w0.432: v4(114.12,18.82) 113.26,17.96 R1614.1
  BOTTOM w0.508: v1(32.66,59.08) 32.4,59.34 26.67,59.34 24.92,57.58 v1(23.85,57.58)
  BOTTOM w0.762: v4(82.73,24.95) 81.38,26.29 81.38,27.26 75.72,32.92 75.72,75.77 81.1,81.15 81.1,95.03 77.72,98.4 77.72,99.04
  vias: v1(35.92,73.46) v1(36.5,73.28) v1(36.88,71.88) v1(37.06,73.59) v1(77.37,99.63) v1(77.98,99.63) v1(95.05,112.44) v1(95.28,111.86) v4(94.5,111.93) v4(94.74,111.09)
+1P8VSB_COMP_A: length 3.4
  TOP w0.254: PR8805.2 PC8811.1 107.34,113.74 107.34,112.52 v2(106.99,112.17)
+1P8VSB_EN_A: length 4.9
  TOP w0.102: v2(108.74,112.04) 108.64,112.14 108.64,113.29 v1(108.36,113.57)
  BOTTOM w0.254: v1(108.36,113.57) PR8811.2 PC8808.1 107.47,113.85 107.29,113.67 PU8801.5
+1P8VSB_FB1_A: length 14.6
  TOP w0.254: v1(100.18,110.89) 101.16,109.9 v2(108.84,109.9) 109.97,109.9 111.25,111.18 PR8807.2 PC8810.2
  BOTTOM w0.203: v1(100.18,110.89) PJP8801.1
+1P8VSB_FB_A: length 6.8
  TOP w0.254: v2(110.21,111.08) 110.39,111.25 110.39,112.98 ; 110.39,112.98 110.39,113.62 v1(110.36,113.64) ; 110.39,112.98 109.86,112.98 109.7,113.13 PR8805.1 PR8810.1
  BOTTOM w0.254: v1(110.36,113.64) 110.36,113.08 110.09,112.81 PU8801.6
+1P8VSB_OUT:
  vias: v2(101.07,111.71)
+1P8VSB_PWRGD: length 227.2
  TOP w0.102: v2(105.21,112.19) 106.05,113.03 v1(106.55,113.03) ; R2346.1 27.64,48.85 27.03,48.85 25.6,47.42 24.64,47.42 21.74,44.53 v1(21.74,44.43)
  TOP w0.432: R1801.1 63.09,7.52 62.75,7.18 62.25,7.18 61.77,7.65 v1(61.77,7.77)
  IN1 w0.102: v1(43.82,96.04) 44.42,96.65 46.36,96.65 47.27,97.56 47.27,99.34 50.1,102.17 51.67,102.17 54.61,105.11 57.3,105.11 57.5,105.31 60.45,108.26 67.13,108.26 68.91,110.04 71.58,110.04 72.19,110.64 80.85,110.64 82.46,112.25 92.69,112.25 94.36,113.92 105.66,113.92 v1(106.55,113.03)
  IN1 w0.508: v1(39.14,7.85) 39.82,7.17 45.25,7.17 45.82,7.74 46.9,7.74 46.92,7.71 51.14,7.71 51.36,7.5 58.19,7.5 58.39,7.7 61.7,7.7 v1(61.77,7.77)
  IN3 w0.102: v1(43.82,96.04) 40.03,92.26 40.03,89.21 38.14,87.32 32.6,87.32 31.89,86.6 29.47,86.6 26.95,84.08 25.67,84.08 25.04,83.45 25.04,78.54 17.63,71.13 17.63,57.65 18.75,56.54 18.75,54.28 19.61,53.42 19.61,46.56 v1(21.74,44.43)
  IN3 w0.508: v1(21.74,44.43) 21.74,43.33 24.26,40.82 24.26,28.7 24.05,28.5 24.05,25.99 25.3,24.74 25.3,20.02 25.77,19.55 30.68,19.55 39.14,11.08 v1(39.14,7.85)
  BOTTOM w0.102: v1(106.55,113.03) 106.55,112.65 106.89,112.31 PU8801.4
+1P8VSB_SW:
  vias: v2(105.51,111.79)
+1P8VSB_VIN:
  vias: v2(110.24,109.71)
+1P8VSUS_ORG: length 96.4
  TOP w0.432: R1208.1 90.27,27.94 v1(89.89,27.56) ; v1(107.8,24.9) 107.8,22.86 v1(107.02,22.09) ; v3(116.69,32.51) 116.69,31.9 v2(116.62,31.84) 116.38,31.6 C1612.1
  IN1 w0.381: v3(111.44,40.48) 112.01,39.9 112.01,38.99 v3(113.28,37.72)
  IN1 w0.508: v1(111.7,18.82) 111.84,18.96 111.84,19.89 111.48,20.25 110.59,20.25 109.96,20.88 108.23,20.88 v1(107.02,22.09) 106.05,23.07 105.16,23.07 103.96,24.26 v1(103.96,25.76)
  IN2 w0.508: v1(103.96,25.76) 103.96,25.51 103.58,25.12 101.67,25.12 100.91,25.88 100.91,26.26 100.56,26.62 98.63,26.62 97.46,25.45 95.81,25.45 v1(95,26.27)
  IN3 w0.305: v3(116.69,32.51) 116.55,32.37 116.55,27.3 114.45,25.21 114.45,24.43 113.82,23.8 113.82,23.78 112.01,21.97 110.46,21.97 109.91,21.41 107.7,21.41 v1(107.02,22.09)
  IN3 w0.381: v1(107.8,24.9) 107.8,24.37 108.44,23.73 108.89,23.73 109.11,23.95 110.51,23.95 111.24,24.68 111.24,25.03 112.05,25.84 112.05,26.4 111.53,26.92 111.53,28.14 111.9,28.51 111.9,33.27 112.51,33.87 112.51,37.5 112.73,37.72 113.28,37.72 ; v3(114.76,41.15) 113.75,40.14 113.16,40.14 112.8,39.79 112.8,38.21 113.28,37.72 ; v3(113.28,37.72) 113.28,37.72
  IN3 w0.508: v1(99.72,31.5) 99.72,31.02 99.5,30.8 96.68,30.8 95.88,30 94.28,30 92.37,28.09 90.42,28.09 v1(89.89,27.56) 90.45,27 93.7,27 94,26.7 94.56,26.7 v1(95,26.27)
  BOTTOM w0.254: v3(114.76,41.15) 114.65,41.15 114.47,41.32 U0400.AF16 ; U0400.AA1 116.69,32.84 v3(116.69,32.51) ; v3(111.44,40.48) U0400.AK15
  BOTTOM w0.356: R1107.1 99.72,31.5 v1(99.72,31.5)
  BOTTOM w0.432: v1(111.7,18.82) R1614.2 112.47,19.15 112.32,19.31 C1628.1
+2P5_VPP_COMP_A: length 1.7
  TOP w0.432: PR8804.2 PC8802.1 v2(39.68,15.76)
+2P5_VPP_FB1_A: length 10
  TOP w0.432: v2(49.95,18.96) 49.16,18.96 v1(49.1,19.03) 43.23,19.03 42.63,18.43 PC8803.2 PR8803.2
+2P5_VPP_FB_A: length 9.2
  TOP w0.432: 41.45,17.57 PC8803.1 ; PC8803.1 41.2,17.2 41.3,17.1 PR8804.1 41.78,16.72 v1(42.01,16.94) ; PC8803.1 PR8803.1 PR8802.1
  TOP w0.508: 41.45,17.57 42.81,17.57 v2(43.43,18.19)
  BOTTOM w0.254: 41.99,15.9 41.99,15.8 43.14,14.65 PU8800.6
  BOTTOM w0.432: 41.99,15.9 41.99,16.92 v1(42.01,16.94)
+2P5_VPP_SW: length 3.7
  TOP w0.508: v1(46.91,16.46) v2(46.91,17.1)
  BOTTOM w0.508: PL8800.1 45.63,18.4 46.91,17.12 v1(46.91,16.46)
+2P5_VPP_VIN: length 9.5
  TOP w0.508: v2(42.32,19.69) 42.32,20.35 41.88,20.78 PR8801.2 41.45,19.97 PC8801.1 v1(41.17,19.03)
  BOTTOM w0.254: PU8800.10 43.53,17.07
  BOTTOM w0.508: v1(41.17,19.03) 41.12,18.98 41.12,18.04 41.25,17.91 43.08,17.91 43.44,18.27 PC8800.1 44.04,17.58 43.53,17.07
+2P5V_VPP: length 42.7
  TOP w0.432: v1(55.63,21.29) 54.86,22.05 v2(54.86,23.29) 54.86,25.19 55.85,26.18 C2232.1 C2233.1 57.58,26.72 57.48,26.82 57.48,26.82 57.15,27.16 C2101.1 ; C2001.1 69.22,25.58 C2242.1 C2243.1 70.21,24.69 70.78,25.26 71.33,25.26 71.86,24.74 v1(71.86,24.72)
  TOP w0.508: v1(71.27,21.71) 71.27,23.27 71.86,23.85 v1(71.86,24.72) ; C2101.1 56.79,27.26 v1(56.3,26.76)
  IN3 w0.508: v1(55.63,21.29) 55.66,21.29 55.68,21.31 62.11,21.31 62.54,20.88 69.65,20.88 70.49,21.72 71.25,21.72 71.27,21.69 v1(71.27,21.71)
  BOTTOM w0.508: v1(55.63,21.29) 55.63,21.26 54.58,20.21 54.58,18.32 53.48,17.21 53.48,16.53 52.72,15.76 PJP8802.1
+2P5V_VPP_EN_A: length 5.9
  TOP w0.432: v1(46.91,14.33) 46.05,14.33 45.52,13.79 PC8814.1 45.52,13.08 45.85,12.75 PR8812.2 PR8813.2 45.57,11.97 v2(45.49,12.04)
  BOTTOM w0.254: PU8800.5 46.59,14.65 v1(46.91,14.33)
+2P5V_VPP_PWRGD: length 188.8
  TOP w0.254: v1(103.06,89.51) 103.06,89.91 PR8616.1 102.17,90.81 v2(101.93,90.81)
  TOP w0.432: PR8814.1 42.98,14.76 ; v1(68.99,9.11) 68.99,9.58 68.81,9.76 R1806.2 68.81,11.79 68.3,12.3 68.3,16.16 68.1,16.36 68.1,20.25 v1(64.62,23.73)
  TOP w0.508: v1(47.28,15.15) 47.18,15.04 46.33,15.04 46.08,15.29 43.51,15.29 42.98,14.76
  IN1 w0.254: v1(64.62,23.73) 64.62,23.83 64.24,24.21 60.63,24.21 60,24.84 58.68,24.84 57.31,26.22 56.11,26.22 54.84,27.49 52.81,27.49 52.38,27.92 52.38,28.32 53.24,29.18 53.24,31.36 51.02,33.58 50.55,33.58 50.09,34.05 50.09,34.44 49.89,34.65 49.89,49.56 46.63,52.81 46.63,54.92 46.69,54.97 46.69,62.92 48.35,64.58 52.31,64.58 54.79,67.06 56.16,67.06 59.64,70.54 59.64,90.35 64.98,95.68 67.49,95.68 68.28,94.9 78.02,94.9 80.91,92 90.22,92 91.57,90.66 102.01,90.66 103.06,89.6 v1(103.06,89.51)
  IN3 w0.508: v1(68.99,9.11) 68.31,8.44 63.17,8.44 62.93,8.68 61.41,8.68 61.06,8.33 54.33,8.33 54.13,8.54 51.56,8.54 46.3,13.8 46.3,14.58 46.87,15.15 v1(47.28,15.15)
  BOTTOM w0.254: v1(47.28,15.15) 46.84,15.15 46.84,15.15 PU8800.4
+3P3V: length 845
  TOP w0.305: 86.25,7.65 J5300.1
  TOP w0.356: v1(29.36,71.35) 29.24,71.22 R2913.2 29.44,70.16 Q2901.5 29.44,68.46 29.06,68.07 29.06,67.44 29.44,67.06 Q2901.2 29.44,64.85 29.16,64.57 R2901.1 ; R2600.1 28.36,71.88 27.36,70.88 27.36,68.28 26.64,67.57 Q2900.5 Q2900.2 26.64,64.04 26.44,63.83 R2900.1
  TOP w0.432: C2103.1 C2105.1 56.59,30.38 56.39,30.18 55.35,30.18 54.85,29.67 54.45,29.67 53.52,28.73 53.52,28.68 52.96,28.12 v1(52.86,28.12) ; v1(38.64,63.34) 37.92,64.06 37.92,64.7 R3901.1 ; R5725.1 23.8,86.77 v1(23.41,87.16) ; R1919.1 74.88,14.94 v1(74.52,14.58) 73.78,14.58 73.05,13.85 73.05,13.79 71.47,12.21 71.09,12.21 70.56,11.69 R1804.1 ; v1(103.35,25.76) 101.99,25.76 101.54,26.21 101.54,27.21 102.62,28.3 104.14,28.3 104.7,28.86 104.7,30 ; 157.73,21.23 v1(157.72,21.23) ; 157.73,21.23 157.73,20.3 158.62,19.41 v1(158.62,17.99) ; 157.73,21.23 157.73,21.8 155.87,23.66 155.87,26.08 155.44,26.51 153.78,26.51 ; v1(194.31,69.37) 194.31,69.75 193.59,70.47 193.1,70.47 192.89,70.69 PR9809.1 ; R1004.1 R1002.1 104.7,30 ; R1921.1 76.81,13.97 v1(76.81,13.32) ; v1(125.59,27.35) 126.01,26.93 R0414.1 ; 104.7,30 R1010.1 R1003.1 106.5,28.73 106.96,28.27 106.96,27.38 C2003.1 107.85,26.31 107.85,26.31 107.85,25.83 107.85,25.83 C2004.1 107.58,25.56 107.49,25.47 106.32,25.47 106.01,25.16 106.01,23.06 106.19,22.88 106.19,21.91 106.81,21.29 106.81,17.92 105.8,16.92 105.8,12.1 v1(106.32,11.58) ; v1(67.82,24.51) 67.82,25.14 69.11,26.43 69.11,26.45 69.3,26.63 69.32,26.63 69.61,26.93 C2012.1 ; v1(29.36,71.35) 28.83,71.88 R2600.1
  TOP w0.457: R1205.1 139.78,32.18 139.34,31.75 139.04,31.75 137.09,29.8 137.09,28.53 136.45,27.89 135.18,27.89 134.67,27.38 v1(134.67,24.69)
  TOP w0.508: v1(85.9,23.37) 85.9,22.42 87.17,21.15 87.17,20.88 89.81,18.24 v1(89.81,16.03) 89.81,14.04 87.89,12.12 87.13,12.12 86.67,11.66 v1(86.67,11.2) 86.67,10.95 85.73,10.01 85.73,8.18 86.25,7.65 ; v1(152.36,24.67) 152.36,25.66 ; L3800.1 19.86,22.06 19.86,19.06 20.27,18.65 v1(20.27,16.56) ; v1(57.98,13.55) 57.98,14.31 57.17,15.13 57.17,18.27 51.33,24.1 C2104.1 51.33,25.54 v1(50.86,26.01)
  IN1 w0.432: v1(86.67,11.2) 86.67,10.11 86.17,9.61 86.17,7.78 84.56,6.16 68.69,6.16 66.32,8.54 63.9,8.54 63.5,8.94 v1(63.5,9.17)
  IN1 w0.508: v1(205.97,87.71) 206.45,88.19 207.09,88.19 210.11,85.17 v1(210.11,68.25) ; v1(89.81,16.03) 81,16.03 79.07,14.1 77.59,14.1 v1(76.81,13.32) 75.79,13.32 v1(74.52,14.58) ; v1(52.86,28.12) 54.89,28.12 55.53,27.49 58.55,27.49 60.38,25.66 61.62,25.66 62.59,24.69 64.54,24.69 65.74,23.5 66.8,23.5 v1(67.82,24.51) ; v1(134.67,24.69) 134.67,24.95 133.58,26.04 132.99,26.04 132.97,26.06 132.33,26.06 131.79,25.53 129.79,25.53 127.44,27.88 126.12,27.88 v1(125.59,27.35) ; v1(111.26,12.65) 110.2,11.58 v1(106.32,11.58) 104.91,11.58 104.41,11.09 96.72,11.09 v1(94.98,9.35) 93.31,11.03 91.1,11.03 90.29,11.84 86.97,11.84 86.67,11.53 v1(86.67,11.2)
  IN1 w0.762: v4(196.44,63.1) 196.57,63.22 197.43,63.22 198.02,63.81 201.43,63.81 201.79,63.45 204.28,63.45 v4(206.1,65.27) ; v4(141.86,79.91) 141.94,79.83 141.94,78.79 143.71,77.02 144.75,77.02 145.26,76.51 147.7,76.51 147.89,76.7 148.97,76.7 151.31,74.35 152.22,74.35 153.16,73.41 157.02,73.41 160.12,70.31 161.57,70.31 162.56,69.32 164.8,69.32 v4(165.23,68.89) ; v1(210.11,67.31) 209.42,66.63 209.42,61.27 206.68,58.53 206.68,54.86 205.88,54.06 205.88,52.46 206.45,51.89 206.45,50.77 206.96,50.27 209.75,50.27 212.73,47.29 212.73,43.93 v1(213.29,43.37) v1(213.9,42.76)
  IN2 w0.508: v1(38.07,88.14) 38.56,87.65 38.56,83.62 37.72,82.78 37.72,81.94 36.27,80.5 36.27,78.34 40.08,74.53 40.08,71.25 40.95,70.38 40.95,67.29 39.45,65.79 39.45,64.15 v1(38.64,63.34) 38.64,57.71 40.31,56.04 40.31,53.32 v1(38.89,51.89) ; v1(52.86,28.12) 52.62,28.12 50.86,26.36 v1(50.86,26.01) ; v1(63.5,9.17) 62.64,9.17 58.26,13.55 v1(57.98,13.55) ; v1(134.67,24.69) 134.67,24.74 134.8,24.87 135.33,24.87 135.71,24.49 139.29,24.49 140.54,25.73 151.3,25.73 v1(152.36,24.67) ; v1(31.98,87.45) 31.98,85.28 30.73,84.03 30.73,75.06 28.93,73.26 28.93,71.78 v1(29.36,71.35) ; v1(194.31,69.37) 195.1,70.16 195.71,70.16 196.11,69.75 196.11,68.3 195.35,67.54 193.6,67.54 192.66,66.6 192.66,64.26 192.89,64.04 v1(192.89,62.66) ; v1(103.35,25.76) 101.93,25.76 101.55,26.14 101.55,26.65 101.5,26.7 101.5,27.49 102.18,28.17 102.18,29.14 v1(101.89,29.43) 101.46,29.43 100.7,28.67 99.06,28.67 98.04,27.65 v1(98.04,27.56)
  IN2 w0.762: v1(192.89,62.66) 192.21,62.66 191.14,61.6 189.22,61.6 188.3,62.51 180.01,62.51 177.8,64.72 177.8,65.31 176.26,66.85 174.55,66.85 173.21,68.18 169.9,68.18 168.82,67.11 166.79,67.11 166.09,67.81 166.09,68.02 v4(165.23,68.89) ; 158.79,19.42 182.36,19.42 182.37,19.41 ; v1(118.19,91.72) 118.19,91.62 117.91,91.34 117.91,90.68 118.87,89.72 125.88,89.72 126.59,89 126.59,88.71 127.47,87.84 134.62,87.84 136.12,86.34 136.25,86.34 141.55,81.03 141.55,80.22 v4(141.86,79.91)
  IN2 w0.889: 55.75,99.29 56.46,98.58 58.14,98.58 58.32,98.76 81.3,98.76 83.1,96.97 94.08,96.97 102.15,105.03 103.31,105.03 v1(103.86,104.48) 103.41,104.03 103.41,102.48 104.93,100.97 105.25,100.97 105.73,100.49 105.73,98.71 106.5,97.94 109.82,97.94 109.97,98.08 111.85,98.08 113.41,96.52 113.41,95.21 116.48,92.14 117.77,92.14 v1(118.19,91.72)
  IN2 w1.016: v1(213.9,42.76) 215.64,41.02 215.64,30.17 214.43,28.96 214.43,27.18
  IN3 w0.508: v1(152.36,24.67) 154.81,24.67 156.97,22.51 156.97,22.51 157.72,21.76 v1(157.72,21.23) ; v1(31.98,87.45) 33.4,88.88 37.33,88.88 v1(38.07,88.14) 38.07,91.16 46.87,99.95 48.59,99.95 49.29,99.25 52.64,99.25 53.6,100.21 54.36,100.21 v1(54.93,99.64) ; v1(38.89,51.89) 37.91,50.92 37.91,41.49 41.38,38.03 v1(41.38,37.32) 40.11,36.05 40.11,32.14 40.49,31.75 41.43,31.75 42.01,31.17 42.01,30.26 44.02,28.25 44.53,28.25 45.95,26.82 48.97,26.82 49.78,26.01 v1(50.86,26.01) ; v1(125.59,27.35) 125.2,26.96 125.2,25.86 124.99,25.66 124.99,22.66 126.49,21.16 126.49,15.01 125.65,14.18 122.63,14.18 121.64,13.19 114.55,13.19 113.97,12.6 111.32,12.6 v1(111.26,12.65) ; v1(85.9,23.37) 87.15,24.62 89,24.62 v1(89.79,25.4)
  IN3 w0.762: v1(192.89,62.66) 194.01,63.78 195.76,63.78 v4(196.44,63.1)
  BOTTOM w0.102: v2(204.5,86.82) 204.53,86.85 Q3602.1
  BOTTOM w0.305: CON2100.255 56.35,27.82 55.64,27.11 55.21,27.11 ; v1(67.82,24.51) 67.82,25.59 69,26.77 69.26,26.77 69.31,26.82 CON2000.255 ; U5100.5 87.71,17.55 ; v1(50.86,26.01) 50.86,26.27 50.56,26.57 CON2100.260
  BOTTOM w0.381: Q3602.1 205.45,88.23 v1(205.97,87.71) R3602.1 205.46,86.9 204.81,86.25 204.25,86.25 203.23,87.28 R3601.1
  BOTTOM w0.432: R3110.1 R3109.1 155.92,18.39 156.4,18.86 158.23,18.86 158.62,18.47 v1(158.62,17.99) ; 98.79,109.52 C5300.2 R0503.2 ; v1(52.86,28.12) 54.2,28.12 55.21,27.11 ; R1409.1 125.85,27.79 125.8,27.74 125.8,27.56 v1(125.59,27.35) ; PR9804.2 PR9803.2 192.56,62.99 v1(192.89,62.66) ; v1(94.98,9.35) 94.98,12.08 R1518.1 ; R1222.1 102.9,24.87 103.35,25.33 v1(103.35,25.76) ; v1(101.89,29.43) 101.87,29.43 101.6,29.7 R1500.1 ; PR9802.2 196.16,63.6 196.44,63.32 v4(196.44,63.1) ; v1(118.19,91.72) 118.77,92.31 118.77,93.45 118.59,93.62 118.59,93.96 PR9415.1
  BOTTOM w0.508: v1(103.86,104.48) 102.98,105.36 102.98,107.88 101.35,109.52 98.79,109.52 ; v1(89.81,16.03) 89.23,16.03 87.71,17.55 ; v1(38.07,88.14) v2(38.07,87.48) ; v1(23.41,87.16) 24.08,87.84 27.41,87.84 27.66,87.58 29.62,87.58 29.68,87.65 31.79,87.65 v1(31.98,87.45) ; v1(20.27,16.56) 22.16,16.56 24.71,19.12 24.71,20.35 28.14,23.78 29.38,23.78 30.47,24.87 30.96,24.87 32.62,26.53 32.62,27.03 31.1,28.55 31.08,28.55 30.16,29.48 30.16,31.58 35.38,36.81 40.86,36.81 v1(41.38,37.32)
  BOTTOM w0.762: v4(206.1,65.27) 208.06,65.27 v1(210.11,67.31) v1(210.11,68.25)
  vias: v1(55.54,99.64) v1(185.37,19.28) v1(204.57,43.31) v1(205.11,43.61) v2(55.42,98.96) v4(182.4,18.6) v4(183.29,18.6) v4(184.18,18.6) v4(185.06,18.6) v4(213.36,28.32) v4(213.36,27.43) v4(213.39,26.55) v4(213.39,25.63) v4(213.39,24.21)
