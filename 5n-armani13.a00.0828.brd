# Allegro board 5n-armani13.a00.0828.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DP_DDI2_DATA1: length 152.2
  TOP w0.102: v5(34.04,81.23) 33.93,81.13 C5711.1
  IN1 w0.109: v5(34.04,81.23) 33.99,81.28 32.82,81.28 32.26,81.84 30.76,81.84 30.28,82.32 30.28,84.94 35.03,89.69 41.03,89.69 43.68,92.34 45.93,92.34 51.75,98.16 55.63,98.16 58.79,101.32 58.79,102.2 61.18,104.59 67,104.59 68.09,104.59 68.51,105 71.67,105 74.23,102.45 78.84,102.45 84.66,96.63 94.8,96.63 95.24,96.19 100.63,96.19 101.25,95.57 101.25,94.73 102.08,93.9 103.84,93.9 105.11,92.64 105.89,92.64 112.27,86.26 113.13,86.26 115.67,83.72 125.65,83.72 126.96,82.41 126.96,71.09 127.11,70.94 127.11,65.45 128.14,64.42 128.63,64.42 128.96,64.75 129.97,64.75 130.56,64.16 v1(130.56,62.31)
  BOTTOM w0.076: U0400.D52 125.72,62.51 126.38,62.51 126.53,62.59 126.76,62.59 126.88,62.53 127.05,62.53 127.16,62.58 127.52,62.58 127.62,62.47 128.96,62.47 129,62.51 129.05,62.51
  BOTTOM w0.102: v1(130.56,62.31) 130.48,62.39 130.48,62.6 130.12,62.96 129.55,62.96 129.1,62.51 129.05,62.51
DP_DDI2_DATA1#: length 152.2
  TOP w0.102: v1(33.99,81.97) 33.98,81.97 33.6,81.59 33.27,81.59 33.22,81.64 C5712.1
  IN1 w0.109: v1(33.99,81.97) 33.76,82.2 33.48,82.2 33.35,82.07 33.35,81.62 33.22,81.49 32.91,81.49 32.35,82.05 30.85,82.05 30.49,82.41 30.49,84.85 35.11,89.48 41.11,89.48 43.76,92.13 46.02,92.13 51.84,97.94 55.72,97.94 59,101.23 59,102.11 61.27,104.38 66.91,104.38 68.18,104.38 68.6,104.79 71.59,104.79 74.14,102.24 78.75,102.24 84.57,96.42 94.71,96.42 95.15,95.98 100.54,95.98 101.04,95.48 101.04,94.64 101.99,93.69 103.75,93.69 105.02,92.43 105.81,92.43 112.19,86.05 113.04,86.05 115.58,83.51 125.56,83.51 126.75,82.32 126.75,71 126.9,70.86 126.9,65.36 128.06,64.21 128.72,64.21 129.05,64.54 129.88,64.54 130.35,64.07 130.35,62.99 130.22,62.87 129.72,62.87 129.59,62.74 129.59,62.56 129.85,62.31 v1(129.95,62.31)
  BOTTOM w0.076: U0400.C52 126.07,62.07 126.25,62.07 126.31,62.13 126.31,62.26 126.39,62.34 126.52,62.4 126.57,62.42 126.72,62.42 126.84,62.36 127.08,62.36 127.19,62.41 127.19,62.41 127.45,62.41 127.55,62.31 129.05,62.31
  BOTTOM w0.102: 129.05,62.31 129.18,62.31 129.63,62.76 130.03,62.76 130.16,62.63 130.16,62.44 130.04,62.31 v1(129.95,62.31)
DP_DDI2_DATA2: length 144.6
  TOP w0.102: v5(32.23,82.98) 31.93,82.98 31.74,82.79 31.61,82.79 C5713.1
  IN1 w0.109: v5(32.23,82.98) 31.73,82.98 31.66,82.91 31.21,82.91 30.9,83.22 30.9,84.67 35.29,89.07 41.44,89.07 44.03,91.65 46.15,91.65 51.77,97.26 56.26,97.26 58.34,99.33 58.34,99.91 59.64,101.21 59.64,101.88 61.58,103.81 68.73,103.81 69.58,102.96 72.2,102.96 73.35,101.81 78.59,101.81 84.4,96.01 94.54,96.01 94.98,95.57 97.8,95.57 98.63,94.73 100.36,94.73 101.87,93.23 103.6,93.23 105,91.82 105.72,91.82 112.03,85.51 112.74,85.51 115.16,83.08 125.4,83.08 126.34,82.14 126.34,70.74 126.47,70.61 126.47,67.57 126.17,67.28 126.17,65.44 127.31,64.3 127.31,62.72 127.6,62.44 128.94,62.44 129.11,62.44 129.44,62.12 129.44,61.92 v1(129.94,61.42)
  BOTTOM w0.076: U0400.B50 126.91,61.28 127.57,61.28 127.73,61.12 128.79,61.12 128.92,61.25 128.92,61.6 129.09,61.78
  BOTTOM w0.102: v1(129.94,61.42) 129.52,61.84 129.15,61.84 129.09,61.78
DP_DDI2_DATA2#: length 144.5
  TOP w0.102: v1(32.13,83.67) 32.04,83.76 31.84,83.76 31.75,83.67 31.75,83.12 31.62,83 31.46,83 31.34,83.11 C5714.1
  IN1 w0.109: v1(32.13,83.67) 32.08,83.72 31.83,83.72 31.7,83.59 31.7,83.25 31.57,83.12 31.3,83.12 31.11,83.31 31.11,84.59 35.38,88.85 41.53,88.85 44.11,91.43 46.24,91.43 51.85,97.05 56.35,97.05 58.55,99.25 58.55,99.82 59.85,101.13 59.85,101.79 61.66,103.6 68.64,103.6 69.49,102.75 72.12,102.75 73.26,101.6 78.5,101.6 84.31,95.79 94.45,95.79 94.89,95.36 97.71,95.36 98.55,94.52 100.27,94.52 101.78,93.02 103.51,93.02 104.92,91.61 105.63,91.61 111.94,85.3 112.65,85.3 115.08,82.87 125.31,82.87 126.13,82.06 126.13,70.66 126.26,70.53 126.26,67.66 125.96,67.36 125.96,65.36 127.1,64.21 127.1,62.64 127.51,62.23 129.02,62.23 129.23,62.03 129.23,61.92 129.11,61.8 129.01,61.8 128.88,61.67 128.88,61.34 129.01,61.21 129.19,61.21 129.32,61.34 v1(129.32,61.43)
  BOTTOM w0.076: U0400.A50 127.38,61.09 127.53,61.09 127.66,60.96 128.86,60.96 128.96,61.06 129.15,61.06 129.18,61.04
  BOTTOM w0.102: v1(129.32,61.43) 129.33,61.43 129.58,61.17 129.58,60.96 129.46,60.84 129.26,60.84 129.21,60.89 129.21,61.01 129.18,61.04
DP_DDI2_DATA3: length 134.2
  TOP w0.102: C5715.1 34.01,84.25 34.24,84.48 34.24,85.27 v1(34.42,85.45)
  IN1 w0.109: v3(127.88,61.49) 128.11,61.26 128.11,61.07 127.98,60.94 127.15,60.94 126.62,61.48 126.62,64.11 125.53,65.19 125.53,67.1 125.33,67.3 125.33,68.36 125.61,68.64 125.61,69.21 125.25,69.57 125.25,71.4 125.69,71.85 125.69,81.87 125.19,82.37 114.86,82.37 112.49,84.74 111.9,84.74 106.26,90.38 105.5,90.38 103.28,92.6 101.6,92.6 100.12,94.08 95.52,94.08 94.23,95.38 84.14,95.38 78.37,101.15 62.03,101.15 61.79,100.92 61.34,100.92 59.84,99.41 59.3,99.41 56.48,96.6 52.07,96.6 48.98,93.51 46.35,90.88 46.27,90.88 46.18,90.88 44.15,90.88 41.41,88.14 41.32,88.14 39.35,88.14 38.55,87.34 34.7,87.34 33.78,86.41 33.78,86.08 v1(34.42,85.45)
  BOTTOM w0.076: U0400.C51 126.45,61.7 126.72,61.7 126.91,61.51 127.86,61.51 v3(127.88,61.49)
DP_DDI2_DATA3#: length 134.2
  TOP w0.102: v5(34.24,86.24) 33.73,85.73 C5716.1
  IN1 w0.109: v3(128.49,61.49) 128.32,61.32 128.32,60.98 128.07,60.73 127.07,60.73 126.41,61.39 126.41,64.02 125.32,65.1 125.32,67.01 125.12,67.21 125.12,68.44 125.4,68.73 125.4,69.12 125.04,69.49 125.04,71.49 125.48,71.93 125.48,81.79 125.1,82.16 114.77,82.16 112.4,84.53 111.81,84.53 106.17,90.17 105.42,90.17 103.2,92.39 101.51,92.39 100.03,93.87 95.44,93.87 94.14,95.17 84.05,95.17 78.28,100.94 62.12,100.94 61.88,100.71 61.43,100.71 59.92,99.2 59.38,99.2 56.57,96.39 52.16,96.39 49.19,93.43 46.44,90.67 46.18,90.67 44.24,90.67 41.5,87.93 41.23,87.93 39.44,87.93 38.63,87.12 34.79,87.12 34.24,86.57 v5(34.24,86.24)
  BOTTOM w0.076: U0400.D51 125.91,61.57 126.2,61.86 126.79,61.86 126.98,61.67 127.54,61.67 127.73,61.86 128.12,61.86 v3(128.49,61.49)
EC_AGND: length 9.2
  TOP w0.203: R2328.2 44.39,35.95 v1(44.1,35.95) 43.62,35.95 43.56,35.9 U2300.112
  TOP w0.254: C2317.2 44.15,33.23 43.94,33.43 v1(43.94,33.99)
  TOP w0.305: C2321.2 46.08,36.58 v1(46.13,36.53)
  BOTTOM w0.381: v1(43.94,33.99) 43.05,34.88 43.05,35.41 43.56,35.92 43.99,35.92 44.02,35.95 v1(44.1,35.95) 44.57,36.43 v2(44.68,36.43) 44.78,36.53 v1(46.13,36.53)
EC_MUTE#: length 47.6
  TOP w0.152: R2302.2 45.89,39.12 v1(46.04,39.27)
  IN3 w0.152: v1(44.86,50.37) 44.86,50.37 45.11,50.12 45.11,48.12 45.52,47.71 45.52,39.8 v1(46.04,39.27)
  BOTTOM w0.152: D3807.1 23.03,38.32 24.02,39.31 24.02,41.42 25.93,43.33 25.93,47.45 31.12,52.63 39.47,52.63 v2(40.5,51.6) 41.73,50.37 v1(44.86,50.37)
EC_MUTE#_R: length 21.4
  IN3 w0.152: v1(17.98,41.26) 17.98,39.83 19.86,37.95 21.03,37.95 22.02,36.96 22.02,34.27 22.4,33.89 v1(23.04,33.89)
  BOTTOM w0.152: v1(23.04,33.89) 22.92,33.77 21.52,33.77 21.39,33.64 C3833.1 R3811.2 20.63,31.56 20.63,31.17 20.5,31.04 U3800.2 ; v1(17.98,41.26) 18.65,40.59 20.19,40.59 20.35,40.74 v2(20.96,40.74) 21.03,40.74 21.98,39.8 D3807.3
EDCA0_0: length 33.1
  TOP w0.127: v1(188.58,103.8) U6801.R13
  IN3 w0.122: v1(168.79,102.45) 168.79,104.27 169.07,104.55 169.07,105.69 170.36,106.98 175.82,106.98 177.94,104.86 181.22,104.86 182.06,105.7 185.47,105.7 185.65,105.52 185.65,105.13 185.55,105.03 185.36,105.03 185.24,104.9 185.24,104.67 186.5,103.4 187.95,103.4 187.98,103.37 188.47,103.37 188.58,103.48 v1(188.58,103.8)
  BOTTOM w0.102: 168.71,101.42 168.71,101.04 169.04,100.71 169.28,100.71 169.53,100.47 169.53,100.11 169.3,99.89 169.3,98.35 U6000.H28
  BOTTOM w0.127: 168.71,101.42 168.49,101.64 168.49,101.89 168.79,102.19 v1(168.79,102.45)
EDCA0_1: length 32.9
  IN1 w0.122: v1(175.14,98.47) 175.14,98.94 178.18,101.98 178.52,101.98 178.64,101.86 178.64,101.62 178.77,101.5 179,101.5 179.13,101.63 179.13,102.27 179.29,102.44 181.79,102.44 181.92,102.56 181.92,103.05 182.04,103.18 182.35,103.18 182.47,103.05 182.47,102.92 182.6,102.8 182.91,102.8 183.03,102.92 183.03,103.36 183.21,103.53 184.17,103.53 184.29,103.65 184.29,104.06 184.38,104.14 184.69,104.14 184.78,104.06 184.78,103.5 184.91,103.38 185.14,103.38 185.27,103.5 185.27,103.92 185.39,104.04 185.63,104.04 185.76,103.92 185.76,103.65 185.88,103.53 187.46,103.53 187.59,103.41 187.6,103.41 187.61,103.4 187.95,103.4 187.98,103.38 189.99,103.38 190.01,103.4 190.75,103.4 190.79,103.36 191.14,103.36 191.43,103.64 195.54,103.64 196.41,104.51 196.84,104.51 197.38,103.97 v1(197.38,103.8)
  BOTTOM w0.102: v1(175.14,98.47) 175.14,98.46 174.4,97.72 174.1,97.72 173.93,97.55 173.36,97.55 173.03,97.22 U6000.C27
  BOTTOM w0.127: v1(197.38,103.8) U6800.C2
EDCA0_2: length 32.9
  IN3 w0.122: v1(188.57,94.19) 188.32,94.44 188.32,94.66 188.49,94.82 188.89,94.82 189.1,94.61 189.1,94.31 189.23,94.19 189.61,94.19 189.74,94.31 189.74,94.47 189.86,94.6 190.03,94.6 190.03,94.61 190.49,94.61 190.65,94.44 190.65,93.82 190.17,93.34 185.29,93.34 183.46,95.17 181.67,95.17 181.66,95.18 181.65,95.18 181.25,95.59 177.56,95.59 177.07,96.08 176.29,96.86 176.11,96.86 175.87,96.62 175.87,96.38 176.3,95.95 176.3,95.23 174.96,93.88 172.34,93.88 172.12,94.1 172.12,95.14 172.44,95.46 173.71,95.46 v1(174.41,94.76)
  BOTTOM w0.102: v1(174.41,94.76) 174.41,94.46 174.28,94.33 173.95,94.33 U6000.A23
  BOTTOM w0.127: v1(188.57,94.19) 188.56,94.19 U6800.R13
EDCA0_3: length 34.1
  TOP w0.127: U6801.C2 v1(197.38,94.2)
  IN3 w0.122: v1(176.94,90.86) 177.62,90.17 178.87,90.17 180.36,88.68 193.17,88.68 194.11,89.62 194.11,91.68 194.09,91.7 194.09,92.11 194.26,92.28 194.26,92.94 194.56,93.24 194.56,93.96 195.94,95.33 197.49,95.33 197.8,95.02 197.8,94.33 197.67,94.2 v1(197.38,94.2)
  BOTTOM w0.102: v1(176.94,90.86) 176.94,90.88 176.53,91.29 175.06,91.29 174.78,91.01 174.25,91.01 174.14,91.12 174.07,91.15 173.49,91.15 173.35,91.08 173.11,91.08 172.98,91.15 172.66,91.15 U6000.E19
EDCA1_0: length 26.5
  TOP w0.127: U6803.C2 188.55,84.78 v1(188.55,84.79)
  IN1 w0.122: v1(176.81,87.2) 177.52,87.91 178.11,87.91 179.5,89.3 181.88,89.3 182.01,89.18 182.01,88.72 182.13,88.59 182.37,88.59 182.49,88.72 182.49,89.18 182.62,89.3 185.49,89.3 185.61,89.18 185.61,88.59 185.73,88.47 185.97,88.47 186.1,88.59 186.1,89.18 186.22,89.3 187.05,89.3 187.44,88.91 187.44,88.74 187.16,88.46 187.16,88.28 187.4,88.04 187.6,88.04 187.89,88.32 188.06,88.32 188.33,88.05 188.33,87.88 188.05,87.59 188.05,87.42 188.32,87.15 188.32,85.02 v1(188.55,84.79)
  BOTTOM w0.102: U6000.E15 172.03,87.82 172.29,88.09 172.52,88.09 172.63,88.15 173.03,88.15 173.34,87.95 173.91,87.95 173.99,87.86 174.33,87.86 174.57,88.11 176.28,88.11
  BOTTOM w0.127: 176.28,88.11 176.81,87.58 v1(176.81,87.2)
EDCA1_1: length 33.3
  IN1 w0.122: v1(174.95,83.56) 174.95,81.57 175.32,81.19 179.5,81.19 181.36,79.33 183.92,79.33 184.85,78.4 190.85,78.4 190.86,78.38 191.3,78.38 192.3,79.38 192.3,81.94 192.89,82.53 192.89,82.57 194.69,84.37 195.14,84.37 195.17,84.35 196.95,84.35 v1(197.37,84.77)
  BOTTOM w0.102: v1(174.95,83.56) 174.55,83.95 174.28,83.95 173.78,83.88 173.47,83.88 173.34,83.93 173.26,83.95 173.16,83.95 U6000.D10
  BOTTOM w0.127: U6802.R13 197,84.4 v1(197.37,84.77)
EDCA1_2: length 26.4
  BOTTOM w0.102: U6000.D6 172.43,79.55 172.76,79.23 172.93,79.23 173.28,78.88 173.28,78.67 173.63,78.31 174.38,78.31 174.51,78.18 175.08,78.18 175.88,77.38
  BOTTOM w0.127: 175.88,77.38 177.7,75.57 177.7,75.49 177.85,75.34 178.09,75.34 178.18,75.43 178.18,75.62 178.31,75.75 178.54,75.75 178.66,75.62 178.66,74.77 178.79,74.64 179.04,74.64 179.17,74.77 179.17,75.62 179.3,75.75 179.55,75.75 179.68,75.62 179.68,74.77 179.81,74.64 180.06,74.64 180.19,74.77 180.19,75.62 180.31,75.75 180.62,75.75 180.75,75.62 180.75,74.74 180.84,74.65 181.14,74.65 181.25,74.77 181.25,75.26 181.38,75.39 181.75,75.39 181.88,75.26 181.88,74.79 183.57,73.1 185.42,73.1 185.62,73.31 185.62,73.42 185.75,73.54 187.4,73.54 187.81,73.96 187.81,74.22 188.17,74.58 U6802.C2
EDCA1_3: length 35.3
  TOP w0.127: U6803.R13 v1(197.35,74.42)
  IN3 w0.122: v1(197.35,74.42) 196.13,74.42 195.72,74 194.75,74 194.56,73.81 194.18,73.81 193.52,73.15 187.66,73.15 187.38,72.88 183.21,72.88 182.64,73.45 179.59,73.45 179.07,72.92 170.89,72.92 170.49,73.33 170.49,74.45 170.28,74.65 v1(170.28,75.01)
  BOTTOM w0.102: v1(170.28,75.01) 170.28,76.53 170.21,76.61 170.21,76.63 170.15,76.69 170.15,77.32 169.9,77.58 169.9,78.14 170.04,78.44 170.06,78.76 170.1,78.89 170.12,78.93 U6000.G5
EDP_AUXN: length 110.6
  IN3 w0.127: v1(65.89,96.53) 65.46,96.96 65.46,96.96 65.45,97.61 65.45,97.87 66.14,98.55 79.85,98.55 82.48,95.93 94.29,95.93 96.16,97.79 98.57,97.79 99.69,98.91 101.15,98.91 102.42,97.64 108.81,97.64 110.01,96.45 110.64,96.45 111.63,95.46 112.76,95.46 116.21,92 116.21,90.85 119.24,87.82 121.71,87.82 129.67,79.86 129.67,77.62 131.12,76.18 131.12,66.73 131.78,66.07 131.78,63.55 133.05,62.28 133.05,60.75 130.92,58.63 127.67,58.63 127.62,58.68 125.58,58.68 125.27,58.37 124.46,58.37 v3(124.25,58.58)
  BOTTOM w0.076: U0400.E45 124.33,58.23 124.25,58.31 v3(124.25,58.58)
  BOTTOM w0.102: v1(65.89,96.53) 66.07,96.7 66.07,96.89 65.96,97 65.54,97 65.43,97.11 65.43,97.82 65.62,98.01 65.79,98.01 C3009.1
EDP_AUXN_CC: length 2.3
  BOTTOM w0.102: C3009.2 65.97,99.1 65.66,99.42 65.66,99.71 65.36,100 65.11,100 64.95,100.16 64.95,100.26 65.08,100.39 CON3000.19
EDP_AUXP: length 110.9
  IN3 w0.127: v1(65.23,96.53) 65.23,97.61 65.23,97.96 66.05,98.78 79.95,98.78 82.58,96.15 94.2,96.15 96.06,98.02 98.48,98.02 99.59,99.14 101.24,99.14 102.51,97.87 108.91,97.87 110.1,96.67 110.74,96.67 111.73,95.68 112.85,95.68 116.44,92.09 116.44,90.94 119.34,88.05 121.8,88.05 129.9,79.95 129.9,77.72 131.34,76.27 131.34,66.82 132,66.16 132,63.65 133.27,62.38 133.27,60.66 131.01,58.4 127.57,58.4 127.52,58.45 125.67,58.45 125.37,58.14 124.53,58.14 v3(124.22,57.84)
  BOTTOM w0.076: U0400.F45 124.22,57.93 v3(124.22,57.84)
  BOTTOM w0.102: 65.23,97.49 v1(65.23,96.53) ; 65.23,97.49 v2(65,97.49) ; 65.23,97.49 65.23,97.82 65.1,97.94 C3008.1
EDP_AUXP_CC: length 2.3
  BOTTOM w0.102: C3008.2 65.17,99.1 65.46,99.39 65.46,99.62 65.28,99.8 65.02,99.8 64.74,100.08 64.74,100.23 64.58,100.39 CON3000.18
EDP_COMP: length 1.2
  TOP w0.432: R0413.1 v3(124.87,62.31)
  BOTTOM w0.254: U0400.E52 124.87,62.18 v3(124.87,62.31)
EDP_DISP_UTIL: length 5.9
  BOTTOM w0.076: 129.18,62.03 128.68,62.03 128.61,62.1 127.68,62.1 127.45,61.87 127.14,61.87 126.87,62.14 U0400.B52
  BOTTOM w0.102: 129.18,62.03 129.65,62.03 129.81,61.88 131.33,61.88 T0408.1
EDP_HPD: length 157.6
  TOP w0.102: R0415.2 127.15,30.2 v2(127.08,30.28) 127.03,30.33 126.24,30.33 125.98,30.59 125.98,30.92 126.34,31.29 v3(126.34,31.45) 126.09,31.7 125.77,31.7 123.93,33.55 121.46,36.01 121.46,37.12 v3(120.88,37.71)
  IN2 w0.102: v1(84.61,22) 84.98,22 86.81,20.17 89.36,20.17 89.99,20.81 91.46,20.81 91.66,20.6 96.98,20.6 98.46,22.08 102.06,22.08 102.49,22.51 105.77,22.51 106.81,21.47 110.12,21.47 110.47,21.82 112.28,21.82 112.78,21.32 112.78,21.32 112.91,21.19 114.45,21.19 114.64,21.38 117.99,21.38 119.55,22.94 122.6,22.94 126.19,26.53 126.19,30.05 125.98,30.26 125.98,31.09 v3(126.34,31.45)
  BOTTOM w0.102: v1(84.61,22) 84.33,22.27 83.32,22.27 82.96,22.63 82.96,23.13 82.95,23.14 82.41,23.68 81.08,23.68 80.65,23.24 74.28,23.24 73.81,23.71 73.81,24.05 74.24,24.48 74.24,64.98 v2(73.89,65.33) 73.63,65.59 73.63,86.8 72.1,88.34 72.1,92.61 69.85,94.86 64.93,94.86 63.81,95.99 63.81,97.23 63.83,97.26 R3000.1 ; U0400.L10 121.21,38.04 v3(120.88,37.71)
EDP_HPD_R: length 2.9
  BOTTOM w0.102: R3000.2 63.83,98.91 63.88,98.96 v2(63.88,99.34) 63.6,99.62 63.3,99.62 62.58,100.34 CON3000.14
EDP_TXN0: length 102.1
  IN3 w0.127: v1(130.94,60.23) 131.16,60.01 131.34,60.01 132.31,60.99 132.31,62.08 131.12,63.28 131.12,65.76 130.45,66.42 130.45,74.37 129.3,75.53 129.3,76.57 129.01,76.86 129.01,79.56 121.41,87.15 118.95,87.15 115.54,90.56 115.54,91.71 112.47,94.78 110.66,94.78 108.53,96.9 101.96,96.9 101.65,96.6 99.24,96.6 98.7,97.13 96.46,97.13 94.6,95.27 82.18,95.27 81.17,96.28 80.02,96.28 78.51,97.79 71.11,97.79 70.02,96.7 69.57,96.7 69.27,96.4 69.27,96.07 v1(69.52,95.81)
  BOTTOM w0.076: U0400.C47 125.85,59.51 125.85,59.37 125.9,59.31 126.09,59.31 126.16,59.39 126.45,59.39 126.63,59.21 127.81,59.21 128.01,59.4 128.01,59.43
  BOTTOM w0.102: 130.23,59.97 130.68,59.97 v1(130.94,60.23) ; 130.23,59.97 v2(130.23,60.2) ; 130.23,59.97 129.79,59.97 129.65,59.82 128.39,59.82 128.01,59.43 ; C3006.1 67.87,97.29 67.62,97.03 67.62,96.86 68,96.47 68.99,96.47 69.27,96.2 69.27,96.07 v1(69.52,95.81)
EDP_TXN0_CC: length 3.6
  BOTTOM w0.102: v2(67.46,99.29) 67.3,99.13 ; 67.3,99.13 67.62,98.81 67.62,98.43 67.89,98.15 C3006.2 ; 67.3,99.13 66.43,99.99 66.43,100.24 66.58,100.39 CON3000.22
EDP_TXN1: length 99
  IN3 w0.127: v5(71.48,95.84) 71.12,96.19 71.12,96.52 71.65,97.06 78.24,97.06 79.83,95.47 80.84,95.47 81.71,94.59 95.12,94.59 95.94,95.4 98.5,95.4 99.04,95.94 103.96,95.94 104.57,95.33 105.77,95.33 106.23,94.87 109.59,94.87 110.33,94.12 111.02,94.12 118.78,86.36 121.24,86.36 128.35,79.26 128.35,76.59 128.64,76.29 128.64,75.21 128.79,75.05 129.79,74.05 129.79,66.04 130.45,65.38 130.45,63 131.62,61.84 131.62,61.24 131.32,60.94 130.25,60.94 129.57,60.25 129.57,59.54 v1(129.18,59.16)
  BOTTOM w0.076: U0400.D46 125.9,59.09 126.32,58.67 126.32,58.41 126.34,58.37 126.52,58.27 126.56,58.25 126.72,58.25 126.89,58.31 127.07,58.31 127.2,58.25 128.03,58.25 128.39,58.61 128.47,58.61
  BOTTOM w0.102: C3004.1 69.81,98.6 69.27,98.05 69.27,97.51 69.75,97.03 70.7,97.03 70.95,96.78 70.95,96.36 v5(71.48,95.84) ; v1(129.18,59.16) 129.18,58.84 128.95,58.61 128.47,58.61
EDP_TXN1_CC: length 2.9
  BOTTOM w0.102: C3004.2 69.81,99.46 69.47,99.8 69.47,99.88 69.27,100.08 67.98,100.08 67.91,100.15 67.91,100.22 68.08,100.39 CON3000.25
EDP_TXP0: length 101.9
  IN3 w0.127: v1(130.94,59.62) 131.1,59.79 131.43,59.79 132.54,60.89 132.54,62.18 131.34,63.37 131.34,65.86 130.68,66.52 130.68,74.47 129.53,75.62 129.53,76.66 129.24,76.95 129.24,79.65 121.51,87.38 119.04,87.38 115.76,90.66 115.76,91.81 112.56,95.01 110.75,95.01 108.63,97.13 101.86,97.13 101.56,96.83 99.33,96.83 98.8,97.36 96.37,97.36 94.5,95.49 82.28,95.49 81.26,96.51 80.11,96.51 78.6,98.02 71.02,98.02 69.93,96.93 69.48,96.93 69.04,96.49 69.04,96.01 v5(68.83,95.81)
  BOTTOM w0.076: U0400.C46 126.51,59.09 126.56,59.04 127.88,59.04 128.12,59.28 128.14,59.28 128.15,59.29
  BOTTOM w0.102: C3007.1 67.41,96.93 67.41,96.78 67.92,96.27 68.91,96.27 69.03,96.15 69.03,96.01 v5(68.83,95.81) ; 128.15,59.29 128.48,59.62 129.73,59.62 129.88,59.77 130.79,59.77 v1(130.94,59.62)
EDP_TXP0_CC: length 3.3
  BOTTOM w0.102: CON3000.21 66.08,100.39 66.23,100.24 66.23,99.91 67.41,98.72 67.41,98.43 67.13,98.15 C3007.2
EDP_TXP1: length 99.2
  IN3 w0.127: v1(70.75,95.83) 70.9,95.98 70.89,96 70.89,96.62 71.56,97.28 78.33,97.28 79.92,95.7 80.93,95.7 81.81,94.82 95.03,94.82 95.84,95.63 98.41,95.63 98.94,96.17 104.06,96.17 104.67,95.56 105.87,95.56 106.33,95.1 109.68,95.1 110.43,94.35 111.11,94.35 118.87,86.59 121.34,86.59 128.58,79.35 128.58,76.68 128.87,76.39 128.87,75.3 129.34,74.82 130.02,74.15 130.02,66.14 130.68,65.48 130.68,63.1 131.85,61.94 131.85,61.14 131.41,60.71 130.35,60.71 129.79,60.16 v1(129.79,59.16)
  BOTTOM w0.076: U0400.C45 126,58.53 126.14,58.43 126.17,58.36 126.2,58.25 126.52,58.09 126.75,58.09 126.91,58.14 127.03,58.14 127.16,58.08 128.1,58.08 128.42,58.4 128.47,58.4
  BOTTOM w0.102: v1(70.75,95.83) 70.75,96.7 70.62,96.83 69.66,96.83 69.06,97.43 69.06,97.84 ; C3005.1 68.91,98.25 69.06,98.1 69.06,97.84 ; 69.06,97.84 v2(68.83,97.84) ; 128.47,58.4 129.04,58.4 v1(129.79,59.16)
EDP_TXP1_CC: length 2.9
  BOTTOM w0.102: CON3000.24 67.58,100.39 67.69,100.28 67.69,100.08 67.89,99.88 69.18,99.88 69.27,99.79 69.27,99.72 69,99.46 C3005.2
EDP_VDD_EN: length 143.4
  IN2 w0.102: v1(83.97,22.96) 84.07,22.86 85.09,22.86 87.09,20.86 89.07,20.86 90.44,22.23 97.4,22.23 98.57,23.4 102.75,23.4 102.96,23.19 106.05,23.19 106.29,22.95 112.12,22.95 113.2,21.87 114.1,21.87 114.3,22.07 116.8,22.07 117.67,22.94 118.58,22.94 119.26,23.62 122.31,23.62 123.67,24.99 123.67,28.22 123.55,28.35 123.55,31.68 121.87,33.36 121.39,33.36 119.23,35.53 119.23,39.33 v3(118.9,39.66)
  BOTTOM w0.089: U0400.U13 118.57,39.66 v3(118.9,39.66)
  BOTTOM w0.102: D3000.2 83.72,95.94 81.81,94.03 81.81,78.69 v2(77.09,73.97) 76.52,73.4 76.52,32.87 81.92,27.48 81.92,27.1 83.87,25.14 83.87,23.07 v1(83.97,22.96)
EMMC_CCLK: length 26.1
  TOP w0.102: R2500.1 96.87,21.46 v1(97,21.59)
  IN3 w0.127: v1(97,21.59) 97,21.72 97.14,21.86 102.87,21.86 103.53,22.52 103.53,22.66 104.98,24.11 104.98,24.95 105.82,25.78 105.82,26.07 106.77,27.03 108.74,27.03 109.45,27.74 109.45,28.03 v1(109.49,28.07)
  BOTTOM w0.076: U0400.AM3 110.85,33.69 110.85,33.13 110.96,32.84 110.96,32.55 110.9,32.35 110.9,30.9 110.91,30.89
  BOTTOM w0.102: 110.91,30.89 110.91,30.39 110.9,30.39 110.9,29.03 v2(110.67,28.8) 109.94,28.07 v1(109.49,28.07)
EMMC_CLK_R: length 15.2
  TOP w0.102: U2500.M6 100.09,19.78 100.58,20.27 v1(100.62,20.27) ; R2500.2 93.74,22.32 93.55,22.13 92.68,22.13 92.31,22.5 R2509.1 92.23,23.29 v1(92.23,23.29)
  IN1 w0.097: v1(92.23,23.29) 92.23,23.07 93.15,22.15 93.63,22.15 95.07,20.7 98.5,20.7 98.73,20.93 99.97,20.93 100.62,20.28 v1(100.62,20.27)
  BOTTOM w0.102: v1(92.23,23.29) 91.7,23.83 91.34,23.83 v2(91.06,24.11)
EMMC_CMD: length 48.3
  TOP w0.102: v1(91.01,23.32) 90.68,23.32 90.42,23.06 R2513.2 ; v1(99.9,20.27) 99.53,19.9 U2500.M5
  IN1 w0.097: v1(99.9,20.27) 99.52,19.89 94.87,19.89 93.32,21.44 92.86,21.44 91.03,23.27 91.03,23.32 v1(91.01,23.32)
  IN3 w0.127: v1(99.9,20.27) 99.9,20.3 99.48,20.72 98.34,20.72 98.22,20.6 94.89,20.6 94.76,20.73 94.76,21.01 94.89,21.14 97.92,21.14 97.97,21.19 99.62,21.19 99.83,20.97 103.01,20.97 104.19,22.15 104.19,22.61 105.49,23.9 105.49,24.25 105.87,24.63 105.87,24.94 106.86,25.93 106.86,26.37 107.01,26.52 108.51,26.52 108.81,26.22 109.04,26.22 109.17,26.34 109.17,26.74 109.96,27.53 109.96,30.75 109.83,30.88 109.12,30.88 v3(108.87,30.63)
  BOTTOM w0.076: v3(108.87,30.63) 109.08,30.84 109.31,30.84 109.59,31.12 109.59,32.46 109.43,32.9 109.43,33.15 109.47,33.28 109.47,34.39 U0400.AP4
  BOTTOM w0.102: v2(89.43,24.79) 89.54,24.79 v1(91.01,23.32)
EMMC_DATA0: length 36.7
  TOP w0.102: R2501.2 v1(96.32,29.39) 96.32,29.06 97.38,27.99 97.38,26.78 98.53,25.64 U2500.A3
  IN3 w0.127: v3(109.06,31.37) 109.83,32.15 109.83,33.17 110.31,33.65 110.31,36.02 109.08,37.25 105.08,37.25 101.34,33.51 98.45,33.51 98.32,33.38 98.32,32.04 98.45,31.92 100.44,31.92 100.57,31.79 100.57,31.06 99.74,30.23 96.92,30.23 96.57,29.88 96.57,29.65 v1(96.32,29.39)
  BOTTOM w0.076: v3(109.06,31.37) 109.26,31.57 109.26,32.23 108.93,32.55 108.93,32.8 109.03,33.04 109.03,33.19 U0400.AP2
EMMC_DATA1: length 36.6
  TOP w0.102: U2500.A4 99.03,26.48 98.48,27.04 98.48,28.82 v1(97.89,29.41) 98.17,29.7 R2502.2
  IN3 w0.127: v1(97.89,29.41) 98.32,29.85 99.9,29.85 101.28,31.23 101.28,31.84 100.83,32.3 98.83,32.3 98.7,32.43 98.7,33 98.83,33.13 101.49,33.13 105.24,36.87 105.97,36.87 106.1,36.74 106.1,36.48 106.22,36.35 106.48,36.35 106.6,36.48 106.6,36.74 106.73,36.87 106.99,36.87 107.11,36.74 107.11,36.48 107.24,36.35 107.49,36.35 107.62,36.48 107.62,36.74 107.75,36.87 108.13,36.87 108.26,36.74 108.26,36.36 108.38,36.24 109.56,36.24 109.93,35.87 109.93,35.41 109.45,34.93 109.45,34.73 109.93,34.24 109.93,33.81 109.45,33.33 109.45,32.53 v3(108.8,31.88)
  BOTTOM w0.076: U0400.AP1 109.2,32.52 109.42,32.29 109.42,31.22 109.21,31 108.78,31 108.6,31.18 108.6,31.68 v3(108.8,31.88)
EMMC_DATA2: length 35.5
  TOP w0.102: R2503.2 100.56,29.56 v1(100.56,29.43) 100.56,29.39 100.2,29.03 100.2,28.63 100.33,28.5 100.58,28.5 100.66,28.58 100.66,28.88 100.76,28.98 100.97,28.98 101.07,28.88 101.07,28.3 100.94,28.17 99.87,28.17 99.77,28.27 99.77,28.91 99.67,29.01 99.39,29.01 99.31,28.93 99.31,27.26 99.53,27.04 U2500.A5
  IN3 w0.127: v1(100.56,29.43) 100.56,29.97 101.36,30.77 101.61,30.77 101.74,30.9 101.74,31.92 101.22,32.44 101.22,32.62 101.35,32.75 101.65,32.75 105.34,36.44 105.6,36.44 105.88,36.15 105.88,35.01 106.02,34.88 106.27,34.88 106.4,35 106.4,35.49 106.53,35.62 106.78,35.62 106.91,35.49 106.91,35 107.04,34.88 107.29,34.88 107.42,35 107.42,35.28 107.56,35.43 107.8,35.43 107.92,35.3 107.92,35 108.05,34.88 108.31,34.88 108.43,35 108.43,35.26 108.6,35.42 108.94,35.42 109.07,35.3 109.07,34.57 109.45,34.19 109.45,33.87 109.07,33.49 109.07,32.7 108.41,32.04 108.41,31.32 108.3,31.21 108.3,30.97 v3(108.3,30.97)
  BOTTOM w0.076: U0400.AP3 109.2,33.81 108.87,33.48 108.87,33.07 108.83,33 108.77,32.84 108.77,32.42 108.44,32.09 108.44,31.1 v3(108.3,30.97)
EMMC_DATA3: length 38.3
  TOP w0.076: 97.37,24.53 97.78,24.53 U2500.B2
  TOP w0.102: v1(108.65,29.64) 108.12,29.11 v2(107.95,29.11) ; R2504.2 94.46,29.64 94.72,29.39 v1(95.04,29.39) 95.1,29.33 95.1,28.6 95.94,27.76 96.28,27.76 96.43,27.61 96.77,27.61 96.9,27.49 96.9,27.26 96.77,27.13 96.58,27.13 96.46,27 96.46,26.75 96.58,26.62 96.83,26.62 96.95,26.49 96.95,26.24 97.05,26.14 97.16,26.14 97.27,26.03 97.27,25.85 97.16,25.74 97.03,25.74 96.9,25.61 96.9,24.81 97.18,24.53 97.37,24.53
  IN3 w0.127: v1(108.65,29.64) 108.64,29.63 107.9,29.63 107.14,30.38 107.14,31.67 107.27,31.79 107.27,33.45 106.99,33.73 104.26,33.73 103.66,33.13 103.66,32.04 103.38,31.76 103.38,30.71 102.31,29.64 102.31,29.25 101.29,28.23 97.76,28.23 97.29,27.75 95.94,27.75 95.04,28.66 v1(95.04,29.39)
  BOTTOM w0.076: U0400.AN3 110.09,34.1 110.09,33.87 110.1,33.87 110.13,33.77 110.13,33.57 110.09,33.5 110.09,33.21 110.12,33.17 110.13,33.11 110.13,32.95 110.08,32.77 110.08,30.84 109.98,30.74 109.98,30.56
  BOTTOM w0.102: 109.98,30.56 109.98,30.4 109.98,30.25 109.65,29.91 108.92,29.91 v1(108.65,29.64)
EMMC_DATA4: length 36.8
  TOP w0.076: 98.28,25.55 98.28,25.03 U2500.B3
  TOP w0.102: R2505.2 95.39,29.68 v1(95.68,29.39) 95.78,29.39 95.89,29.29 95.89,29.06 95.78,28.96 95.5,28.96 95.4,28.86 95.4,28.7 95.52,28.58 96.34,28.58 97.16,27.76 97.16,26.67 98.28,25.55
  IN3 w0.127: v1(108.25,30.1) 107.96,30.1 107.52,30.54 107.52,31.51 107.65,31.64 107.65,32.36 108.31,33.02 108.31,33.58 107.77,34.11 105.7,34.11 104.99,34.83 104.81,34.83 102.45,32.47 102.45,32.29 102.77,31.97 103,31.74 103,30.87 102.14,30.01 101.68,30.01 101.46,29.79 101.46,28.94 101.13,28.61 97.6,28.61 97.13,28.13 96.62,28.13 96.53,28.22 96.53,28.63 96.41,28.76 95.55,28.76 95.42,28.88 95.42,29.13 v1(95.68,29.39)
  BOTTOM w0.076: 109.79,30.64 109.79,30.8 109.92,30.93 109.92,32.63 109.86,32.68 U0400.AN1
  BOTTOM w0.102: v2(95.05,28.76) v1(95.68,29.39) ; v1(108.25,30.1) 109.57,30.1 109.79,30.33 109.79,30.64
EMMC_DATA5: length 36.4
  TOP w0.076: U2500.B4 98.78,25.03 98.78,25.59 98.77,25.6
  TOP w0.102: 98.77,25.6 98.77,26.07 98.68,26.16 98.35,26.16 98.23,26.28 98.23,26.42 98.45,26.63 98.45,26.78 98.3,26.92 98.16,26.92 97.95,26.71 97.8,26.71 97.61,26.9 97.61,28.26 96.95,28.92 v1(96.95,29.42) 97.24,29.71 R2506.2 ; v2(109.73,29.92) 109.73,30.17 v3(109.41,30.48)
  IN3 w0.127: v1(96.95,29.42) 96.95,29.72 97.08,29.85 97.34,29.85 97.47,29.72 97.47,29.12 97.59,28.99 100.95,28.99 101.08,29.12 101.08,29.95 101.52,30.39 101.89,30.39 102.62,31.12 102.62,31.59 101.96,32.25 101.96,32.51 105.1,35.65 105.37,35.65 105.5,35.53 105.5,34.86 105.86,34.5 108.24,34.5 108.36,34.37 108.36,34.06 108.69,33.74 108.69,32.86 108.03,32.2 108.03,31.48 107.91,31.36 107.91,30.7 108.03,30.57 108.37,30.57 108.76,30.18 108.96,30.18 109.2,29.94 109.45,29.94 109.58,30.07 109.58,30.32 v3(109.41,30.48)
  BOTTOM w0.076: v3(109.41,30.48) 109.41,30.65 109.75,31 109.75,32.49 109.6,32.92 109.6,33.12 109.64,33.29 109.64,33.46 U0400.AN2
EMMC_DATA6: length 38.9
  TOP w0.076: U2500.B5 99.28,25.03 99.28,25.6 99.27,25.6
  TOP w0.102: v2(107.9,27.33) 108.12,27.33 108.57,27.79 108.57,28.34 v1(108.38,28.53) ; R2507.2 99.16,29.26 98.88,28.98 v1(98.88,27.63) 98.88,27 99.27,26.61 99.27,25.6
  IN3 w0.127: v1(98.88,27.63) 98.88,27.13 98.76,27 96.77,27 96.62,26.85 96.62,26.56 96.75,26.43 99.32,26.43 99.45,26.56 99.45,27.03 99.57,27.15 99.83,27.15 99.95,27.03 99.95,26.56 100.08,26.43 100.34,26.43 100.46,26.56 100.46,27.03 100.59,27.15 100.84,27.15 100.97,27.03 100.97,26.56 101.1,26.43 101.56,26.43 101.69,26.56 101.69,27.55 102.42,28.29 102.69,28.29 102.82,28.16 102.82,26.98 102.95,26.85 103.18,26.85 103.3,26.98 103.3,28.84 103.8,29.34 104.13,29.34 104.26,29.22 104.26,28.11 104.37,27.99 104.61,27.99 104.74,28.12 104.74,28.74 104.87,28.87 105.09,28.87 105.34,28.62 105.52,28.62 105.77,28.87 108.04,28.87 v1(108.38,28.53)
  BOTTOM w0.076: U0400.AM4 110.26,34.39 110.26,33.9 110.29,33.8 110.29,33.54 110.26,33.46 110.26,33.25 110.27,33.22 110.29,33.12 110.29,32.93 110.26,32.79 110.26,30.78
  BOTTOM w0.102: v1(108.38,28.53) 108.38,28.8 109.3,29.72 109.73,29.72 110.26,30.25 110.26,30.78
EMMC_DATA7: length 40.4
  TOP w0.076: 99.78,25.6 99.78,25.03 U2500.B6
  TOP w0.102: 99.78,25.6 99.78,26.37 99.88,26.47 100.66,26.47 100.76,26.57 100.76,27.47 100.66,27.57 99.91,27.57 v1(99.8,27.69) 99.8,27.82 99.92,27.94 101.04,27.94 101.3,28.2 101.3,29.26 101.04,29.52 R2508.2 101.82,30.02 v2(101.91,30.1)
  IN3 w0.127: v1(109.49,29.31) 109.13,28.96 108.66,28.96 108.37,29.25 104.76,29.25 104.64,29.38 104.64,29.75 104.76,29.87 106.33,29.87 106.45,30 106.45,32.09 106.89,32.53 106.89,33.23 106.76,33.35 105.59,33.35 105.46,33.23 105.46,32.7 105.34,32.57 105.08,32.57 104.94,32.71 104.94,33.22 104.8,33.35 104.42,33.35 104.04,32.98 104.04,31.88 103.76,31.6 103.76,31.06 103.89,30.94 105.87,30.94 106.02,30.78 106.02,30.55 105.89,30.43 104.35,30.43 102.62,28.7 102.3,28.7 101.29,27.69 v1(99.8,27.69)
  BOTTOM w0.076: U0400.AM1 110.53,30.97
  BOTTOM w0.102: v1(109.49,29.31) 109.59,29.31 110.46,30.19 110.46,30.9 110.53,30.97
EMMC_RCLK: length 47
  TOP w0.102: R2512.2 92.85,22.82 v1(92.85,23.29) ; v1(101.27,22.53) 100.7,21.96 99.99,21.96 99.81,21.78 U2500.H5
  IN1 w0.097: v1(101.27,22.53) 100.61,21.87 98.81,21.87 98.12,21.19 95.26,21.19 93.83,22.63 93.38,22.63 92.85,23.16 v1(92.85,23.29)
  IN3 w0.127: v1(101.27,22.53) 101.42,22.68 101.6,22.68 101.73,22.56 101.73,22.5 101.85,22.37 102.63,22.37 103.02,22.76 103.02,23.15 103.18,23.31 103.45,23.31 103.64,23.49 103.64,23.69 103.51,23.82 102.64,23.82 102.51,23.69 102.51,23 102.39,22.88 102.13,22.88 102.01,23 102.01,24.2 102.13,24.32 104.34,24.32 104.47,24.45 104.47,24.7 104.34,24.83 102.13,24.83 102.01,24.96 102.01,25.33 102.13,25.45 102.93,25.45 103.05,25.34 104.61,25.34 104.85,25.58 104.85,25.77 104.76,25.86 104.65,25.86 104.51,26 104.51,26.33 104.4,26.44 104.4,26.63 104.55,26.78 104.79,26.78 105.21,26.36 105.39,26.36 105.52,26.5 105.52,26.79 105.07,27.25 105.07,27.73 105.33,27.99 105.61,27.99 105.98,28.36 106.46,28.36 106.63,28.2 106.63,27.66 106.76,27.54 107.01,27.54 107.14,27.66 107.14,28.23 107.26,28.36 107.52,28.36 107.64,28.23 107.64,27.66 107.77,27.54 108.43,27.54 108.71,27.82 108.71,28.24 v1(108.99,28.53)
  BOTTOM w0.076: 110.72,30.89 110.73,30.9 110.73,32.37 110.79,32.57 110.79,32.81 110.79,32.82 110.68,33.1 110.68,33.2 U0400.AM2
  BOTTOM w0.102: v1(108.99,28.53) 109.08,28.62 109.81,28.62 110.29,29.1 110.29,29.67 110.66,30.04 110.66,30.83 110.72,30.89 ; v1(92.85,23.29) 92.85,24.23 v2(92.81,24.26)
EMMC_RCOMP_R: length 4.7
  BOTTOM w0.203: U0400.AT1 108.39,32.89 108.39,32.44 108.2,32.25 108.2,31.67 107.74,31.2 v2(107.74,29.72) 107.74,29.48 107.42,29.16 R1301.1
ENA: length 44.5
  TOP w0.102: R5807.2 36.65,76.74 v1(36.83,76.92) 37.27,76.49 U5800.26
  IN1 w0.102: v1(36.83,76.92) 36.83,76.73 34.25,74.15 33.35,74.15 32.11,75.39 28.89,75.39 v1(28.7,75.58)
  BOTTOM w0.102: U5702.16 16.33,79.22 16.17,79.06 14.85,79.06 12.62,76.83 12.62,75.4 13.71,74.32 13.71,72.83 14.04,72.5 14.04,69.2 15.29,67.95 18.82,67.95 19.33,68.46 22.56,68.46 25.63,71.53 v2(25.63,73.73) 27.48,75.58 v1(28.7,75.58)
ENB: length 34.8
  TOP w0.102: R5808.2 42.72,73.17 v1(42.66,73.23) 41.97,73.23 41.58,72.84 41.18,72.84 40.66,73.36 U5800.36
  IN1 w0.102: v1(42.66,73.23) 42.26,73.23 40.18,71.15 38.03,71.15 36.99,70.11 34.58,70.11 31.61,73.08 25.35,73.08 24.28,74.15 v1(23.6,74.15)
  BOTTOM w0.102: U5702.10 19.03,78.99 19.46,78.56 19.46,77.42 20.17,76.71 23.11,76.71 v2(23.17,76.66) 23.37,76.46 23.37,74.37 v1(23.6,74.15)
ESPI_ALERT#: length 119.6
  TOP w0.102: v1(25.55,33.4) 25.65,33.5 U2300.55 ; v1(61.57,9.35) 61.34,9.58 61.34,11.97 61.19,12.12 61.19,13.21 61.51,13.53 61.8,13.53 62.38,14.11 62.38,18.64 v1(63.14,19.41)
  IN2 w0.102: v1(61.57,9.35) 60.37,10.56 53.34,10.56 49.77,14.12 49.27,14.12 48.38,13.24 38.66,13.24 38.51,13.39 37.14,13.39 31.09,19.43 29.56,19.43 28.45,20.54 28.45,22.08 26.57,23.96 26.57,29.8 26.09,30.28 26.09,32.87 v1(25.55,33.4)
  IN3 w0.102: v1(97.49,33.89) 97.49,33.33 96.42,32.26 93.99,32.26 93.55,31.82 93.55,30.67 92.93,30.05 92.1,30.05 91.87,29.82 89.61,29.82 87.96,28.17 84.33,28.17 80.37,24.21 76.01,24.21 72.51,20.7 70.83,20.7 70.19,20.07 63.81,20.07 v1(63.14,19.41)
  BOTTOM w0.076: U0400.AY11 105.61,38.53 104.84,38.53 104.67,38.37 104.67,38.27 104.01,37.61 104.01,37.04
  BOTTOM w0.102: 104.01,37.04 103.33,36.35 103.33,35.94 101.25,33.86 100.28,33.86 99.73,33.31 99.73,32.98 R1107.2 99.61,32.96 99.47,33.1 99.47,33.37 99,33.84 97.54,33.84 v1(97.49,33.89) ; v1(25.55,33.4) v2(26.39,33.4)
ESPI_CLK: length 166.1
  TOP w0.102: U2300.57 28.2,32.7 31.57,36.07 35.26,36.07 v1(35.81,35.51) ; v1(87.3,23.73) v2(87.3,22.96) 88.6,21.67 88.6,21.37 91.16,18.8 91.16,17.15 92.35,15.95 92.35,14.67 92,14.31 92,12.13 90.25,10.38 90.25,9.28 89.25,8.28 J5300.7
  IN1 w0.097: v1(102.16,31.37) 102.67,30.86 104.26,30.86 106.88,28.24 106.88,27.13 106.92,27.1 106.92,27.04 107.68,26.28 107.68,25.9 107.31,25.53 106.73,25.53 106.02,24.82 106.02,24.62 105.79,24.39 105.17,24.39 104.93,24.63 104.93,26.39 104.33,26.99 103.31,26.99 102.9,27.41 100.93,27.41 100.21,26.69 98.93,26.69 97.86,25.63 94.54,25.63 94.28,25.89 94.28,26.71 93.76,27.23 90.75,27.23 89.97,26.44 89.28,26.44 87.3,24.46 v1(87.3,23.73) 87.3,23.45 87.11,23.26 87.11,22.61 87.04,22.53 86.39,22.53 86.23,22.37 86.23,22.13 86.36,22 86.99,22 87.11,21.87 87.11,21.62 86.99,21.49 85.73,21.49 85.6,21.36 85.6,21.08 85.73,20.96 86.44,20.96 86.51,20.89 86.51,20.65 86.39,20.53 86.08,20.53 85.93,20.37 85.93,19.94 85.75,19.76 84.07,19.76 83.24,20.6 83.24,20.98 83.11,21.11 81.97,21.11 81.74,20.88 81.74,20.48 80.58,19.32 80,19.32 79.76,19.57 77.78,19.57 76.25,18.04 74.93,18.04 74.55,17.65 73.77,17.65 73.67,17.75 73.67,17.94 73.57,18.04 73.38,18.04 73.28,17.94 73.28,17.75 73.19,17.65 72.99,17.65 72.9,17.75 72.9,17.94 72.8,18.04 72.61,18.04 72.51,17.94 72.51,17.75 72.42,17.65 70.51,17.65 69.64,16.79 61.88,16.79 61.57,17.1 59.59,17.1 57.99,18.7 54.69,18.7 54.25,19.13 50.27,19.13 48.16,21.24 48.16,23.29 43.26,28.19 43.26,28.44 42.78,28.92 42.78,29.06 42.95,29.23 42.95,29.36 42.82,29.5 42.68,29.5 42.51,29.33 42.37,29.33 42.23,29.47 42.23,29.6 42.41,29.77 42.41,29.91 42.27,30.05 42.13,30.05 41.96,29.88 41.82,29.88 41.69,30.01 41.69,30.15 41.86,30.32 41.86,31.27 41.68,31.45 40.89,31.45 40.79,31.55 40.79,31.78 40.92,31.9 41.1,31.9 41.22,32.03 41.22,33.28 40.87,33.63 40.87,38.31 40.74,38.43 40.41,38.43 40.28,38.31 40.28,32.74 40.16,32.62 39.9,32.62 39.8,32.71 39.8,36.63 39.6,36.83 39.24,36.83 39.12,36.71 39.12,34.85 38.99,34.72 38.71,34.72 38.58,34.85 38.58,36.81 38.46,36.93 38.15,36.93 38.02,36.81 38.02,35.61 37.9,35.48 37.67,35.48 37.54,35.61 37.54,36.7 37.41,36.83 37.16,36.83 37.03,36.7 37.03,35.64 36.91,35.51 v1(35.81,35.51)
  BOTTOM w0.102: R1108.2 100.71,31.65 100.66,31.6 C1104.1 101.07,31.27 102.06,31.27 v1(102.16,31.37)
ESPI_CS#: length 134.3
  TOP w0.102: v1(25.15,31.83) 25.53,31.83 25.99,32.3 U2300.58 ; v1(87.76,30.69) 87.33,30.69 87.15,30.51 87.15,29.12 87.73,28.54 87.73,26.55 86.56,25.38 86.56,22.66 87.83,21.39 87.83,21.12 90.45,18.51 90.45,16.82 91.64,15.62 91.64,14.96 91.06,14.38 91.06,13.21 90.04,12.19 90.04,11.18 88.98,10.11 88.98,9.65 88.85,9.53 87.15,9.53 87.02,9.4 87.02,8.77 87.22,8.56 87.63,8.56 87.76,8.44 v1(87.76,7.8) 87.75,7.79 J5300.4
  IN1 w0.097: v1(25.15,31.83) 26.59,30.38 26.59,21.64 27.3,20.93 27.3,18.74 39.61,6.43 50.17,6.43 50.42,6.18 58.72,6.18 59.58,7.05 66.91,7.05 69.33,4.63 72.15,4.63 72.25,4.72 72.25,5.45 72.34,5.55 72.71,5.55 72.82,5.44 72.82,4.78 72.89,4.71 73.19,4.71 73.28,4.8 73.28,5.45 73.38,5.55 84.99,5.55 87.24,7.8 v1(87.76,7.8)
  BOTTOM w0.102: R1115.2 97.36,29.52 97.36,29.25 97.1,28.99 96.04,28.99 94.48,27.43 93.78,27.43 93.45,27.1 93.45,26.49 93.85,26.09 93.85,25.7 93.12,24.97 90.93,24.97 90.42,25.47 90.42,26.07 90.53,26.17 90.53,27.82 89.95,28.4 89.73,28.4 88.76,29.37 88.76,29.69 v2(88.3,30.14) v1(87.76,30.69)
ESPI_IO0: length 139.1
  TOP w0.102: R1110.2 C1103.1 94.01,35.36 94.01,33.87 93.74,33.61 93.27,33.61 93.04,33.38 92.56,33.38 91.54,32.36 90.86,32.36 90.25,31.75 90.25,31.36 89.38,30.5 v2(89.38,29.97) 89.26,29.85 89.26,27.5 89,27.25 89,26.91 89.38,26.53 89.38,24.8 89.81,24.37 89.81,21.99 90.01,21.8 90.44,21.8 91.29,20.94 91.29,20.33 91.62,19.99 92.68,19.99 92.98,19.7 95.54,19.7 95.96,19.28 95.96,17.86 95.78,17.68 94.08,17.68 93.9,17.5 93.9,15.73 94.72,14.91 95.66,14.91 95.78,14.79 95.78,14.56 95.66,14.43 95.17,14.43 95.02,14.28 95.02,14.02 95.12,13.92 95.73,13.92 95.88,13.77 95.88,13.49 95.73,13.34 95.1,13.34 94.89,13.13 94.89,12.93 95.02,12.8 95.74,12.8 95.87,12.68 95.87,12.38 95.64,12.16 94.78,12.16 94.72,12.09 94.72,11.76 94.59,11.64 94.11,11.64 92.08,9.6 v1(92.08,7.9) 91.75,7.58 J5300.12 ; U2300.59 26.08,31.9 25.32,31.14 v1(25.17,31.14)
  IN1 w0.097: v1(92.08,7.9) 87.9,3.73 68.94,3.73 66.52,6.15 61.16,6.15 59.6,4.6 38.1,4.6 23.65,19.05 23.65,26.93 24.29,27.57 24.29,27.58 24.49,27.78 24.49,29.7 25.17,30.38 v1(25.17,31.14)
ESPI_IO1: length 137.2
  TOP w0.102: R1111.2 C1102.1 93.09,35.36 93.09,34.67 93.14,34.62 93.14,33.87 92.9,33.63 92.49,33.63 91.55,32.69 90.48,32.69 90.35,32.57 90.35,32.21 90.25,32.11 89.89,32.11 v2(89.61,31.83) 89.61,31.65 89.82,31.44 89.82,31.26 89.14,30.58 89,30.58 88.87,30.46 88.87,29.72 89.03,29.57 89.03,27.6 88.77,27.34 88.77,26.82 89.15,26.43 89.15,24.71 89.59,24.28 89.59,21.9 89.91,21.57 90.34,21.57 91.06,20.85 91.06,20.23 91.55,19.74 92.62,19.74 92.88,19.47 95.45,19.47 95.65,19.27 95.65,19.08 95.52,18.95 94.49,18.95 94.36,18.82 94.36,18.6 94.49,18.47 95.5,18.47 95.63,18.34 95.63,18.14 95.5,18.01 93.85,18.01 93.68,17.83 93.68,15.63 94.39,14.92 94.39,14.67 94.49,14.57 94.69,14.57 94.79,14.47 94.79,14.26 94.69,14.16 94.49,14.16 94.39,14.06 94.39,13.86 94.49,13.76 94.69,13.76 94.79,13.65 94.79,13.45 94.69,13.35 94.49,13.35 94.39,13.25 94.39,13.03 94.69,12.73 94.69,12.55 91.85,9.71 91.85,8.28 v1(91.47,7.9) 91.25,7.69 J5300.11 ; v1(24.69,27.41) 23.9,28.2 23.9,30.2 24.44,30.74 25.37,30.74 26.13,31.5 U2300.60
  IN1 w0.097: v1(24.69,27.41) 23.93,26.65 23.93,19.08 38.19,4.82 58.31,4.82 59.86,6.38 66.63,6.38 69.05,3.95 87.52,3.95 v1(91.47,7.9)
ESPI_IO2: length 139.2
  TOP w0.102: J5300.10 90.75,7.85 v1(90.75,7.85) 90.75,8.46 90.88,8.59 91.06,8.59 91.29,8.36 91.49,8.36 91.62,8.49 91.62,9.81 93.59,11.77 93.59,11.95 93.37,12.17 93.37,12.35 93.49,12.48 93.67,12.48 93.88,12.27 94.03,12.27 94.16,12.4 94.16,12.88 93.89,13.15 93.89,13.43 94.08,13.61 94.08,13.79 93.9,13.97 93.5,13.97 93.37,14.1 93.37,14.28 93.47,14.38 94.03,14.38 94.16,14.51 94.16,14.82 93.45,15.54 93.45,18.07 93.72,18.34 94.01,18.34 94.13,18.47 94.13,19.1 94.01,19.23 93.32,19.23 93.22,19.13 93.22,18.87 93.17,18.82 92.84,18.82 92.76,18.9 92.76,19.27 92.57,19.46 91.5,19.46 90.83,20.14 90.83,20.76 90.25,21.34 89.74,21.34 89.36,21.72 89.36,24.18 88.93,24.61 88.93,25.35 88.85,25.43 88.65,25.43 88.52,25.55 88.52,25.73 88.65,25.86 88.8,25.86 88.93,25.99 88.93,26.32 88.47,26.77 88.47,28.1 88.57,28.2 88.7,28.2 88.8,28.3 88.8,28.51 88.7,28.61 88.57,28.61 88.5,28.68 88.47,28.71 88.47,28.91 88.57,29.01 88.7,29.01 88.8,29.12 88.8,29.32 88.65,29.47 88.65,30.69 88.8,30.84 89.07,30.84 89.22,30.99 89.22,31.17 89.1,31.3 88.57,31.3 88.47,31.4 88.47,31.58 88.6,31.7 88.96,31.7 89.09,31.83 89.09,32.02 88.86,32.25 88.86,32.38 89.06,32.59 89.2,32.59 89.52,32.27 89.71,32.27 89.85,32.42 89.85,32.56 89.52,32.9 89.52,33.04 89.63,33.16 89.78,33.16 90.07,32.87 90.24,32.87 90.37,33 90.37,33.15 90.07,33.45 90.07,33.59 90.34,33.87 90.34,34.24 90.49,34.38 90.89,34.38 91.02,34.25 91.02,33.85 90.7,33.53 90.7,33.23 v2(90.81,33.12) 91.29,33.12 91.41,33.25 91.41,33.45 91.49,33.53 92.06,33.53 92.15,33.62 92.15,35.36 C1101.1 R1112.2 ; v1(24.71,26.8) 25.12,27.21 25.12,27.59 24.13,28.58 24.13,30.08 24.56,30.51 25.48,30.51 26.06,31.1 U2300.61
  IN1 w0.097: v1(24.71,26.8) 24.16,26.24 24.16,19.28 37.45,5.99 49.98,5.99 50.24,5.73 58.85,5.73 58.86,5.73 58.9,5.73 59.77,6.6 66.73,6.6 69.15,4.18 87.08,4.18 v1(90.75,7.85)
ESPI_IO3: length 138.8
  TOP w0.102: R1113.2 C1100.1 v2(90.72,34.97) 90.07,34.32 90.07,33.92 88.24,32.09 88.24,31.3 88.42,31.12 88.42,29.31 88.24,29.14 88.24,24.95 88.14,24.84 87.17,24.84 87.02,24.69 87.02,24.46 87.15,24.34 87.63,24.34 87.76,24.21 87.76,23.88 87.9,23.74 88.14,23.74 88.27,23.87 88.27,24.21 88.39,24.34 88.87,24.34 89.1,24.1 89.1,21.65 89.64,21.11 90.15,21.11 90.6,20.66 90.6,20.04 91.64,19 91.64,17.35 91.97,17.02 92.25,17.02 92.38,17.15 92.38,17.63 92.48,17.73 92.84,17.73 92.91,17.66 92.91,16.87 92.66,16.62 92.66,16.44 93.22,15.88 93.22,15.22 93.35,15.09 93.52,15.09 93.7,14.91 93.7,14.73 93.57,14.61 92.96,14.61 92.76,14.41 92.76,14.23 92.86,14.12 92.94,14.12 93.07,14 93.07,13.26 93.19,13.13 93.52,13.13 93.62,13.03 93.62,12.85 93.52,12.75 92.61,12.75 92.48,12.63 92.48,12.37 92.61,12.25 92.96,12.25 93.14,12.07 93.14,11.65 93.07,11.58 93.07,11.58 92.87,11.58 92.58,11.86 92.43,11.86 92.32,11.75 92.32,11.57 92.58,11.3 92.58,11.1 92.46,10.97 92.31,10.97 91.99,11.29 91.85,11.29 91.7,11.15 91.7,11.01 92.03,10.68 92.03,10.54 91.86,10.38 91.68,10.38 91.52,10.54 91.19,10.54 90.73,10.09 90.73,9.53 90.86,9.4 91.19,9.4 91.31,9.27 91.31,8.94 91.19,8.82 90.47,8.82 90.25,8.6 v1(90.25,8.31) J5300.9 ; v1(24.71,26.19) 25.35,26.82 25.35,27.68 25.22,27.82 24.36,28.67 24.36,29.77 24.87,30.28 25.57,30.28 25.6,30.3 25.6,30.3 25.99,30.7 U2300.62
  IN1 w0.097: v1(90.25,8.31) 90.25,7.75 86.9,4.4 75.58,4.4 75.49,4.5 75.49,5.23 75.39,5.33 75,5.33 74.91,5.23 74.91,4.5 74.81,4.4 74.42,4.4 74.33,4.5 74.33,5.23 74.23,5.33 73.84,5.33 73.75,5.23 73.75,4.5 73.65,4.4 69.24,4.4 66.82,6.82 59.68,6.82 58.81,5.96 58.67,5.96 58.67,5.95 50.33,5.95 50.08,6.21 37.66,6.21 25.1,18.77 25.1,25.81 v1(24.71,26.19)
ESPI_RESET#: length 156.9
  TOP w0.102: J5300.5 v1(88.25,8.26) 88.65,8.26 88.78,8.38 88.78,8.64 88.6,8.82 87.43,8.82 87.31,8.94 87.31,9.16 87.45,9.3 88.9,9.3 89.15,9.05 89.33,9.05 89.76,9.48 89.76,9.73 89.69,9.81 89.48,9.81 89.36,9.93 89.36,10.17 90.53,11.34 90.53,11.61 90.3,11.84 90.3,12.12 90.57,12.4 90.75,12.4 90.91,12.25 90.91,12.07 91.01,11.96 91.15,11.96 91.52,12.33 91.52,14.51 91.87,14.87 91.87,15.72 90.68,16.91 90.68,18.6 88.09,21.19 88.09,21.46 86.79,22.75 86.79,25.28 88.01,26.5 88.01,29.06 87.88,29.18 87.54,29.18 87.43,29.3 87.43,29.48 87.52,29.57 88.06,29.57 88.19,29.7 88.19,29.85 88.09,29.95 87.55,29.95 87.48,30.03 87.48,30.18 87.58,30.28 88.09,30.28 88.19,30.38 88.19,30.94 88.01,31.12 87.55,31.12 87.42,31.24 87.42,31.42 87.55,31.55 87.88,31.55 88.01,31.68 88.01,31.88 87.88,32.01 87.38,32.01 v2(87.25,32.13) 87.25,32.51 87.43,32.69 88.52,32.69 89.84,34.01 89.84,34.72 90.78,35.66 90.78,38.36 91.14,38.71 92.28,38.71 92.94,39.37 95.28,39.37 98.05,42.14 102.05,42.14 103.59,40.6 103.59,40.48 104.06,40.01 104.06,39.96 104.57,39.45 104.57,38.69 v3(104.29,38.41) ; R2331.2 24.86,34.17 25.87,34.18 25.99,34.3 U2300.53 27.68,34.3 v1(28.03,33.95)
  IN1 w0.097: v1(28.03,33.95) 26.85,32.77 26.85,21.71 27.53,21.03 27.53,18.84 38.71,7.66 38.71,7.65 39.71,6.66 50.27,6.66 50.52,6.4 58.62,6.4 59.49,7.27 67.03,7.27 68.52,5.77 69.8,5.77 69.9,5.68 69.9,4.98 70,4.88 70.38,4.88 70.48,4.98 70.48,5.68 70.58,5.77 70.96,5.77 71.06,5.68 71.06,4.98 71.16,4.88 71.54,4.88 71.64,4.98 71.64,5.68 71.74,5.77 84.9,5.77 87.38,8.26 v1(88.25,8.26)
  BOTTOM w0.076: U0400.BA11 105.14,38.83 104.87,39.1 104.46,39.1 104.29,38.93 v3(104.29,38.41)
FAN1_PWM: length 321.8
  TOP w0.102: U2300.47 25.94,36.7 25.58,37.06 25.26,37.06 24.75,37.57 23.32,37.57 v1(21.11,39.78) v2(20.47,39.78)
  IN2 w0.102: v1(206.01,91.51) 209.7,87.81 209.7,59.49 207.49,57.28 207.49,54.08 213.69,47.88 213.69,45.75 217.04,42.4 217.04,27.36 215.48,25.81 215.48,23.2 213.98,21.69 211.79,21.69 204.32,14.22 204.32,11.49 202.51,9.68 151.99,9.68 151.23,8.92 111.79,8.92 111.16,9.54 105.21,9.54 103.28,7.61 103.28,5.88 100.65,3.25 96.67,3.25 93.9,6.02 91.16,6.02 90.02,4.88 51.68,4.88 48.79,7.77 48.11,7.77 46.99,8.89 45.03,8.89 44.25,8.11 43.28,8.11 42.49,8.89 35.08,8.89 22.07,21.9 22.07,37.8 21.11,38.77 v1(21.11,39.78)
  BOTTOM w0.102: v2(203.02,92.59) 203.23,92.38 R3601.2
  BOTTOM w0.381: Q3602.2 204.53,90.55 204.22,90.86 R3610.2 ; R3610.2 204.22,92.05 204.37,92.2 205.31,92.2 v1(206.01,91.51) ; R3610.2 R3601.2
FAN1_TACH: length 316.3
  TOP w0.102: v1(206.83,87.58) 205.99,86.74 v2(205.99,86.69) ; v2(20.5,41.63) 21.36,40.77 v1(21.77,40.77) 24.97,40.77 25.88,39.85 25.88,39.6 25.99,39.5 U2300.40
  IN1 w0.102: v1(206.71,72.75) 206.32,73.13 206.32,81.33 205.94,81.71 205.94,86.69 v1(206.83,87.58) ; v1(151.21,11.94) 151.86,11.29 162.18,11.29 162.75,10.73 176.23,10.73 177.09,9.86 197.88,9.86 210.27,22.25 213.83,22.25 215.08,23.49 215.08,27.78 v1(216.23,28.93)
  IN2 w0.102: v1(208.28,62.13) 207.26,61.11 207.26,53.99 213.44,47.81 213.44,45.62 216.32,42.73 216.32,29.03 v1(216.23,28.93) ; v1(21.77,40.77) 21.77,38.75 22.53,37.99 22.53,32.41 23.31,31.64 23.31,21.31 35.27,9.35 47.18,9.35 48.3,8.23 48.98,8.23 49.49,7.72 53.51,7.72 55.47,5.77 58.94,5.77 59.47,6.3 60.44,6.3 61.4,5.34 64.87,5.34 65.65,6.12 72.04,6.12 72.85,6.94 94.28,6.94 97.05,4.17 100.27,4.17 102.36,6.26 102.36,7.99 104.87,10.49 106.7,10.49 107.33,11.13 108.39,11.13 108.97,10.55 118.85,10.55 119.67,11.36 123.26,11.36 123.77,10.85 137.57,10.85 138.58,11.86 143.23,11.86 143.56,11.53 147.38,11.53 147.58,11.33 149.2,11.33 149.56,11.69 150.96,11.69 v1(151.21,11.94)
  BOTTOM w0.102: R3602.2 v1(206.83,87.58) ; v1(208.28,62.13) 204.88,62.13 204.62,62.39 D3600.1 204.62,67.01 204.22,67.41 204.22,69.42 206.71,71.91 v1(206.71,72.75)
FB_A_VCPU: length 7.5
  BOTTOM w0.102: PR7816.1 179.88,47.07 180.06,46.89 180.06,44.86 v2(180.52,44.4)
  BOTTOM w0.229: PU7800.17 177.79,48.45 177.85,48.39 178.28,48.39 178.56,48.11 178.56,47.98 PC7818.2 178.92,47.78 179.25,48.11 179.34,48.11 PR7822.1 179.88,48.25 PR7816.1
FB_B_VCPU: length 12.1
  BOTTOM w0.229: PR7814.2 175.73,58.26 175.73,56.51 175.63,56.4 175.63,55.2 174.85,54.42 174.85,54.2 174.71,54.06 174.71,53.66 PR7815.1 173.94,52.89 173.94,52.55 174.7,51.79 PU7800.5
  BOTTOM w0.254: PR7814.2 175.06,58.93 PR7820.2 PR7855.2 173.76,58.93 173.36,58.52 172.87,58.52 172.44,58.96 v2(172.44,59.26)
FB_B_VCPU_R: length 5.7
  BOTTOM w0.229: PC7820.1 174.52,54.92 174.52,54.33 PR7815.2
  BOTTOM w0.254: PC7820.1 175.29,55.68 175.29,56.57 175.39,56.67 175.39,57.57 PC7841.1 v2(173.96,58.11)
FB_C_VCPU: length 6.8
  TOP w0.229: v1(173.45,44.17) 173.81,44.17 174.02,43.97 174.02,43.23 PR7845.2
  TOP w0.254: v1(173.45,44.17) 173.12,43.84 v2(172.72,43.84)
  BOTTOM w0.229: PU7800.25 175.1,46 174.94,45.84 174.94,45.41 175.03,45.32 PC7834.1 174.72,44.73 174.47,44.73 174.14,44.4 PR7851.2 173.68,44.4 v1(173.45,44.17)
FBA_SEN0: length 12.6
  TOP w0.102: v1(199.39,101.96) v2(200.2,101.96)
  IN3 w0.102: v1(192.68,99.24) 192.68,99.6 194.36,101.27 195.44,101.27 196.96,102.79 197.84,102.79 198.67,101.96 v1(199.39,101.96)
  BOTTOM w0.102: v1(192.68,99.24) 192.15,99.24 191.49,98.58 U6800.J10 ; v1(199.39,101.96) 199.57,102.14 R6801.2
FBA_SEN1: length 13.7
  TOP w0.102: U6801.J10 192.13,98.58 v1(192.28,98.73) ; v1(199.42,101.35) 199.42,100.75 v2(199.92,100.24)
  IN3 w0.102: v1(199.42,101.35) 198.99,101.35 197.75,102.59 197.16,102.59 196.14,101.57 196.14,100.96 196.16,100.95 196.16,100.45 195.88,100.16 194.72,100.16 194.39,99.82 194.01,99.82 192.92,98.73 v1(192.28,98.73)
  BOTTOM w0.102: R6802.2 199.57,101.2 v1(199.42,101.35)
FBA_SEN2: length 10.6
  IN3 w0.102: v1(199.32,76.6) 198.68,77.23 198.68,77.71 198.44,77.95 196.78,77.95 196.73,78 195.62,78 195.6,78.01 194.55,78.01 194.54,78.02 192.99,78.02 v1(192.93,78.09)
  BOTTOM w0.102: v1(199.32,76.6) 199.43,76.6 R6817.2 ; U6802.J10 194.23,79.26 193.69,79.26 192.93,78.49 v1(192.93,78.09)
FBA_SEN3: length 18.9
  TOP w0.102: v1(192.76,81.66) 193.27,81.16 193.27,79.87 193.84,79.3 194.27,79.3 U6803.J10 ; v1(199.32,75.28) 199.68,75.28 v2(199.92,75.03)
  IN3 w0.102: v1(192.76,81.66) 195.12,81.66 195.6,81.18 196.35,81.18 197.17,82 197.55,82 197.79,81.76 197.79,81.49 198.08,81.2 198.33,81.2 199.14,80.39 199.14,80.27 199.72,79.68 199.72,79.14 199.01,78.42 199.01,77.55 199.72,76.84 199.72,75.69 v1(199.32,75.28)
  BOTTOM w0.102: v1(199.32,75.28) 199.46,75.14 R6819.2
FBA_VREFC_0: length 5.9
  BOTTOM w0.102: 184.82,97.37 184.82,96.88 184.82,96.31 R6806.2 ; 184.82,97.37 R6807.1 ; 184.82,97.37 184.82,98.06 184.81,98.07 C6801.1 ; C6801.1 185.24,98.4 185.42,98.58 U6800.J14 ; C6801.1 184.81,98.94 184.84,98.96 v2(184.84,99.57)
FBA_VREFC_1: length 5.4
  TOP w0.102: v2(183.21,100.05) R6808.2 183.29,99.24 R6809.1 C6802.1 185.57,98.38 185.78,98.58 U6801.J14
FBA_VREFC_2: length 5
  BOTTOM w0.254: R6810.2 201.09,77.14 200.25,77.98 R6811.1 200.25,78.46 200.08,78.64 C6803.1 199.14,79.07 198.61,79.6 U6802.J14
FBA_VREFC_3: length 76.2
  TOP w0.254: 200.24,78.09 200.24,78.08 199.77,78.08 v1(199.54,78.31) ; 200.24,78.09 R6805.1 ; 200.24,78.09 200.24,78.6 200.25,78.62 C6800.1 ; C6800.1 198.81,79.1 198.31,79.6 U6803.J14 ; C6800.1 200.25,79.68 v2(200.69,80.11)
  IN2 w0.254: v1(172.53,69.75) 172.23,69.45 169.37,69.45 169.1,69.18 168.47,69.18 165.34,72.3 161.33,72.3 160.22,73.41 159.36,73.41 157.84,74.93 154.69,74.93 152.11,77.51 v1(149.19,77.51)
  IN3 w0.254: v1(199.54,78.31) 199.54,77.42 200.03,76.94 200.03,73.99 196.04,70 193.91,70 191.03,67.13 191.03,65.02 189.42,63.4 182.08,63.4 181.12,64.36 181.12,66.81 177.95,69.98 173.18,69.98 172.95,69.75 v1(172.53,69.75)
  BOTTOM w0.254: v1(149.19,77.51) 148.6,77.51 R6804.2
FBA_ZQ0: length 7.5
  BOTTOM w0.102: U6800.J13 187.81,98.23 185.75,98.23 185.42,97.9 185.42,95.94 185.27,95.79 184.89,95.79 184.4,95.3 R6800.2 v2(183.24,95.2)
FBA_ZQ1: length 5.7
  TOP w0.102: v2(184.53,96.04) 184.33,96.24 R6803.2 184.33,97.26 184.86,97.79 185.57,97.79 186.01,98.23 187.44,98.23 187.79,98.23 188.14,98.58 U6801.J13
