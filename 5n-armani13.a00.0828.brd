# Allegro board 5n-armani13.a00.0828.brd (continued)
## Text on the board (continued)
User.45: 0@@list("C0600" "TX_C0603_T02_H39" list(3959.000000 2297.000000) nil) | 0@@list("C0601" "TX_C0603_T02_H39" list(3958.000000 2573.000000) nil) | 0@@list("C0602" "TX_C0603_T02_H39" list(4019.000000 2206.000000) nil) | 0@@list("C0603" "TX_C0402_T02_H28" list(4038.100000 2096.030000) nil) | 0@@list("C0604" "TX_C0402_T02_H28" list(3933.000000 2166.000000) nil) | 0@@list("C0605" "TX_C0402_T02_H28" list(3933.000000 2230.000000) nil) | 0@@list("C0606" "TX_C0402_T02_H28" list(3932.000000 2410.000000) nil) | 0@@list("C0609" "TX_C0402" list(4177.000000 2183.000000) nil) | 0@@list("C0610" "TX_C0402" list(4181.000000 2233.000000) nil) | 0@@list("C0611" "TX_C0402" list(4620.090000 2130.360000) nil) | 0@@list("C0612" "TX_C0402_T02_H28" list(4109.830000 2499.790000) nil) | 0@@list("C0613" "TX_C0402" list(4266.060000 2113.000000) nil) | 0@@list("C0614" "TX_C0402" list(4395.780000 2114.790000) nil) | 0@@list("C0615" "TX_C0402" list(4303.060000 2113.000000) nil) | 0@@list("C0616" "TX_C0402" list(4339.780000 2112.790000) nil) | 0@@list("C0617" "TX_C0402" list(4619.710000 2168.280000) nil) | 0@@list("C0618" "TX_C0402" list(4432.820000 2114.710000) nil) | 0@@list("C0619" "TX_C0402" list(4850.000000 1992.000000) nil) | 0@@list("C0620" "TX_C0402" list(4778.060000 2045.000000) nil) | 0@@list("C0621" "TX_C0402" list(4192.000000 2121.060000) nil) | 0@@list("C0622" "TX_C0402" list(4633.060000 2066.000000) nil) | 0@@list("C0623" "TX_C0402" list(4596.060000 2066.000000) nil) | 0@@list("C0700" "TX_C0402" list(4174.790000 2276.290000) nil) | 0@@list("C0701" "TX_C0402" list(4174.860000 2313.410000) nil) | 0@@list("C0702" "TX_C0402" list(4174.790000 2350.250000) nil) | 0@@list("C0703" "TX_C0402" list(4268.000000 2323.000000) nil) | 0@@list("C0704" "TX_C0402" list(4855.000000 2396.000000) nil) | 0@@list("C0705" "TX_C0402" list(4680.380000 2366.720000) nil) | 0@@list("C0706" "TX_C0402" list(4784.000000 2286.000000) nil) | 0@@list("C0711" "TX_C0402" list(4854.000000 2624.000000) nil) | 0@@list("C0712" "TX_C0402" list(4522.880000 2381.000000) nil) | 0@@list("C0717" "TX_C0402" list(4679.880000 2438.000000) nil) | 0@@list("C0718" "TX_C0402" list(4625.620000 2367.000000) nil) | 0@@list("C0719" "TX_C0402" list(4818.120000 2385.500000) nil) | 0@@list("C0720" "TX_C0402" list(4276.000000 2830.000000) nil) | 0@@list("C0721" "TX_C0402" list(4543.000000 2830.000000) nil) | 0@@list("C0722" "TX_C0402" list(4615.880000 2807.220000) nil) | 0@@list("C0723" "TX_C0402" list(4543.000000 2766.000000) nil) | 0@@list("C0724" "TX_C0402" list(4491.000000 2830.000000) nil) | 0@@list("C0725" "TX_C0402" list(4615.880000 2656.220000) nil) | 0@@list("C0726" "TX_C0402" list(4616.000000 2693.000000) nil) | 0@@list("C0727" "TX_C0402" list(4615.880000 2733.220000) nil) | 0@@list("C0728" "TX_C0402" list(4615.880000 2770.220000) nil) | 0@@list("C0729" "TX_C0402" list(4383.000000 2830.000000) nil) | 0@@list("C0730" "TX_C0402" list(4438.000000 2830.000000) nil) | 0@@list("C0731" "TX_C0402" list(4494.000000 3259.000000) nil) | 0@@list("C0732" "TX_C0402" list(4558.000000 3259.000000) nil) | 0@@list("C0733" "TX_C0402" list(4328.000000 2830.000000) nil) | 0@@list("C0740" "TX_C0402" list(4175.300000 2423.500000) nil) | 0@@list("C0741" "TX_C0402" list(4270.000000 2404.000000) nil) | 0@@list("C0742" "TX_C0402" list(4625.000000 2437.500000) nil) | 0@@list("C0743" "TX_C0402" list(4626.000000 2301.000000) nil) | 0@@list("C0744" "TX_C0402" list(4175.300000 2387.000000) nil) | 0@@list("C0745" "TX_C0402" list(4614.620000 2616.690000) nil) | 0@@list("C0746" "TX_C0402" list(4614.620000 2579.690000) nil) | 0@@list("C0747" "TX_C0402" list(4781.380000 2648.310000) nil) | 0@@list("C0748" "TX_C0402" list(4183.880000 2606.810000) nil) | 0@@list("C0749" "TX_C0402" list(4183.880000 2569.810000) nil) | 0@@list("C1002" "TX_C0402" list(3448.000000 1991.500000) nil) | 0@@list("C1003" "TX_C0402" list(3473.880000 1917.000000) nil) | 0@@list("C1100" "TX_C0402" list(3394.000000 1647.000000) nil) | 0@@list("C1101" "TX_C0402" list(3435.000000 1647.000000) nil) | 0@@list("C1102" "TX_C0402" list(3472.000000 1647.000000) nil) | 0@@list("C1103" "TX_C0402" list(3508.000000 1647.000000) nil) | 0@@list("C1201" "TX_C0402" list(2371.000000 684.000000) nil) | 0@@list("C1202" "TX_C0402" list(2410.000000 684.000000) nil) | 0@@list("C1204" "TX_C0402" list(3393.000000 1451.000000) nil) | 0@@list("C1205" "TX_C0402" list(3396.000000 1307.000000) nil) | 0@@list("C1600" "TX_C0402" list(4347.000000 2004.000000) nil) | 0@@list("C1601" "TX_C0402" list(4347.000000 1940.000000) nil) | 0@@list("C1602" "TX_C0402" list(4464.500000 1433.000000) nil) | 0@@list("C1603" "TX_C0402" list(4464.500000 1396.000000) nil) | 0@@list("C1605" "TX_C0402" list(4401.000000 2005.500000) nil) | 0@@list("C1606" "TX_C0402" list(4551.000000 1924.440000) nil) | 0@@list("C1608" "TX_C0402" list(4581.100000 1456.780000) nil) | 0@@list("C1611" "TX_C0402" list(4142.400000 1491.300000) nil) | 0@@list("C1612" "TX_C0402" list(4388.000000 1469.000000) nil) | 0@@list("C1613" "TX_C0402" list(4592.100000 1420.290000) nil) | 0@@list("C1614" "TX_C0402" list(4445.060000 2025.000000) nil) | 0@@list("C1615" "TX_C0402" list(4432.000000 1919.600000) nil) | 0@@list("C1618" "TX_C0402" list(3590.000000 1535.000000) nil) | 0@@list("C1619" "TX_C0402" list(4306.000000 2018.000000) nil) | 0@@list("C1620" "TX_C0402" list(4269.000000 1997.000000) nil) | 0@@list("C1621" "TX_C0603_T02_H39" list(4691.800000 1948.610000) nil) | 0@@list("C1622" "TX_C0402" list(4436.000000 1955.700000) nil) | 0@@list("C1623" "TX_C0603_T02_H39" list(4689.300000 2061.680000) nil) | 0@@list("C1624" "TX_C0603_T02_H39" list(4745.000000 1982.500000) nil) | 0@@list("C1625" "TX_C0402" list(4496.500000 1990.000000) nil) | 0@@list("C1626" "TX_C0402" list(4534.000000 2019.000000) nil) | 0@@list("C1629" "TX_C0402" list(4468.000000 1359.000000) nil) | 0@@list("C1630" "TX_C0402" list(4488.000000 1090.000000) nil) | 0@@list("C1632" "TX_C0402" list(5041.000000 1127.000000) nil) | 0@@list("C1800" "TX_C0402" list(297.000000 935.000000) nil) | 0@@list("C1903" "TX_C0402" list(1361.000000 3577.000000) nil) | 0@@list("C1904" "TX_C0402" list(942.000000 2439.000000) nil) | 0@@list("C1905" "TX_C0402" list(2695.000000 930.000000) nil) | 0@@list("C1906" "TX_C0402" list(2714.000000 1146.000000) nil) | 0@@list("C2000" "TX_C0402" list(2235.000000 1323.000000) nil) | 0@@list("C2001" "TX_C0402" list(2548.000000 1278.000000) nil) | 0@@list("C2002" "TX_C0402" list(2235.000000 2841.000000) nil) | 0@@list("C2003" "TX_C0402" list(4052.000000 1297.000000) nil) | 0@@list("C2004" "TX_C0402" list(4052.000000 1260.350000) nil) | 0@@list("C2005" "TX_C0402" list(2550.000000 1363.000000) nil) | 0@@list("C2006" "TX_C0402" list(2235.000000 1365.000000) nil) | 0@@list("C2007" "TX_C0402" list(2127.310000 2229.620000) nil) | 0@@list("C2008" "TX_C0402" list(2127.310000 2192.620000) nil) | 0@@list("C2009" "TX_C0402" list(2211.810000 2242.620000) nil) | 0@@list("C2010" "TX_C0402" list(2211.810000 2130.620000) nil) | 0@@list("C2011" "TX_C0402" list(2234.000000 2804.000000) nil) | 0@@list("C2012" "TX_C0402" list(2548.000000 1314.000000) nil) | 0@@list("C2100" "TX_C0402" list(1644.130000 1242.340000) nil) | 0@@list("C2101" "TX_C0402" list(2056.000000 1327.000000) nil) | 0@@list("C2102" "TX_C0402" list(1596.000000 2721.000000) nil) | 0@@list("C2103" "TX_C0402" list(2056.000000 1409.000000) nil) | 0@@list("C2104" "TX_C0402" list(1827.000000 1238.000000) nil) | 0@@list("C2105" "TX_C0402" list(2056.000000 1450.000000) nil) | 0@@list("C2106" "TX_C0402" list(2056.000000 1368.000000) nil) | 0@@list("C2107" "TX_C0402" list(1861.000000 1313.000000) nil) | 0@@list("C2108" "TX_C0402" list(1661.560000 2243.510000) nil) | 0@@list("C2109" "TX_C0402" list(1661.560000 2282.510000) nil) | 0@@list("C2110" "TX_C0402" list(1741.780000 2103.620000) nil) | 0@@list("C2111" "TX_C0402" list(1741.780000 2140.400000) nil) | 0@@list("C2200" "TX_C0402_T02_H28" list(2246.000000 3320.000000) nil) | 0@@list("C2201" "TX_C0402_T02_H28" list(2513.770000 2722.910000) nil) | 0@@list("C2202" "TX_C0402_T02_H28" list(2318.000000 2339.000000) nil) | 0@@list("C2203" "TX_C0402_T02_H28" list(2477.000000 1485.000000) nil) | 0@@list("C2204" "TX_C0402_T02_H28" list(2532.270000 2078.620000) nil) | 0@@list("C2205" "TX_C0402_T02_H28" list(2522.000000 2268.000000) nil) | 0@@list("C2206" "TX_C0402_T02_H28" list(2245.690000 3003.230000) nil) | 0@@list("C2207" "TX_C0402_T02_H28" list(2556.000000 2648.000000) nil) | 0@@list("C2208" "TX_C0402_T02_H28" list(1532.630000 1242.340000) nil) | 0@@list("C2209" "TX_C0402_T02_H28" list(2172.950000 1269.030000) nil) | 0@@list("C2210" "TX_C0402_T02_H28" list(1733.000000 3819.000000) nil) | 0@@list("C2211" "TX_C0402_T02_H28" list(1849.660000 2172.650000) nil) | 0@@list("C2212" "TX_C0402_T02_H28" list(2055.000000 2291.000000) nil) | 0@@list("C2213" "TX_C0402_T02_H28" list(1735.960000 2396.640000) nil) | 0@@list("C2214" "TX_C0402_T02_H28" list(1737.000000 2315.000000) nil) | 0@@list("C2215" "TX_C0402_T02_H28" list(2045.000000 2971.000000) nil) | 0@@list("C2216" "TX_C0402_T02_H28" list(2046.000000 2930.000000) nil) | 0@@list("C2217" "TX_C0402_T02_H28" list(2051.000000 2766.000000) nil) | 0@@list("C2218" "TX_C0402_T02_H28" list(2039.570000 3624.950000) nil) | 0@@list("C2219" "TX_C0402_T02_H28" list(1870.280000 2014.260000) nil) | 0@@list("C2220" "TX_C0402" list(2248.950000 1269.030000) nil) | 0@@list("C2221" "TX_C0402" list(2211.950000 1269.030000) nil) | 0@@list("C2222" "TX_C0402" list(1607.630000 1242.340000) nil) | 0@@list("C2223" "TX_C0402" list(1571.130000 1242.340000) nil) | 0@@list("C2224" "TX_C0402" list(2548.000000 3193.000000) nil) | 0@@list("C2225" "TX_C0402" list(2386.000000 2649.000000) nil) | 0@@list("C2226" "TX_C0402" list(2558.000000 2570.000000) nil) | 0@@list("C2227" "TX_C0402" list(2200.000000 3708.000000) nil) | 0@@list("C2228" "TX_C0402" list(2266.000000 1760.000000) nil) | 0@@list("C2229" "TX_C0402" list(2555.810000 3611.550000) nil) | 0@@list("C2230" "TX_C0402" list(2541.520000 1789.400000) nil) | 0@@list("C2231" "TX_C0402" list(2385.930000 2606.780000) nil) | 0@@list("C2232" "TX_C0402_T02_H28" list(2014.810000 1267.620000) nil) | 0@@list("C2233" "TX_C0402_T02_H28" list(2055.810000 1267.620000) nil) | 0@@list("C2234" "TX_C0402" list(2069.000000 2709.000000) nil) | 0@@list("C2235" "TX_C0402" list(2055.000000 2252.000000) nil) | 0@@list("C2236" "TX_C0402" list(2073.000000 2347.000000) nil) | 0@@list("C2237" "TX_C0402" list(2050.810000 3217.790000) nil) | 0@@list("C2238" "TX_C0402" list(1838.000000 1912.000000) nil) | 0@@list("C2239" "TX_C0402" list(1771.810000 3378.810000) nil) | 0@@list("C2240" "TX_C0402" list(2141.000000 1450.000000) nil) | 0@@list("C2241" "TX_C0402" list(2045.310000 1930.900000) nil) | 0@@list("C2242" "TX_C0402" list(2514.000000 1209.000000) nil) | 0@@list("C2243" "TX_C0402" list(2550.000000 1209.000000) nil) | 0@@list("C2300" "TX_C0402" list(1096.000000 2105.000000) nil) | 0@@list("C2301" "TX_C0402" list(1343.000000 2110.000000) nil) | 0@@list("C2302" "TX_C0402" list(1605.000000 1442.000000) nil) | 0@@list("C2303" "TX_C0402" list(1185.000000 1270.000000) nil) | 0@@list("C2304" "TX_C0402" list(1551.000000 1744.000000) nil) | 0@@list("C2305" "TX_C0402" list(737.150000 1788.160000) nil) | 0@@list("C2306" "TX_C0402" list(1058.000000 2105.000000) nil) | 0@@list("C2307" "TX_C0402" list(866.000000 1306.000000) nil) | 0@@list("C2308" "TX_C0402" list(1630.000000 1880.100000) nil) | 0@@list("C2309" "TX_C0402" list(740.000000 1573.000000) nil) | 0@@list("C2310" "TX_C0402" list(1147.000000 2070.000000) nil) | 0@@list("C2311" "TX_C0402" list(1604.000000 2128.000000) nil) | 0@@list("C2312" "TX_C0402" list(1511.000000 1961.000000) nil) | 0@@list("C2313" "TX_C0402" list(1661.000000 1497.000000) nil) | 0@@list("C2314" "TX_C0402" list(1560.000000 1607.000000) nil) | 0@@list("C2315" "TX_C0402" list(1402.000000 1267.000000) nil) | 0@@list("C2316" "TX_C0402_T02_H28" list(810.760000 2026.360000) nil) | 0@@list("C2317" "TX_C0402" list(1544.000000 1557.000000) nil) | 0@@list("C2318" "TX_C0402" list(1476.930000 2031.050000) nil) | 0@@list("C2319" "TX_C0402" list(1643.350000 1978.010000) nil) | 0@@list("C2321" "TX_C0402" list(1565.000000 1694.000000) nil) | 0@@list("C2400" "TX_C0402_T02_H26" list(822.000000 1172.000000) nil) | 0@@list("C2401" "TX_C0402" list(1020.000000 2105.000000) nil) | 0@@list("C2500" "TX_C0402" list(3455.000000 1214.650000) nil) | 0@@list("C2501" "TX_C0402_T02_H26" list(3381.000000 1214.350000) nil) | 0@@list("C2502" "TX_C0402_T02_H28" list(3632.500000 768.000000) nil) | 0@@list("C2503" "TX_C0402" list(3494.000000 1214.350000) nil) | 0@@list("C2504" "TX_C0402" list(3419.000000 1214.350000) nil) | 0@@list("C2505" "TX_C0402" list(3458.000000 1420.000000) nil) | 0@@list("C2506" "TX_C0402_T02_H26" list(3632.500000 809.000000) nil) | 0@@list("C2600" "TX_C0402" list(401.000000 3130.000000) nil) | 0@@list("C2601" "TX_C0402_T02_H28" list(442.000000 3130.000000) nil) | 0@@list("C2908" "TX_C0402" list(775.000000 2909.000000) nil) | 0@@list("C2909" "TX_C0402" list(882.000000 2740.000000) nil) | 0@@list("C3003" "TX_C0402" list(2023.000000 4193.500000) nil) | 0@@list("C3100" "TX_C0402_T02_H28" list(8622.000000 1012.000000) nil) | 0@@list("C3101" "TX_C0402" list(8622.000000 1126.000000) nil) | 0@@list("C3102" "TX_C0402" list(8622.000000 1052.000000) nil) | 0@@list("C3103" "TX_C0402" list(8622.000000 1089.000000) nil) | 0@@list("C3108" "TX_C0402_T02_H28" list(8621.000000 894.000000) nil) | 0@@list("C3109" "TX_C0402" list(8622.000000 972.000000) nil) | 0@@list("C3110" "TX_C0402" list(8621.000000 933.000000) nil) | 0@@list("C3111" "TX_C0402" list(8231.000000 827.800000) nil) | 0@@list("C3112" "TX_C0402" list(8231.000000 864.000000) nil) | 0@@list("C3113" "TX_C0402" list(8307.000000 613.200000) nil) | 0@@list("C3114" "TX_C0402" list(8307.000000 577.000000) nil) | 0@@list("C3115" "TX_C0402" list(8521.000000 519.000000) nil) | 0@@list("C3116" "TX_C0402_T02_H28" list(8608.000000 352.000000) nil) | 0@@list("C3117" "TX_C0402" list(8608.000000 313.000000) nil) | 0@@list("C3118" "TX_C0402" list(8608.000000 391.000000) nil) | 0@@list("C3119" "TX_C0402" list(8612.000000 428.000000) nil) | 0@@list("C3605" "TX_C0402" list(3823.000000 3557.000000) nil) | 0@@list("C3701" "TX_C0402" list(225.000000 2453.000000) nil) | 0@@list("C3702" "TX_C0402" list(5738.000000 996.000000) nil) | 0@@list("C3703" "TX_C0402" list(5723.000000 1157.000000) nil) | 0@@list("C3704" "TX_C0402" list(5872.000000 1195.000000) nil) | 0@@list("C3705" "TX_C0402_T02_H28" list(5872.000000 1234.000000) nil) | 0@@list("C3707" "TX_C0402" list(3953.000000 2115.000000) nil) | 0@@list("C3801" "TX_C0402" list(535.000000 1168.000000) nil) | 0@@list("C3804" "TX_C0402_T02_H28" list(496.000000 1521.000000) nil) | 0@@list("C3805" "TX_C0402" list(547.390000 1637.720000) nil) | 0@@list("C3806" "TX_C0402" list(457.000000 1529.000000) nil) | 0@@list("C3807" "TX_C0402" list(464.550000 1686.320000) nil) | 0@@list("C3817" "TX_C0402_T02_H28" list(510.000000 1227.000000) nil) | 0@@list("C3818" "TX_C0603" list(338.610000 1229.710000) nil) | 0@@list("C3821" "TX_C0603" list(264.000000 1279.000000) nil) | 0@@list("C3823" "TX_C0402_T02_H28" list(402.000000 1288.000000) nil) | 0@@list("C3824" "TX_C0402_T02_H28" list(341.000000 1567.000000) nil) | 0@@list("C3832" "TX_C0402_T02_H28" list(538.760000 1528.390000) nil) | 0@@list("C3835" "TX_C0402" list(-30.000000 1035.000000) nil) | 0@@list("C3836" "TX_C0402" list(25.000000 1037.000000) nil) | 0@@list("C3837" "TX_C0402" list(78.190000 1035.880000) nil) | 0@@list("C3838" "TX_C0402" list(121.190000 1035.880000) nil) | 0@@list("C3901" "TX_C0402" list(1303.000000 2506.000000) nil) | 0@@list("C3902" "TX_C0402_T02_H28" list(1224.000000 2506.000000) nil) | 0@@list("C3903" "TX_C0402" list(1024.000000 2621.000000) nil) | 0@@list("C3904" "TX_C0402" list(1352.000000 2688.000000) nil) | 0@@list("C3905" "TX_C0402_T02_H28" list(1024.000000 2540.000000) nil) | 0@@list("C3906" "TX_C0402_T02_H28" list(1352.000000 2768.000000) nil) | 0@@list("C3907" "TX_C0402" list(1201.000000 2826.000000) nil) | 0@@list("C3908" "TX_C0402_T02_H26" list(1352.000000 2727.000000) nil) | 0@@list("C3909" "TX_C0402" list(1353.000000 2543.000000) nil) | 0@@list("C3910" "TX_C0402_T02_H26" list(1264.000000 2506.000000) nil) | 0@@list("C3911" "TX_C0402" list(1352.000000 2651.000000) nil) | 0@@list("C3913" "TX_C0402_T02_H26" list(1024.000000 2582.000000) nil) | 0@@list("C3914" "TX_C0402" list(1165.000000 2826.000000) nil) | 0@@list("C5111" "TX_C0402" list(2934.790000 615.020000) nil) | 0@@list("C5112" "TX_C0402" list(2862.240000 615.620000) nil) | 0@@list("C5113" "TX_C0402" list(2898.430000 615.620000) nil) | 0@@list("C5114" "TX_C0402" list(2789.660000 615.620000) nil) | 0@@list("C5115" "TX_C0402" list(2825.870000 615.620000) nil) | 0@@list("C5116" "TX_C0402" list(2970.910000 615.280000) nil) | 0@@list("C5118" "TX_C0402" list(3043.970000 614.420000) nil) | 0@@list("C5119" "TX_C0402" list(3007.350000 614.290000) nil) | 0@@list("C5120" "TX_C0402" list(3080.880000 614.420000) nil) | 0@@list("C5126" "TX_C0402" list(2089.600000 565.000000) nil) | 0@@list("C5127" "TX_C0402" list(1789.500000 565.000000) nil) | 0@@list("C5128" "TX_C0402" list(1899.000000 565.000000) nil) | 0@@list("C5129" "TX_C0402" list(2017.000000 565.000000) nil) | 0@@list("C5130" "TX_C0402" list(2115.000000 670.000000) nil) | 0@@list("C5131" "TX_C0402" list(297.000000 897.000000) nil) | 0@@list("C5301" "TX_C0402" list(1465.000000 2559.000000) nil) | 0@@list("C5700" "TX_C0402" list(682.000000 3645.000000) nil) | 0@@list("C5701" "TX_C0402" list(967.000000 3641.000000) nil) | 0@@list("C5702" "TX_C0402" list(701.000000 3340.000000) nil) | 0@@list("C5703" "TX_C0402" list(889.000000 3300.000000) nil) | 0@@list("C5704" "TX_C0402" list(1008.000000 3641.000000) nil) | 0@@list("C5705" "TX_C0402" list(1006.000000 3351.000000) nil) | 0@@list("C5706" "TX_C0402" list(1005.000000 3311.000000) nil) | 0@@list("C5707" "TX_C0402" list(852.000000 3302.000000) nil) | 0@@list("C5708" "TX_C0402" list(814.000000 3302.000000) nil) | 0@@list("C5709" "TX_C0402" list(1000.000000 3392.000000) nil) | 0@@list("C5710" "TX_C0402" list(1000.000000 3429.000000) nil) | 0@@list("C5711" "TX_C0402" list(1080.000000 3448.000000) nil) | 0@@list("C5712" "TX_C0402" list(1080.000000 3485.000000) nil) | 0@@list("C5713" "TX_C0402" list(1006.000000 3503.000000) nil) | 0@@list("C5714" "TX_C0402" list(1006.000000 3541.000000) nil) | 0@@list("C5715" "TX_C0402" list(1100.000000 3571.000000) nil) | 0@@list("C5716" "TX_C0402" list(1100.000000 3609.000000) nil) | 0@@list("C5717" "TX_C0402" list(692.000000 3793.000000) nil) | 0@@list("C5718" "TX_C0402" list(655.000000 3793.000000) nil) | 0@@list("C5719" "TX_C0402" list(366.000000 3580.000000) nil) | 0@@list("C5720" "TX_C0402" list(366.000000 3539.000000) nil) | 0@@list("C5721" "TX_C0402" list(366.000000 3459.000000) nil) | 0@@list("C5722" "TX_C0402" list(366.000000 3498.000000) nil) | 0@@list("C5800" "TX_C0402" list(1405.000000 3096.500000) nil) | 0@@list("C5801" "TX_C0402" list(1355.000000 3080.000000) nil) | 0@@list("C5802" "TX_C0402" list(1286.000000 3113.000000) nil) | 0@@list("C5803" "TX_C0402" list(1304.000000 3063.000000) nil) | 0@@list("C5804" "TX_C0402" list(1430.000000 3453.300000) nil) | 0@@list("C5805" "TX_C0402" list(1576.090000 3248.530000) nil) | 0@@list("C5806" "TX_C0402" list(1576.000000 3357.000000) nil) | 0@@list("C5807" "TX_C0402" list(1578.000000 3403.000000) nil) | 0@@list("C5811" "TX_C0402" list(1561.000000 3306.000000) nil) | 0@@list("C5812" "TX_C0402" list(1598.000000 3306.000000) nil) | 0@@list("C5813" "TX_C0402" list(863.000000 2462.000000) nil) | 0@@list("C5814" "TX_C0402" list(881.000000 2678.000000) nil) | 0@@list("C5906" "TX_C0402" list(532.000000 3749.000000) nil) | 0@@list("C5912" "TX_C0402" list(494.000000 3749.000000) nil) | 0@@list("C6000" "TX_C0402" list(5267.990000 3555.000000) nil) | 0@@list("C6001" "TX_C0402" list(5293.990000 3529.000000) nil) | 0@@list("C6002" "TX_C0402" list(5346.000000 3477.000000) nil) | 0@@list("C6003" "TX_C0402" list(5320.100000 3502.810000) nil) | 0@@list("C6004" "TX_C0402" list(5241.860000 3581.060000) nil) | 0@@list("C6005" "TX_C0402" list(5215.990000 3607.000000) nil) | 0@@list("C6006" "TX_C0402" list(5180.990000 3635.000000) nil) | 0@@list("C6007" "TX_C0402" list(5155.260000 3660.600000) nil) | 0@@list("C6201" "TX_C0402" list(5895.490000 3875.500000) nil) | 0@@list("C6202" "TX_C0402" list(5802.000000 3769.000000) nil) | 0@@list("C6203" "TX_C0402" list(5799.000000 3891.000000) nil) | 0@@list("C6300" "TX_C0402_H20" list(6892.000000 3398.000000) nil) | 0@@list("C6303" "TX_C0402" list(6370.000000 3365.500000) nil) | 0@@list("C6304" "TX_C0402" list(6407.000000 3327.000000) nil) | 0@@list("C6305" "TX_C0402" list(6955.000000 3324.000000) nil) | 0@@list("C6615" "TX_C0402" list(7074.000000 4355.000000) nil) | 0@@list("C6616" "TX_C0402" list(7058.000000 3965.000000) nil) | 0@@list("C6617" "TX_C0402" list(7679.000000 4329.000000) nil) | 0@@list("C6618" "TX_C0402" list(7676.000000 3992.000000) nil) | 0@@list("C6619" "TX_C0402" list(7477.680000 4453.000000) nil) | 0@@list("C6620" "TX_C0402" list(7048.000000 3610.000000) nil) | 0@@list("C6621" "TX_C0402" list(7057.000000 3266.000000) nil) | 0@@list("C6622" "TX_C0402" list(7691.000000 3527.000000) nil) | 0@@list("C6623" "TX_C0402" list(7680.000000 3171.000000) nil) | 0@@list("C6624" "TX_C0402" list(7401.000000 3072.000000) nil) | 0@@list("C6625" "TX_C0402" list(7038.000000 4355.000000) nil) | 0@@list("C6626" "TX_C0402" list(7058.000000 3925.000000) nil) | 0@@list("C6627" "TX_C0402" list(7679.000000 4370.000000) nil) | 0@@list("C6628" "TX_C0402" list(7676.000000 3950.000000) nil) | 0@@list("C6629" "TX_C0402_T02_H28" list(7691.000000 3488.000000) nil) | 0@@list("C6632" "TX_C0402" list(7680.000000 3132.000000) nil) | 0@@list("C6633" "TX_C0402" list(7057.000000 3229.000000) nil) | 0@@list("C6636" "TX_C0402" list(7048.000000 3652.000000) nil) | 0@@list("C6637" "TX_C0402" list(7691.000000 3563.000000) nil) | 0@@list("C6700" "TX_C0402" list(6026.000000 3946.000000) nil) | 0@@list("C6701" "TX_C0402" list(6042.510000 3710.500000) nil) | 0@@list("C6702" "TX_C0402" list(6152.510000 3933.500000) nil) | 0@@list("C6703" "TX_C0402" list(6014.500000 3650.510000) nil) | 0@@list("C6704" "TX_C0402" list(6265.500000 3676.510000) nil) | 0@@list("C6705" "TX_C0402" list(6100.270000 3556.490000) nil) | 0@@list("C6706" "TX_C0402" list(6220.750000 3556.820000) nil) | 0@@list("C6707" "TX_C0402" list(6088.210000 3825.820000) nil) | 0@@list("C6708" "TX_C0402" list(6051.790000 3871.180000) nil) | 0@@list("C6709" "TX_C0402" list(6231.790000 3917.180000) nil) | 0@@list("C6710" "TX_C0402" list(6144.820000 3896.790000) nil) | 0@@list("C6711" "TX_C0402" list(6189.210000 3824.820000) nil) | 0@@list("C6712" "TX_C0402" list(6289.000000 3828.000000) nil) | 0@@list("C6713" "TX_C0402" list(6239.000000 3842.000000) nil) | 0@@list("C6714" "TX_C0402" list(6158.570000 3609.030000) nil) | 0@@list("C6715" "TX_C0402" list(5974.050000 3572.320000) nil) | 0@@list("C6716" "TX_C0402" list(6126.720000 3749.900000) nil) | 0@@list("C6717" "TX_C0402" list(6154.990000 3560.570000) nil) | 0@@list("C6718" "TX_C0402_T02_H28" list(6374.500000 3531.500000) nil) | 0@@list("C6719" "TX_C0402_T02_H28" list(5862.220000 3688.980000) nil) | 0@@list("C6720" "TX_C0402_T02_H28" list(5737.180000 3772.350000) nil) | 0@@list("C6721" "TX_C0402" list(5867.500000 4497.510000) nil) | 0@@list("C6722" "TX_C0402_T02_H28" list(5962.510000 3770.500000) nil) | 0@@list("C6723" "TX_C0402_T02_H28" list(6401.180000 4129.350000) nil) | 0@@list("C6724" "TX_C0402_T02_H28" list(6061.160000 3504.720000) nil) | 0@@list("C6725" "TX_C0402_T02_H28" list(6226.500000 3676.510000) nil) | 0@@list("C6726" "TX_C0402_T02_H28" list(6057.500000 3638.510000) nil) | 0@@list("C6727" "TX_C0402_T02_H28" list(6288.000000 3567.000000) nil) | 0@@list("C6728" "TX_C0402_T02_H28" list(6151.000000 3825.000000) nil) | 0@@list("C6729" "TX_C0402_T02_H28" list(6258.000000 3751.000000) nil) | 0@@list("C6730" "TX_C0402_T02_H28" list(6191.510000 3751.500000) nil) | 0@@list("C6731" "TX_C0402_T02_H28" list(6167.500000 3679.510000) nil) | 0@@list("C6732" "TX_C0402" list(6374.500000 3493.000000) nil) | 0@@list("C6733" "TX_C0402" list(5802.490000 3731.500000) nil) | 0@@list("C6734" "TX_C0402" list(5822.500000 4497.510000) nil) | 0@@list("C6735" "TX_C0402" list(6474.510000 4159.500000) nil) | 0@@list("C6736" "TX_C0402" list(6316.490000 4103.500000) nil) | 0@@list("C6737" "TX_C0402" list(6268.500000 3941.510000) nil) | 0@@list("C6738" "TX_C0402" list(6216.490000 4006.500000) nil) | 0@@list("C6739" "TX_C0402" list(6369.510000 4065.500000) nil) | 0@@list("C6740" "TX_C0402" list(5897.510000 3785.500000) nil) | 0@@list("C6741" "TX_C0402" list(6216.510000 3968.500000) nil) | 0@@list("C6742" "TX_C0402" list(6030.790000 3573.530000) nil) | 0@@list("C6743" "TX_C0402" list(6355.510000 3884.500000) nil) | 0@@list("C6744" "TX_C0402" list(6350.510000 3921.500000) nil) | 0@@list("C6745" "TX_C0402" list(6366.510000 3570.500000) nil) | 0@@list("C6746" "TX_C0402_T02_H28" list(6357.490000 3683.500000) nil) | 0@@list("C6747" "TX_C0402" list(6356.510000 3739.500000) nil) | 0@@list("C6748" "TX_C0402" list(6356.510000 3776.500000) nil) | 0@@list("C6749" "TX_C0402" list(6461.000000 3631.000000) nil) | 0@@list("C6750" "TX_C0402" list(6547.500000 4174.490000) nil) | 0@@list("C6751" "TX_C0402" list(6437.180000 4004.210000) nil) | 0@@list("C6752" "TX_C0402" list(6382.510000 3823.500000) nil) | 0@@list("C6753" "TX_C0402" list(6474.490000 3730.500000) nil) | 0@@list("C6754" "TX_C0402" list(6282.510000 3991.500000) nil) | 0@@list("C6800" "TX_C0402" list(7690.000000 3368.000000) nil) | 0@@list("C6802" "TX_C0402" list(7077.000000 4144.000000) nil) | 0@@list("C6907" "TX_C0402" list(5913.450000 3609.080000) nil) | 0@@list("C6908" "TX_C0402" list(5989.000000 3946.000000) nil) | 0@@list("C7100" "TX_C0402_T02_H28" list(5897.490000 3746.500000) nil) | 0@@list("C7101" "TX_C0402_T02_H28" list(6216.510000 4066.500000) nil) | 0@@list("C7102" "TX_C0402" list(5897.510000 3824.500000) nil) | 0@@list("C7103" "TX_C0402" list(6316.490000 4028.500000) nil) | 0@@list("D2600" "TX_ESD_2P_33_39X24_H24" list(303.000000 3298.000000) nil) | 0@@list("D2900" "TX_ESD_2P_33_39X24_H24" list(385.000000 3005.000000) nil) | 0@@list("D2901" "TX_ESD_2P_33_39X24_H24" list(385.000000 2860.000000) nil) | 0@@list("D2902" "TX_SOT323" list(485.000000 2925.000000) nil) | 0@@list("D5100" "TX_ESD_2P_33_39X24_H24" list(1790.000000 670.000000) nil) | 0@@list("D5101" "TX_ESD_2P_33_39X24_H24" list(1885.000000 670.000000) nil) | 0@@list("D5102" "TX_ESD_2P_33_39X24_H24" list(2015.000000 670.000000) nil) | 0@@list("D5103" "TX_ESD_2P_33_39X24_H24" list(2065.000000 670.000000) nil) | 0@@list("D5702" "TX_ESD_2P_33_39X24_H24" list(240.000000 3777.000000) nil) | 0@@list("D5703" "TX_ESD_2P_33_39X24_H24" list(240.000000 3695.000000) nil) | 0@@list("D5704" "TX_ESD_2P_33_39X24_H24" list(317.000000 3663.000000) nil) | 0@@list("D5707" "TX_ESD_2P_33_39X24_H24" list(238.000000 3884.000000) nil) | 0@@list("F2600" "TX_POLYSWITCH_2P_87X59" list(543.000000 3134.000000) nil) | 0@@list("J5300" "TX_FPC_12P_20_2HD_RA_PANA" list(3293.000000 432.820000) nil) | 0@@list("J5301" "TX_FPC_12P_20_2HD_RA_PANA" list(1525.180000 2747.000000) nil) | 0@@list("L3800" "TX_L0603_T015" list(544.380000 1122.860000) nil) | 0@@list("L3805" "TX_L0603_T015" list(594.050000 1680.920000) nil) | 0@@list("L5701" "TX_CHOKE_4P_49X39_MURA" list(321.000000 3729.000000) nil) | 0@@list("L5702" "TX_CHOKE_4P_49X39_MURA" list(491.000000 3619.000000) nil) | 0@@list("L5703" "TX_CHOKE_4P_49X39_MURA" list(473.000000 3354.000000) nil) | 0@@list("L5704" "TX_CHOKE_4P_49X39_MURA" list(509.000000 3535.000000) nil) | 0@@list("L5705" "TX_CHOKE_4P_49X39_MURA" list(647.000000 3461.000000) nil) | 0@@list("L6700" "TX_L0402_T02" list(5697.280000 3820.100000) nil) | 0@@list("L6701" "TX_L0402_T02" list(5916.000000 4497.510000) nil) | 0@@list("L6702" "TX_L0402" list(6437.800000 3504.000000) nil) | 0@@list("PC7600" "TX_C0402_H22" list(2060.000000 4548.000000) nil) | 0@@list("PC7602" "TX_C0402" list(1973.000000 4550.000000) nil) | 0@@list("PC7603" "TX_C0402" list(1190.000000 3778.000000) nil) | 0@@list("PC7604" "TX_C0402" list(2500.000000 4096.000000) nil) | 0@@list("PC7606" "TX_C0603_T015_H37" list(2105.000000 4548.000000) nil) | 0@@list("PC7607" "TX_C0603_T015_H37" list(1401.000000 4192.000000) nil) | 0@@list("PC7609" "TX_C0603" list(985.000000 4224.000000) nil) | 0@@list("PC7610" "TX_C0402" list(1295.000000 4263.560000) nil) | 0@@list("PC7611" "TX_C0603_T015_H37" list(1226.500000 4091.510000) nil) | 0@@list("PC7612" "TX_C0603_T015_H37" list(1257.000000 4163.000000) nil) | 0@@list("PC7807" "TX_C0402" list(6779.000000 2347.500000) nil) | 0@@list("PC7808" "TX_C0402" list(6742.000000 2346.000000) nil) | 0@@list("PC7809" "TX_C0402" list(6880.000000 2091.000000) nil) | 0@@list("PC7810" "TX_C0402_H22" list(6880.000000 2128.000000) nil) | 0@@list("PC7811" "TX_C0402" list(6840.000000 2010.000000) nil) | 0@@list("PC7813" "TX_C0402" list(6840.000000 1945.000000) nil) | 0@@list("PC7819" "TX_C0402" list(6678.000000 2438.000000) nil) | 0@@list("PC7821" "TX_C0402" list(6883.000000 2225.000000) nil) | 0@@list("PC7824" "TX_C0402" list(6572.000000 2378.000000) nil) | 0@@list("PC7825" "TX_C0402" list(6746.000000 2213.000000) nil) | 0@@list("PC7826" "TX_C0402" list(6880.000000 2165.000000) nil) | 0@@list("PC7827" "TX_C0402" list(6372.500000 2076.000000) nil) | 0@@list("PC7828" "TX_C0402_H22" list(6409.000000 2076.000000) nil) | 0@@list("PC7829" "TX_C0402" list(6285.000000 2084.000000) nil) | 0@@list("PC7830" "TX_C0402" list(6553.000000 1993.000000) nil) | 0@@list("PC7832" "TX_C0402" list(6787.000000 1929.000000) nil) | 0@@list("PC7836" "TX_C0402" list(6402.000000 2201.000000) nil) | 0@@list("PC7914" "TX_C0402" list(5729.000000 2215.000000) nil) | 0@@list("PC7915" "TX_C0402" list(5632.060000 2778.000000) nil) | 0@@list("PC8004" "TX_C0402" list(5681.060000 1794.000000) nil) | 0@@list("PC8012" "TX_C0402" list(5652.000000 3071.000000) nil) | 0@@list("PC8013" "TX_C0402" list(5690.060000 3120.000000) nil) | 0@@list("PC8100" "TX_C0603_T02_H39" list(4624.000000 2517.000000) nil) | 0@@list("PC8101" "TX_C0603_T02_H39" list(4335.000000 2519.500000) nil) | 0@@list("PC8102" "TX_C0603_T02_H39" list(4769.000000 2480.000000) nil) | 0@@list("PC8103" "TX_C0603_T02_H39" list(4776.000000 2571.500000) nil) | 0@@list("PC8104" "TX_C0603_T02_H39" list(4388.120000 2519.500000) nil) | 0@@list("PC8107" "TX_C0603_T02_H39" list(4475.620000 2415.000000) nil) | 0@@list("PC8108" "TX_C0603_T02_H39" list(4422.120000 2415.000000) nil) | 0@@list("PC8109" "TX_C0603_T02_H39" list(4367.120000 2415.000000) nil) | 0@@list("PC8110" "TX_C0603_T02_H39" list(4314.620000 2415.000000) nil) | 0@@list("PC8111" "TX_C0603_T02_H39" list(5450.000000 1709.000000) nil) | 0@@list("PC8112" "TX_C0603_T02_H39" list(5450.000000 1655.000000) nil) | 0@@list("PC8113" "TX_C0603_T02_H39" list(5445.000000 1600.000000) nil) | 0@@list("PC8114" "TX_C0603_T02_H39" list(5358.000000 1608.000000) nil) | 0@@list("PC8115" "TX_C0603_T02_H39" list(5450.000000 1762.000000) nil) | 0@@list("PC8116" "TX_C0603_T02_H39" list(5436.000000 1834.000000) nil) | 0@@list("PC8117" "TX_C0603_T02_H39" list(5381.000000 1845.000000) nil) | 0@@list("PC8118" "TX_C0603_T02_H39" list(4821.120000 2480.000000) nil) | 0@@list("PC8119" "TX_C0603_T02_H39" list(4418.120000 2310.000000) nil) | 0@@list("PC8120" "TX_C0603_T02_H39" list(4365.120000 2310.000000) nil) | 0@@list("PC8121" "TX_C0603_T02_H39" list(4312.120000 2310.000000) nil) | 0@@list("PC8122" "TX_C0603_T02_H39" list(4771.880000 2390.000000) nil) | 0@@list("PC8124" "TX_C0603_T02_H39" list(4471.120000 2310.000000) nil) | 0@@list("PC8125" "TX_C0603_T02_H39" list(4366.120000 2205.000000) nil) | 0@@list("PC8126" "TX_C0603_T02_H39" list(4523.120000 2205.000000) nil) | 0@@list("PC8127" "TX_C0603_T02_H39" list(4471.120000 2205.000000) nil) | 0@@list("PC8128" "TX_C0603_T02_H39" list(5447.100000 1961.000000) nil) | 0@@list("PC8129" "TX_C0603_T02_H39" list(4313.120000 2205.000000) nil) | 0@@list("PC8130" "TX_C0603_T02_H39" list(5376.560000 1951.000000) nil) | 0@@list("PC8131" "TX_C0603_T02_H39" list(5324.560000 1951.000000) nil) | 0@@list("PC8132" "TX_C0603_T02_H39" list(5457.000000 2015.000000) nil) | 0@@list("PC8133" "TX_C0603_T02_H39" list(4418.620000 2205.000000) nil) | 0@@list("PC8134" "TX_C0603_T02_H39" list(4261.120000 2205.000000) nil) | 0@@list("PC8135" "TX_C0603_T02_H39" list(4441.000000 2519.500000) nil) | 0@@list("PC8136" "TX_C0603_T02_H39" list(5457.000000 2068.000000) nil) | 0@@list("PC8137" "TX_C0603_T02_H39" list(4443.000000 2750.000000) nil) | 0@@list("PC8138" "TX_C0603_T02_H39" list(4390.000000 2750.000000) nil) | 0@@list("PC8139" "TX_C0603_T02_H39" list(4337.000000 2750.000000) nil) | 0@@list("PC8141" "TX_C0603_T02_H39" list(4674.000000 3305.000000) nil) | 0@@list("PC8142" "TX_C0603_T02_H39" list(4443.120000 2622.500000) nil) | 0@@list("PC8143" "TX_C0603_T02_H39" list(4334.880000 2622.500000) nil) | 0@@list("PC8144" "TX_C0603_T02_H39" list(4284.120000 2750.000000) nil) | 0@@list("PC8145" "TX_C0603_T02_H39" list(4180.500000 2781.000000) nil) | 0@@list("PC8146" "TX_C0603_T02_H39" list(4180.000000 2708.000000) nil) | 0@@list("PC8150" "TX_C0603_T02_H39" list(4390.120000 2622.500000) nil) | 0@@list("PC8153" "TX_C0603_T02_H39" list(4281.880000 2622.500000) nil) | 0@@list("PC8154" "TX_C0603_T02_H39" list(4171.620000 2654.000000) nil) | 0@@list("PC8155" "TX_C0603_T02_H39" list(4188.000000 3402.000000) nil) | 0@@list("PC8157" "TX_C0603_T02_H39" list(4532.120000 2102.000000) nil) | 0@@list("PC8158" "TX_C0603_T02_H39" list(4790.120000 2222.500000) nil) | 0@@list("PC8159" "TX_C0603_T02_H39" list(4477.120000 2102.000000) nil) | 0@@list("PC8160" "TX_C0603_T02_H39" list(4844.120000 2222.500000) nil) | 0@@list("PC8161" "TX_C0603_T02_H39" list(5304.060000 1623.000000) nil) | 0@@list("PC8163" "TX_C0603_T02_H39" list(4564.000000 3412.000000) nil) | 0@@list("PC8165" "TX_C0603_T02_H39" list(4188.940000 3455.000000) nil) | 0@@list("PC8168" "TX_C0603_T02_H39" list(4475.000000 3689.000000) nil) | 0@@list("PC8169" "TX_C0603_T02_H39" list(4674.000000 3414.000000) nil) | 0@@list("PC8170" "TX_C0603_T02_H39" list(4693.000000 3689.000000) nil) | 0@@list("PC8171" "TX_C0603_T02_H39" list(4639.000000 3689.000000) nil) | 0@@list("PC8172" "TX_C0603_T02_H39" list(4564.000000 3305.000000) nil) | 0@@list("PC8173" "TX_C0603_T02_H39" list(4900.000000 3689.000000) nil) | 0@@list("PC8174" "TX_C0603_T02_H39" list(4845.000000 3689.000000) nil) | 0@@list("PC8175" "TX_C0603_T02_H39" list(4564.000000 3358.000000) nil) | 0@@list("PC8178" "TX_C0603_T02_H39" list(5272.000000 1951.000000) nil) | 0@@list("PC8179" "TX_C0603_T02_H39" list(4282.000000 2519.500000) nil) | 0@@list("PC8180" "TX_C0603_T02_H39" list(5489.000000 2121.000000) nil) | 0@@list("PC8181" "TX_C0603_T02_H39" list(5489.000000 2176.000000) nil) | 0@@list("PC8182" "TX_C0603_T02_H39" list(5489.000000 2231.000000) nil) | 0@@list("PC8183" "TX_C0603_T02_H39" list(4674.000000 3360.000000) nil) | 0@@list("PC8185" "TX_C0603_T02_H39" list(4530.000000 3689.000000) nil) | 0@@list("PC8186" "TX_C0603_T02_H39" list(4585.000000 3689.000000) nil) | 0@@list("PC8600" "TX_C0402" list(3770.000000 4230.000000) nil) | 0@@list("PC8601" "TX_C0402" list(3613.000000 4165.000000) nil) | 0@@list("PC8604" "TX_C0402" list(3059.000000 4367.000000) nil) | 0@@list("PC8605" "TX_C0402" list(3877.000000 4043.000000) nil) | 0@@list("PC8609" "TX_C0402" list(3895.000000 4171.000000) nil) | 0@@list("PC8610" "TX_C0402" list(3033.000000 4536.000000) nil) | 0@@list("PC8611" "TX_C0402" list(3839.000000 3971.000000) nil) | 0@@list("PC8612" "TX_C0402" list(3890.000000 3957.000000) nil) | 0@@list("PC8613" "TX_C0402_T02_H28" list(3581.000000 4022.000000) nil) | 0@@list("PC8614" "TX_C0402_T02_H28" list(3645.000000 4000.000000) nil) | 0@@list("PC8615" "TX_C0402_T02_H28" list(3645.000000 3959.800000) nil) | 0@@list("PC8616" "TX_C0402" list(3759.000000 3956.000000) nil) | 0@@list("PC8621" "TX_C0402" list(4027.000000 4113.000000) nil) | 0@@list("PC8801" "TX_C0402" list(1393.000000 1029.000000) nil) | 0@@list("PC8802" "TX_C0402" list(1398.000000 874.500000) nil) | 0@@list("PC8803" "TX_C0402" list(1411.000000 962.500000) nil) | 0@@list("PC8810" "TX_C0402" list(4152.000000 4702.000000) nil) | 0@@list("PC8811" "TX_C0402" list(4018.000000 4752.000000) nil) | 0@@list("PC8814" "TX_C0402" list(1564.000000 787.000000) nil) | 0@@list("PC8921" "TX_C0402" list(7728.000000 2584.000000) nil) | 0@@list("PC9000" "TX_C0402" list(1222.000000 3113.000000) nil) | 0@@list("PC9001" "TX_C0402" list(1335.000000 3015.000000) nil) | 0@@list("PC9002" "TX_C0402" list(1079.000000 3000.500000) nil) | 0@@list("PC9003" "TX_C0402" list(1172.000000 2917.000000) nil) | 0@@list("PC9004" "TX_C0402" list(1236.000000 2917.000000) nil) | 0@@list("PC9005" "TX_C0402" list(1633.000000 3004.000000) nil) | 0@@list("PC9007" "TX_C0402" list(1092.000000 3037.000000) nil) | 0@@list("PC9205" "TX_C0402" list(5453.000000 1202.000000) nil) | 0@@list("PC9507" "TX_C0402" list(6187.790000 2823.700000) nil) | 0@@list("PC9515" "TX_C0402" list(6431.000000 4620.000000) nil) | 0@@list("PC9516" "TX_C0603" list(6728.000000 4731.000000) nil) | 0@@list("PC9604" "TX_C0402" list(5199.000000 4339.000000) nil) | 0@@list("PC9625" "TX_C0402" list(4865.000000 4596.000000) nil) | 0@@list("PC9804" "TX_C0402_H22" list(7338.000000 2878.000000) nil) | 0@@list("PC9808" "TX_C0402" list(7325.000000 3020.000000) nil) | 0@@list("PC9809" "TX_C0402" list(7323.000000 2762.000000) nil) | 0@@list("PC9811" "TX_C0402" list(1158.000000 3113.000000) nil) | 0@@list("PD7602" "TX_ESD_2P_33_39X24_COLAY" list(1595.000000 4015.500000) nil) | 0@@list("PL7600" "TX_L0603_T015" list(1499.000000 4260.000000) nil) | 0@@list("PL7601" "TX_L0603_T015" list(1599.000000 4258.000000) nil) | 0@@list("PL7602" "TX_L0603_T015" list(1910.000000 4288.000000) nil) | 0@@list("PL7603" "TX_L0603_T015" list(1205.000000 4163.000000) nil) | 0@@list("PL7604" "TX_L0603_T015" list(1150.000000 4163.000000) nil) | 0@@list("PL7605" "TX_L0402_H24" list(1595.000000 4056.000000) nil) | 0@@list("PL7606" "TX_L0603_T015" list(1086.000000 4199.000000) nil) | 0@@list("PQ7600" "TX_SI7501DN_H44" list(1606.500000 4530.480000) nil) | 0@@list("PQ7603" "TX_SC70_S6_H47" list(2381.000000 4140.000000) nil) | 0@@list("PQ7607" "TX_SI7501DN_H44" list(1865.000000 4536.000000) nil) | 0@@list("PQ7608" "TX_SC70_S6_H47" list(973.000000 4332.500000) nil) | 0@@list("PQ7612" "TX_SC70_S6_H47" list(1125.900000 4471.490000) nil) | 0@@list("PQ7613" "TX_SI7501DN_H44" list(1273.980000 4399.920000) nil) | 0@@list("PQ7614" "TX_SI7501DN_H44" list(1414.010000 4468.580000) nil) | 0@@list("PR7601" "TX_R0402" list(2528.000000 4602.000000) nil) | 0@@list("PR7611" "TX_R0402" list(1270.000000 3778.000000) nil) | 0@@list("PR7612" "TX_R0402" list(1230.000000 3778.000000) nil) | 0@@list("PR7613" "TX_R0402" list(1220.000000 3607.000000) nil) | 0@@list("PR7614" "TX_R0402_0OHM" list(1297.000000 3644.000000) nil) | 0@@list("PR7615" "TX_R0402" list(2398.000000 4257.000000) nil) | 0@@list("PR7616" "TX_R0402" list(2472.000000 4257.000000) nil) | 0@@list("PR7617" "TX_R0402" list(2463.000000 4096.000000) nil) | 0@@list("PR7618" "TX_R0402" list(2538.000000 4096.000000) nil) | 0@@list("PR7620" "TX_R0402" list(2688.000000 4415.000000) nil) | 0@@list("PR7621" "TX_R0402" list(2688.000000 4478.500000) nil) | 0@@list("PR7622" "TX_R0402" list(2672.000000 4602.000000) nil) | 0@@list("PR7623" "TX_R0402" list(2736.000000 4602.000000) nil) | 0@@list("PR7624" "TX_R0402" list(2688.000000 4542.000000) nil) | 0@@list("PR7625" "TX_R0402" list(2009.550000 4550.000000) nil) | 0@@list("PR7626" "TX_R0402" list(1992.000000 4601.000000) nil) | 0@@list("PR7627" "TX_R0402" list(2463.000000 4477.000000) nil) | 0@@list("PR7628" "TX_R0402" list(2245.000000 4462.000000) nil) | 0@@list("PR7629" "TX_R0805_H26" list(1111.000000 4285.000000) nil) | 0@@list("PR7633" "TX_R0402" list(1143.000000 4397.000000) nil) | 0@@list("PR7634" "TX_R0402" list(1295.000000 4227.510000) nil) | 0@@list("PR7635" "TX_R0402" list(1076.000000 4398.000000) nil) | 0@@list("PR7636" "TX_R0402" list(1238.500000 4519.000000) nil) | 0@@list("PR7637" "TX_R0402" list(1256.000000 4575.000000) nil) | 0@@list("PR7638" "TX_R0402" list(917.000000 4395.000000) nil) | 0@@list("PR7639" "TX_R0402" list(981.000000 4396.000000) nil) | 0@@list("PR7640" "TX_R0402" list(1036.500000 4529.000000) nil) | 0@@list("PR7641" "TX_R0402" list(904.000000 4445.000000) nil) | 0@@list("PR7643" "TX_R0402" list(2423.000000 4555.000000) nil) | 0@@list("PR7644" "TX_R0402_0OHM" list(999.000000 4169.000000) nil) | 0@@list("PR7645" "TX_R0402" list(1316.000000 4506.000000) nil) | 0@@list("PR7646" "TX_R0402" list(2607.500000 4602.000000) nil) | 0@@list("PR7705" "TX_R0603_H24" list(7504.000000 1420.000000) nil) | 0@@list("PR7706" "TX_R0402" list(7586.000000 1420.000000) nil) | 0@@list("PR7711" "TX_R0402_0OHM" list(7603.000000 1192.000000) nil) | 0@@list("PR7805" "TX_R0402" list(5501.000000 2876.000000) nil) | 0@@list("PR7807" "TX_R0402" list(6890.000000 2053.800000) nil) | 0@@list("PR7808" "TX_R0402_0OHM" list(6814.000000 2477.000000) nil) | 0@@list("PR7809" "TX_R0402" list(6815.000000 2060.000000) nil) | 0@@list("PR7810" "TX_R0402" list(6803.000000 2010.000000) nil) | 0@@list("PR7811" "TX_R0402_0OHM" list(6759.000000 2474.000000) nil) | 0@@list("PR7819" "TX_R0402_0OHM" list(6641.000000 2484.000000) nil) | 0@@list("PR7823" "TX_R0402" list(6691.000000 2350.000000) nil) | 0@@list("PR7824" "TX_R0402" list(6599.000000 2441.000000) nil) | 0@@list("PR7825" "TX_R0402" list(6746.000000 2176.800000) nil) | 0@@list("PR7826" "TX_R0402" list(6767.000000 2127.000000) nil) | 0@@list("PR7827" "TX_R0402" list(6285.000000 2048.000000) nil) | 0@@list("PR7828" "TX_R0402" list(6635.000000 2359.000000) nil) | 0@@list("PR7831" "TX_R0402" list(6336.000000 2076.000000) nil) | 0@@list("PR7832" "TX_R0402" list(6506.000000 2115.000000) nil) | 0@@list("PR7833" "TX_R0402" list(6500.000000 2078.000000) nil) | 0@@list("PR7835" "TX_R0402" list(6516.000000 1993.000000) nil) | 0@@list("PR7838" "TX_R0402" list(6521.000000 1943.000000) nil) | 0@@list("PR7839" "TX_R0402" list(6506.000000 2152.000000) nil) | 0@@list("PR7840" "TX_R0402_SHORT" list(6474.000000 2200.000000) nil) | 0@@list("PR7842" "TX_R0402" list(6730.000000 1975.000000) nil) | 0@@list("PR7843" "TX_R0402" list(6505.000000 2240.000000) nil) | 0@@list("PR7844" "TX_R0402_0OHM" list(6286.000000 2127.000000) nil) | 0@@list("PR7845" "TX_R0402" list(6617.000000 1916.000000) nil) | 0@@list("PR7846" "TX_R0402" list(6381.000000 2259.000000) nil) | 0@@list("PR7847" "TX_R0402" list(6412.000000 2145.000000) nil) | 0@@list("PR7848" "TX_R0402" list(6655.000000 1916.000000) nil) | 0@@list("PR7850" "TX_R0402_0OHM" list(6555.000000 2255.000000) nil) | 0@@list("PR7853" "TX_R0402" list(6817.000000 2383.000000) nil) | 0@@list("PR7856" "TX_R0402" list(6572.000000 2341.000000) nil) | 0@@list("PR7914" "TX_R0805_0OHM_H26" list(5639.060000 2196.000000) nil) | 0@@list("PR7916" "TX_R0805_0OHM_H26" list(5615.000000 2701.060000) nil) | 0@@list("PR8001" "TX_R0805_0OHM_H26" list(5754.060000 1715.000000) nil) | 0@@list("PR8002" "TX_R0402" list(5681.060000 1758.000000) nil) | 0@@list("PR8009" "TX_R0402" list(5464.000000 2910.000000) nil) | 0@@list("PR8010" "TX_R0402" list(5427.000000 2910.000000) nil) | 0@@list("PR8012" "TX_R0805_0OHM_H26" list(5587.940000 3133.000000) nil) | 0@@list("PR8600" "TX_R0603_H24" list(3814.000000 4223.000000) nil) | 0@@list("PR8601" "TX_R0805_0OHM_H26" list(3585.000000 4114.000000) nil) | 0@@list("PR8602" "TX_R0402" list(3895.000000 4133.000000) nil) | 0@@list("PR8603" "TX_R0402_SHORT" list(3975.000000 4010.000000) nil) | 0@@list("PR8604" "TX_R0402" list(3975.000000 3973.000000) nil) | 0@@list("PR8605" "TX_R0402" list(3059.000000 4330.000000) nil) | 0@@list("PR8606" "TX_R0402" list(3895.000000 4096.000000) nil) | 0@@list("PR8608" "TX_R0402" list(3033.000000 4573.000000) nil) | 0@@list("PR8609" "TX_R0402" list(3803.000000 3971.000000) nil) | 0@@list("PR8610" "TX_R0402" list(3890.000000 3993.000000) nil) | 0@@list("PR8611" "TX_R0402" list(3732.000000 4230.000000) nil) | 0@@list("PR8612" "TX_R0402_SHORT" list(3709.000000 3975.000000) nil) | 0@@list("PR8614" "TX_R0402_SHORT" list(3976.000000 4096.000000) nil) | 0@@list("PR8615" "TX_R0402_0OHM" list(3874.390000 3822.400000) nil) | 0@@list("PR8616" "TX_R0402" list(3836.390000 3820.900000) nil) | 0@@list("PR8617" "TX_R0805_0OHM_H26" list(2969.620000 4324.840000) nil) | 0@@list("PR8618" "TX_R0805_0OHM_H26" list(3008.620000 4481.840000) nil) | 0@@list("PR8802" "TX_R0402" list(1337.000000 962.500000) nil) | 0@@list("PR8803" "TX_R0402" list(1374.000000 962.500000) nil) | 0@@list("PR8804" "TX_R0402" list(1398.000000 912.000000) nil) | 0@@list("PR8805" "TX_R0402" list(4091.000000 4752.000000) nil) | 0@@list("PR8807" "TX_R0402" list(4152.000000 4660.000000) nil) | 0@@list("PR8810" "TX_R0402" list(4173.000000 4752.000000) nil) | 0@@list("PR8812" "TX_R0402" list(1616.000000 773.000000) nil) | 0@@list("PR8813" "TX_R0402" list(1616.000000 708.000000) nil) | 0@@list("PR8814" "TX_R0402" list(1481.000000 790.000000) nil) | 0@@list("PR8900" "TX_R0603_H24" list(7507.450000 2620.160000) nil) | 0@@list("PR8912" "TX_R0402" list(7664.000000 2532.000000) nil) | 0@@list("PR9000" "TX_R0402_SHORT" list(1415.000000 2975.000000) nil) | 0@@list("PR9001" "TX_R0402" list(1333.000000 2973.000000) nil) | 0@@list("PR9004" "TX_R0402_SHORT" list(1513.000000 3039.000000) nil) | 0@@list("PR9005" "TX_R0402" list(1420.000000 3016.000000) nil) | 0@@list("PR9200" "TX_R0402_SHORT" list(5432.000000 1133.000000) nil) | 0@@list("PR9201" "TX_R0402" list(5373.000000 1119.000000) nil) | 0@@list("PR9205" "TX_R0402_SHORT" list(5406.000000 1272.000000) nil) | 0@@list("PR9207" "TX_R0402" list(5370.000000 1272.000000) nil) | 0@@list("PR9500" "TX_R0402" list(6241.010000 2771.000000) nil) | 0@@list("PR9503" "TX_R0402" list(6214.000000 2797.000000) nil) | 0@@list("PR9505" "TX_R0402" list(6288.000000 4569.000000) nil) | 0@@list("PR9506" "TX_R0805_H26" list(6623.000000 4718.000000) nil) | 0@@list("PR9508" "TX_R0402" list(6493.000000 4640.000000) nil) | 0@@list("PR9801" "TX_R0402_0OHM" list(7338.000000 2920.000000) nil) | 0@@list("PR9805" "TX_R0402" list(7338.000000 2840.000000) nil) | 0@@list("PR9809" "TX_R0402" list(7365.000000 3020.000000) nil) | 0@@list("PR9814" "TX_R0402" list(7362.000000 2762.000000) nil) | 0@@list("PR9815" "TX_R0402_SHORT" list(7399.000000 2762.000000) nil) | 0@@list("PT7701" "NB_TPC26T_50" list(7551.000000 1346.000000) nil) | 0@@list("PT8700" "NB_TPC28T_68" list(6555.000000 1782.000000) nil) | 0@@list("PT8704" "NB_TPC28T_68" list(6613.000000 1864.000000) nil) | 0@@list("PT9500" "NB_TPC28T_68" list(6287.000000 2758.000000) nil) | 0@@list("PT9501" "NB_TPC28T_68" list(6113.000000 2845.000000) nil) | 0@@list("PT9502" "NB_TPC28T_68" list(6031.000000 2889.000000) nil) | 0@@list("PT9503" "NB_TPC28T_68" list(6088.000000 2931.000000) nil) | 0@@list("PT9504" "NB_TPC28T_68" list(5976.000000 2848.000000) nil) | 0@@list("PT9505" "NB_TPC28T_68" list(5776.000000 2556.000000) nil) | 0@@list("PT9508" "NB_TPC28T_68" list(6355.000000 4575.000000) nil) | 0@@list("PT9513" "NB_TPC28T_68" list(5784.000000 2885.000000) nil) | 0@@list("PT9514" "NB_TPC28T_68" list(5783.000000 2814.000000) nil) | 0@@list("PT9800" "NB_TPC28T_68" list(7479.000000 2942.000000) nil) | 0@@list("PU8600" "TX_QFN_20P_16_S118_P_H31_4V" list(3745.000000 4105.000000) nil) | 0@@list("PU9000" "TX_SC70_S5_TI" list(1639.000000 3101.000000) nil) | 0@@list("PU9001" "TX_DFN_10P_16_122X83_P_COLA" list(1200.200000 3015.000000) nil) | 0@@list("Q2400" "TX_SC70_S6_H47" list(565.000000 2304.000000) nil) | 0@@list("Q2401" "TX_SC70_S6_H47" list(860.000000 1090.000000) nil) | 0@@list("Q2600" "TX_SOT23_2D4_122X55_H43" list(695.000000 3026.000000) nil) | 0@@list("Q2601" "TX_SOT23_2D4_H44" list(838.000000 3052.000000) nil) | 0@@list("Q2900" "TX_SC70_S6_H47" list(838.000000 2841.000000) nil) | 0@@list("Q2901" "TX_SC70_S6_H47" list(948.000000 2925.000000) nil) | 0@@list("R0401" "TX_R0402" list(4893.000000 3283.000000) nil) | 0@@list("R0402" "TX_R0402" list(4929.000000 3283.000000) nil) | 0@@list("R0404" "TX_R0402" list(4085.000000 1963.000000) nil) | 0@@list("R0405" "TX_R0402" list(3956.000000 1971.000000) nil) | 0@@list("R0406" "TX_R0402" list(4832.000000 3283.000000) nil) | 0@@list("R0407" "TX_R0402" list(4615.880000 2843.720000) nil) | 0@@list("R0408" "TX_R0402_SHORT" list(4754.500000 1406.000000) nil) | 0@@list("R0411" "TX_R0402" list(4756.000000 1258.000000) nil) | 0@@list("R0413" "TX_R0402" list(4730.320000 2690.000000) nil) | 0@@list("R0414" "TX_R0402" list(4758.000000 1331.000000) nil) | 0@@list("R0415" "TX_R0402" list(4795.000000 1399.000000) nil) | 0@@list("R0500" "TX_R0402" list(4122.000000 1945.000000) nil) | 0@@list("R0501" "TX_R0402" list(4048.000000 1963.000000) nil) | 0@@list("R0502" "TX_R0402" list(3995.000000 1971.000000) nil) | 0@@list("R0600" "TX_R0402_0OHM" list(4028.960000 2486.590000) nil) | 0@@list("R0606" "TX_R0402" list(4694.000000 2306.000000) nil) | 0@@list("R0607" "TX_R0402" list(4732.000000 2250.000000) nil) | 0@@list("R0702" "TX_R0402" list(6857.000000 2275.000000) nil) | 0@@list("R0703" "TX_R0402" list(6913.000000 2262.000000) nil) | 0@@list("R0900" "TX_R0402" list(4733.500000 2830.000000) nil) | 0@@list("R1002" "TX_R0402" list(3908.000000 1452.000000) nil) | 0@@list("R1003" "TX_R0402" list(3982.000000 1452.000000) nil) | 0@@list("R1004" "TX_R0402" list(3871.000000 1452.000000) nil) | 0@@list("R1005" "TX_R0402" list(4788.000000 2323.000000) nil) | 0@@list("R1006" "TX_R0402" list(4854.920000 2316.000000) nil) | 0@@list("R1007" "TX_R0402" list(3516.120000 1965.500000) nil) | 0@@list("R1008" "TX_R0402_0OHM" list(3436.880000 1917.000000) nil) | 0@@list("R1010" "TX_R0402" list(3945.000000 1452.000000) nil) | 0@@list("R1017" "TX_R0402" list(4658.000000 1217.000000) nil) | 0@@list("R1018" "TX_R0402" list(4722.000000 1218.990000) nil) | 0@@list("R1022" "TX_R0402" list(4215.000000 1285.000000) nil) | 0@@list("R1023" "TX_R0402" list(4224.400000 1375.200000) nil) | 0@@list("R1024" "TX_R0402" list(4251.000000 1285.000000) nil) | 0@@list("R1025" "TX_R0402" list(4287.000000 1285.000000) nil) | 0@@list("R1026" "TX_R0402" list(4323.000000 1285.000000) nil) | 0@@list("R1027" "TX_R0402" list(4261.000000 1375.000000) nil) | 0@@list("R1028" "TX_R0402" list(4286.200000 1484.300000) nil) | 0@@list("R1029" "TX_R0402" list(4305.000000 1377.300000) nil) | 0@@list("R1030" "TX_R0402" list(3834.000000 1452.000000) nil) | 0@@list("R1100" "TX_R0402" list(4709.500000 1383.500000) nil) | 0@@list("R1101" "TX_R0402" list(4652.000000 1391.000000) nil) | 0@@list("R1106" "TX_R0402" list(4178.300000 1338.900000) nil) | 0@@list("R1110" "TX_R0402" list(3508.000000 1712.000000) nil) | 0@@list("R1111" "TX_R0402" list(3472.000000 1712.000000) nil) | 0@@list("R1112" "TX_R0402" list(3435.000000 1712.000000) nil) | 0@@list("R1113" "TX_R0402" list(3394.000000 1712.000000) nil) | 0@@list("R1114" "TX_R0402" list(4614.200000 1369.990000) nil) | 0@@list("R1200" "TX_R0402" list(3538.000000 1549.000000) nil) | 0@@list("R1204" "TX_R0402" list(3437.000000 1370.000000) nil) | 0@@list("R1205" "TX_R0402" list(5275.000000 1544.000000) nil) | 0@@list("R1208" "TX_R0402" list(3363.500000 1371.000000) nil) | 0@@list("R1209" "TX_R0402" list(3400.000000 1371.000000) nil) | 0@@list("R1210" "TX_R0402" list(4359.000000 1285.000000) nil) | 0@@list("R1211" "TX_R0402_SHORT" list(4836.000000 1298.000000) nil) | 0@@list("R1212" "TX_R0402" list(4836.000000 1233.000000) nil) | 0@@list("R1217" "TX_R0402_0OHM" list(2567.000000 562.000000) nil) | 0@@list("R1218" "TX_R0402" list(2378.000000 779.000000) nil) | 0@@list("R1220" "TX_R0402" list(2300.000000 765.000000) nil) | 0@@list("R1221" "TX_R0402_0OHM" list(2235.000000 765.000000) nil) | 0@@list("R1226" "TX_R0402" list(3359.500000 1307.000000) nil) | 0@@list("R1229" "TX_R0402_0OHM" list(3356.000000 1451.000000) nil) | 0@@list("R1503" "TX_R0402" list(4468.000000 1154.000000) nil) | 0@@list("R1507" "TX_R0402" list(4142.000000 1339.000000) nil) | 0@@list("R1508" "TX_R0402" list(4143.600000 1410.400000) nil) | 0@@list("R1517" "TX_R0402" list(3445.000000 1528.000000) nil) | 0@@list("R1519" "TX_R0402" list(4463.000000 1298.500000) nil) | 0@@list("R1604" "TX_R0402_SHORT" list(4520.000000 1309.000000) nil) | 0@@list("R1606" "TX_R0402_SHORT" list(4751.000000 1920.000000) nil) | 0@@list("R1607" "TX_R0402" list(4395.500000 1245.000000) nil) | 0@@list("R1608" "TX_R0402" list(4207.400000 1491.600000) nil) | 0@@list("R1610" "TX_R0402_SHORT" list(4750.000000 2083.000000) nil) | 0@@list("R1611" "TX_R0402_SHORT" list(4790.000000 1994.000000) nil) | 0@@list("R1612" "TX_R0402_SHORT" list(4877.000000 1298.000000) nil) | 0@@list("R1615" "TX_R0402_0OHM" list(4578.000000 1369.990000) nil) | 0@@list("R1621" "TX_R0402_SHORT" list(5045.000000 1319.000000) nil) | 0@@list("R1622" "TX_R0402_SHORT" list(4264.000000 1934.000000) nil) | 0@@list("R1623" "TX_R0402_SHORT" list(4093.000000 1193.000000) nil) | 0@@list("R1624" "TX_R0402_SHORT" list(4528.000000 1396.000000) nil) | 0@@list("R1800" "TX_R0402_SHORT" list(2362.000000 567.000000) nil) | 0@@list("R1801" "TX_R0402_SHORT" list(2325.000000 567.000000) nil) | 0@@list("R1802" "TX_R0402" list(2420.000000 567.000000) nil) | 0@@list("R1803" "TX_R0402_SHORT" list(2486.000000 571.000000) nil) | 0@@list("R1804" "TX_R0402" list(2567.000000 680.000000) nil) | 0@@list("R1805" "TX_R0402_SHORT" list(2523.000000 571.000000) nil) | 0@@list("R1806" "TX_R0402_0OHM" list(2515.000000 666.000000) nil) | 0@@list("R1807" "TX_R0402" list(2528.000000 779.000000) nil) | 0@@list("R1914" "TX_R0402_SHORT" list(2735.000000 922.000000) nil) | 0@@list("R1915" "TX_R0402" list(2808.010000 952.000000) nil) | 0@@list("R1916" "TX_R0402_SHORT" list(1545.000000 1112.000000) nil) | 0@@list("R1917" "TX_R0402" list(2772.000000 952.000000) nil) | 0@@list("R1918" "TX_R0402" list(2747.000000 1081.990000) nil) | 0@@list("R1919" "TX_R0402" list(2720.000000 866.000000) nil) | 0@@list("R1920" "TX_R0402" list(3254.000000 647.000000) nil) | 0@@list("R1921" "TX_R0402" list(2836.000000 810.000000) nil) | 0@@list("R2000" "TX_R0402" list(2234.000000 2728.000000) nil) | 0@@list("R2001" "TX_R0402_0OHM" list(2234.000000 2765.000000) nil) | 0@@list("R2002" "TX_R0402" list(2386.000000 2569.000000) nil) | 0@@list("R2003" "TX_R0402" list(2211.810000 2093.620000) nil) | 0@@list("R2004" "TX_R0402" list(2211.810000 2167.620000) nil) | 0@@list("R2005" "TX_R0402" list(2211.810000 2205.620000) nil) | 0@@list("R2006" "TX_R0402" list(2127.310000 2155.620000) nil) | 0@@list("R2100" "TX_R0402" list(1755.810000 2455.700000) nil) | 0@@list("R2101" "TX_R0402" list(1742.000000 2250.000000) nil) | 0@@list("R2102" "TX_R0402" list(1742.000000 2213.000000) nil) | 0@@list("R2103" "TX_R0402" list(1741.810000 2176.620000) nil) | 0@@list("R2104" "TX_R0402" list(1661.560000 2319.510000) nil) | 0@@list("R2300" "TX_R0402" list(1365.000000 1267.000000) nil) | 0@@list("R2301" "TX_R0402_SHORT" list(1685.000000 1741.000000) nil) | 0@@list("R2302" "TX_R0402_SHORT" list(1562.000000 1794.000000) nil) | 0@@list("R2305" "TX_R0402" list(1674.000000 1672.000000) nil) | 0@@list("R2306" "TX_R0402" list(1631.000000 1817.000000) nil) | 0@@list("R2307" "TX_R0402_SHORT" list(1563.000000 2128.000000) nil) | 0@@list("R2308" "TX_R0402_SHORT" list(1559.000000 1866.500000) nil) | 0@@list("R2309" "TX_R0402" list(1632.200000 2431.220000) nil) | 0@@list("R2310" "TX_R0402" list(1632.000000 2505.000000) nil) | 0@@list("R2311" "TX_R0402" list(1607.500000 1557.000000) nil) | 0@@list("R2312" "TX_R0402" list(1588.000000 1493.500000) nil) | 0@@list("R2313" "TX_R0402" list(1624.000000 1493.500000) nil) | 0@@list("R2314" "TX_R0402" list(1632.000000 1607.000000) nil) | 0@@list("R2315" "TX_R0402" list(1596.000000 1607.000000) nil) | 0@@list("R2316" "TX_R0402" list(1305.000000 2110.000000) nil) | 0@@list("R2317" "TX_R0402" list(1264.000000 2091.000000) nil) | 0@@list("R2318" "TX_R0402" list(1283.000000 2309.000000) nil) | 0@@list("R2319" "TX_R0402" list(1313.910000 2205.350000) nil) | 0@@list("R2320" "TX_R0402" list(963.000000 1258.000000) nil) | 0@@list("R2321" "TX_R0402_SHORT" list(1439.000000 1267.000000) nil) | 0@@list("R2322" "TX_R0402" list(979.000000 2190.000000) nil) | 0@@list("R2323" "TX_R0402_SHORT" list(975.000000 2107.000000) nil) | 0@@list("R2324" "TX_R0402" list(1635.000000 1727.500000) nil) | 0@@list("R2325" "TX_R0402" list(1635.000000 1764.000000) nil) | 0@@list("R2326" "TX_R0402" list(1214.000000 2093.000000) nil) | 0@@list("R2328" "TX_R0402_0OHM" list(1565.000000 1658.000000) nil) | 0@@list("R2329" "TX_R0402_0OHM" list(1575.000000 1942.000000) nil) | 0@@list("R2330" "TX_R0402_0OHM" list(1577.000000 1983.000000) nil) | 0@@list("R2331" "TX_R0402" list(738.790000 1611.390000) nil) | 0@@list("R2332" "TX_R0402" list(1560.000000 1830.000000) nil) | 0@@list("R2333" "TX_R0402" list(1258.000000 1236.000000) nil) | 0@@list("R2334" "TX_R0402" list(738.000000 1994.000000) nil) | 0@@list("R2335" "TX_R0402" list(740.000000 1702.500000) nil) | 0@@list("R2336" "TX_R0402_SHORT" list(739.000000 1648.000000) nil) | 0@@list("R2337" "TX_R0402" list(1172.000000 1174.000000) nil) | 0@@list("R2338" "TX_R0402" list(1135.000000 1174.000000) nil) | 0@@list("R2339" "TX_R0402" list(1537.000000 2417.000000) nil) | 0@@list("R2341" "TX_R0402" list(1381.000000 2111.000000) nil) | 0@@list("R2342" "TX_R0402" list(1501.600000 2135.600000) nil) | 0@@list("R2343" "TX_R0402" list(1550.000000 1495.000000) nil) | 0@@list("R2344" "TX_R0402" list(915.000000 1260.000000) nil) | 0@@list("R2345" "TX_R0402_SHORT" list(737.000000 1893.000000) nil) | 0@@list("R2346" "TX_R0402_SHORT" list(934.000000 2103.000000) nil) | 0@@list("R2347" "TX_R0402" list(737.000000 1751.000000) nil) | 0@@list("R2348" "TX_R0402" list(1495.780000 2416.400000) nil) | 0@@list("R2349" "TX_R0402" list(1056.000000 1262.000000) nil) | 0@@list("R2351" "TX_R0402" list(1636.000000 1390.000000) nil) | 0@@list("R2400" "TX_R0402_SHORT" list(1221.000000 1237.000000) nil) | 0@@list("R2401" "TX_R0402_SHORT" list(494.000000 2190.000000) nil) | 0@@list("R2402" "TX_R0402_SHORT" list(495.000000 2259.000000) nil) | 0@@list("R2403" "TX_R0402_SHORT" list(316.000000 1012.000000) nil) | 0@@list("R2404" "TX_R0402_0OHM" list(479.000000 2418.000000) nil) | 0@@list("R2405" "TX_R0402" list(495.000000 2330.000000) nil) | 0@@list("R2406" "TX_R0402" list(653.000000 2278.000000) nil) | 0@@list("R2407" "TX_R0402" list(659.000000 2319.000000) nil) | 0@@list("R2408" "TX_R0402" list(653.000000 2237.000000) nil) | 0@@list("R2409" "TX_R0402_SHORT" list(866.000000 1212.000000) nil) | 0@@list("R2410" "TX_R0402_SHORT" list(891.000000 1171.000000) nil) | 0@@list("R2411" "TX_R0402" list(802.000000 1212.000000) nil) | 0@@list("R2412" "TX_R0402" list(1061.000000 2190.000000) nil) | 0@@list("R2413" "TX_R0402" list(1020.000000 2190.000000) nil) | 0@@list("R2414" "TX_R0402" list(991.000000 1056.000000) nil) | 0@@list("R2423" "TX_R0402" list(1007.000000 1258.000000) nil) | 0@@list("R2424" "TX_R0402" list(280.000000 1012.000000) nil) | 0@@list("R2500" "TX_R0402_0OHM" list(3493.000000 1115.650000) nil) | 0@@list("R2501" "TX_R0402" list(3581.000000 1452.650000) nil) | 0@@list("R2502" "TX_R0402" list(3654.000000 1452.650000) nil) | 0@@list("R2503" "TX_R0402" list(3730.000000 1452.650000) nil) | 0@@list("R2504" "TX_R0402" list(3508.000000 1452.650000) nil) | 0@@list("R2505" "TX_R0402" list(3544.500000 1452.650000) nil) | 0@@list("R2506" "TX_R0402" list(3617.500000 1452.650000) nil) | 0@@list("R2507" "TX_R0402" list(3693.000000 1452.650000) nil) | 0@@list("R2508" "TX_R0402" list(3767.000000 1452.650000) nil) | 0@@list("R2509" "TX_R0402" list(3420.000000 1122.650000) nil) | 0@@list("R2510" "TX_R0402_SHORT" list(3343.000000 1214.350000) nil) | 0@@list("R2511" "TX_R0402_SHORT" list(3494.000000 1279.000000) nil) | 0@@list("R2512" "TX_R0402" list(3457.000000 1122.650000) nil) | 0@@list("R2513" "TX_R0402" list(3346.000000 1144.650000) nil) | 0@@list("R2514" "TX_R0402" list(3383.000000 1124.650000) nil) | 0@@list("R2600" "TX_R0402" list(922.000000 3101.000000) nil) | 0@@list("R2601" "TX_R0402" list(656.000000 3128.000000) nil) | 0@@list("R2602" "TX_R0402" list(351.000000 3287.000000) nil) | 0@@list("R2900" "TX_R0402" list(813.000000 2747.000000) nil) | 0@@list("R2901" "TX_R0402" list(913.000000 2813.000000) nil) | 0@@list("R2903" "TX_R0402" list(622.000000 2821.000000) nil) | 0@@list("R2904" "TX_R0402" list(622.000000 2784.800000) nil) | 0@@list("R2905" "TX_R0402" list(654.000000 2729.000000) nil) | 0@@list("R2906" "TX_R0402" list(654.000000 2692.800000) nil) | 0@@list("R2907" "TX_R0402" list(654.000000 2633.000000) nil) | 0@@list("R2908" "TX_R0402" list(654.000000 2596.800000) nil) | 0@@list("R2909" "TX_R0402" list(655.990000 2912.000000) nil) | 0@@list("R2910" "TX_R0402" list(656.000000 2875.800000) nil) | 0@@list("R2911" "TX_R0402" list(385.000000 2905.000000) nil) | 0@@list("R2912" "TX_R0402" list(384.000000 2950.000000) nil) | 0@@list("R2913" "TX_R0402" list(957.000000 3024.000000) nil) | 0@@list("R3004" "TX_R0402_SHORT" list(2019.000000 4153.500000) nil) | 0@@list("R3009" "TX_R0402" list(2008.000000 4058.000000) nil) | 0@@list("R3102" "TX_R0402_0OHM" list(8424.000000 888.000000) nil) | 0@@list("R3103" "TX_R0402_SHORT" list(8445.000000 512.000000) nil) | 0@@list("R3104" "TX_R0402_SHORT" list(8521.000000 482.000000) nil) | 0@@list("R3105" "TX_R0402" list(8370.000000 429.000000) nil) | 0@@list("R3106" "TX_R0402_0OHM" list(8314.000000 411.000000) nil) | 0@@list("R3107" "TX_R0402" list(8370.000000 356.600000) nil) | 0@@list("R3113" "TX_R0402" list(8522.000000 445.000000) nil) | 0@@list("R3114" "TX_R0402" list(8370.000000 392.800000) nil) | 0@@list("R3116" "TX_R0402_0OHM" list(8505.000000 922.000000) nil) | 0@@list("R3609" "TX_R0402" list(2222.000000 1186.000000) nil) | 0@@list("R3612" "TX_R0402" list(2171.000000 1159.000000) nil) | 0@@list("R3613" "TX_R0402" list(3689.000000 3647.000000) nil) | 0@@list("R3614" "TX_R0402" list(3663.000000 3445.000000) nil) | 0@@list("R3700" "TX_R0402" list(5723.000000 1120.000000) nil) | 0@@list("R3701" "TX_R0402" list(5723.000000 1083.000000) nil) | 0@@list("R3702" "TX_R0402_SHORT" list(5872.000000 1272.000000) nil) | 0@@list("R3703" "TX_R0402" list(5723.000000 1046.000000) nil) | 0@@list("R3704" "TX_R0402_SHORT" list(5822.000000 1229.000000) nil) | 0@@list("R3705" "TX_R0402_SHORT" list(5723.000000 1211.000000) nil) | 0@@list("R3706" "TX_R0402_SHORT" list(5872.000000 1322.000000) nil) | 0@@list("R3707" "TX_R0402" list(125.000000 2472.000000) nil) | 0@@list("R3709" "TX_R0402" list(3497.000000 2056.000000) nil) | 0@@list("R3801" "TX_R0402" list(336.730000 1376.340000) nil) | 0@@list("R3804" "TX_R0402_0OHM" list(401.000000 1667.000000) nil) | 0@@list("R3806" "TX_R0603_0OHM_H24" list(-22.000000 877.480000) nil) | 0@@list("R3807" "TX_R0603_0OHM_H24" list(32.000000 877.480000) nil) | 0@@list("R3812" "TX_R0603_0OHM_H24" list(84.000000 876.480000) nil) | 0@@list("R3813" "TX_R0603_0OHM_H24" list(138.000000 876.480000) nil) | 0@@list("R3814" "TX_R0402" list(341.000000 1606.000000) nil) | 0@@list("R3815" "TX_R0402_0OHM" list(407.000000 2083.000000) nil) | 0@@list("R3816" "TX_R0402_0OHM" list(357.280000 1444.770000) nil) | 0@@list("R3817" "TX_R0402_0OHM" list(79.000000 1721.000000) nil) | 0@@list("R3819" "TX_R0402_0OHM" list(354.000000 2438.000000) nil) | 0@@list("R3821" "TX_R0402_0OHM" list(277.810000 1169.190000) nil) | 0@@list("R3826" "TX_R0402" list(271.000000 1106.000000) nil) | 0@@list("R3827" "TX_R0402_0OHM" list(401.040000 1704.320000) nil) | 0@@list("R3901" "TX_R0402_SHORT" list(1274.000000 2826.000000) nil) | 0@@list("R3902" "TX_R0402_SHORT" list(1186.000000 2506.000000) nil) | 0@@list("R3903" "TX_R0402_0OHM" list(1150.000000 2506.000000) nil) | 0@@list("R3904" "TX_R0402_0OHM" list(1353.000000 2615.000000) nil) | 0@@list("R3905" "TX_R0402_SHORT" list(1128.000000 2827.000000) nil) | 0@@list("R3907" "TX_R0402" list(1020.010000 2791.300000) nil) | 0@@list("R3908" "TX_R0402_SHORT" list(1020.010000 2718.500000) nil) | 0@@list("R3909" "TX_R0402" list(1009.010000 2682.000000) nil) | 0@@list("R3910" "TX_R0402" list(1076.000000 2506.010000) nil) | 0@@list("R3911" "TX_R0402" list(1114.000000 2506.000000) nil) | 0@@list("R3912" "TX_R0402_0OHM" list(1024.000000 2501.000000) nil) | 0@@list("R3913" "TX_R0402" list(1020.000000 2755.000000) nil) | 0@@list("R3914" "TX_R0402_0OHM" list(1353.000000 2579.000000) nil) | 0@@list("R3915" "TX_R0402_0OHM" list(1238.000000 2826.000000) nil) | 0@@list("R3916" "TX_R0402" list(1089.000000 2827.000000) nil) | 0@@list("R3917" "TX_R0402_0OHM" list(1323.500000 2843.000000) nil) | 0@@list("R3918" "TX_R0402_0OHM" list(1323.500000 2807.000000) nil) | 0@@list("R5000" "TX_R0402" list(289.000000 3878.000000) nil) | 0@@list("R5001" "TX_R0402" list(299.000000 3915.000000) nil) | 0@@list("R5002" "TX_R0402" list(730.000000 3793.000000) nil) | 0@@list("R5004" "TX_R0402" list(1028.000000 3928.000000) nil) | 0@@list("R5102" "TX_R0402" list(1943.500000 565.000000) nil) | 0@@list("R5103" "TX_R0402" list(1825.990000 565.000000) nil) | 0@@list("R5104" "TX_R0402" list(1862.500000 565.000000) nil) | 0@@list("R5105" "TX_R0402" list(2053.400000 565.000000) nil) | 0@@list("R5106" "TX_R0402" list(2125.800000 565.000000) nil) | 0@@list("R5107" "TX_R0402" list(1480.000000 520.000000) nil) | 0@@list("R5108" "TX_R0402" list(1980.000000 565.000000) nil) | 0@@list("R5109" "TX_R0402_SHORT" list(1477.000000 590.000000) nil) | 0@@list("R5704" "TX_R0402" list(663.930000 3313.460000) nil) | 0@@list("R5705" "TX_R0402" list(685.500000 3263.000000) nil) | 0@@list("R5706" "TX_R0402_0OHM" list(777.000000 3302.000000) nil) | 0@@list("R5707" "TX_R0402" list(740.000000 3302.000000) nil) | 0@@list("R5710" "TX_R0402" list(833.000000 3707.000000) nil) | 0@@list("R5711" "TX_R0402" list(762.000000 3707.000000) nil) | 0@@list("R5714" "TX_R0402_SHORT" list(926.000000 3300.000000) nil) | 0@@list("R5716" "TX_R0402_0OHM" list(1170.000000 3408.000000) nil) | 0@@list("R5717" "TX_R0402" list(1090.000000 3368.000000) nil) | 0@@list("R5718" "TX_R0402" list(1090.000000 3408.000000) nil) | 0@@list("R5719" "TX_R0402_SHORT" list(885.000000 3704.000000) nil) | 0@@list("R5720" "TX_R0402_0OHM" list(1170.000000 3368.000000) nil) | 0@@list("R5725" "TX_R0402" list(751.000000 3670.000000) nil) | 0@@list("R5800" "TX_R0402" list(824.000000 2582.000000) nil) | 0@@list("R5801" "TX_R0402_SHORT" list(824.000000 2647.000000) nil) | 0@@list("R5802" "TX_R0402" list(1578.000000 3440.000000) nil) | 0@@list("R5803" "TX_R0402" list(1430.000000 3526.000000) nil) | 0@@list("R5804" "TX_R0402" list(1430.000000 3489.500000) nil) | 0@@list("R5805" "TX_R0402_SHORT" list(1245.000000 3465.000000) nil) | 0@@list("R5806" "TX_R0402" list(1286.000000 3465.000000) nil) | 0@@list("R5807" "TX_R0402" list(1197.000000 3275.000000) nil) | 0@@list("R5808" "TX_R0402" list(1488.000000 3108.000000) nil) | 0@@list("R5809" "TX_R0402" list(1613.000000 3208.000000) nil) | 0@@list("R5810" "TX_R0402" list(1323.000000 3465.000000) nil) | 0@@list("R5811" "TX_R0402" list(1360.000000 3465.000000) nil) | 0@@list("R5812" "TX_R0402" list(1366.000000 3526.500000) nil) | 0@@list("R5816" "TX_R0402_0OHM" list(1405.000000 3060.000000) nil) | 0@@list("R5817" "TX_R0402" list(1136.000000 3820.000000) nil) | 0@@list("R5818" "TX_R0402" list(1158.500000 3150.000000) nil) | 0@@list("R5821" "TX_R0402" list(1202.000000 3311.000000) nil) | 0@@list("R5822" "TX_R0402" list(1197.000000 3203.000000) nil) | 0@@list("R5823" "TX_R0402" list(1197.000000 3239.000000) nil) | 0@@list("R5826" "TX_R0402" list(1518.000000 3466.000000) nil) | 0@@list("R5827" "TX_R0402" list(1481.000000 3466.000000) nil) | 0@@list("R5904" "TX_R0402" list(457.000000 3749.000000) nil) | 0@@list("R5906" "TX_R0402" list(570.000000 3749.000000) nil) | 0@@list("R5907" "TX_R0402" list(283.000000 3795.000000) nil) | 0@@list("R6200" "TX_R0402" list(5945.000000 3938.000000) nil) | 0@@list("R6202" "TX_R0402" list(5895.000000 3914.000000) nil) | 0@@list("R6203" "TX_R0402" list(5895.000000 3951.000000) nil) | 0@@list("R6204" "TX_R0402" list(5813.000000 3820.000000) nil) | 0@@list("R6205" "TX_R0402" list(5762.000000 3817.000000) nil) | 0@@list("R6206" "TX_R0402" list(5831.000000 3934.000000) nil) | 0@@list("R6207" "TX_R0402" list(5762.000000 3854.000000) nil) | 0@@list("R6300" "TX_R0402" list(6889.000000 3324.000000) nil) | 0@@list("R6301" "TX_R0402" list(6888.000000 3453.000000) nil) | 0@@list("R6302" "TX_R0402" list(6889.000000 3361.000000) nil) | 0@@list("R6308" "TX_R0402" list(6370.000000 3302.500000) nil) | 0@@list("R6309" "TX_R0402" list(6387.000000 3239.500000) nil) | 0@@list("R6803" "TX_R0402" list(7063.000000 4080.000000) nil) | 0@@list("R6805" "TX_R0402" list(7689.990000 3328.000000) nil) | 0@@list("R6808" "TX_R0402" list(7002.000000 4144.000000) nil) | 0@@list("R6809" "TX_R0402" list(7039.000000 4144.000000) nil) | 0@@list("R6818" "TX_R0402" list(7678.000000 3243.000000) nil) | 0@@list("R6908" "TX_R0402_0OHM" list(6271.000000 3482.000000) nil) | 0@@list("R6934" "TX_R0402" list(6108.000000 3452.990000) nil) | 0@@list("R6935" "TX_R0402" list(6138.000000 3482.990000) nil) | 0@@list("R6936" "TX_R0402" list(6426.000000 3390.000000) nil) | 0@@list("R6937" "TX_R0402" list(5372.000000 3451.000000) nil) | 0@@list("R6938" "TX_R0402" list(5786.000000 3152.000000) nil) | 0@@list("R6939" "TX_R0402" list(5697.000000 4355.000000) nil) | 0@@list("R6940" "TX_R0402" list(5659.000000 4355.000000) nil) | 0@@list("R6941" "TX_R0402" list(5418.000000 3401.000000) nil) | 0@@list("RN5701" "TX_2R4P0402_47X55_COLAY" list(321.000000 3729.000000) nil) | 0@@list("RN5702" "TX_2R4P0402_47X55_COLAY" list(491.000000 3619.000000) nil) | 0@@list("RN5703" "TX_2R4P0402_47X55_COLAY" list(473.000000 3353.000000) nil) | 0@@list("RN5704" "TX_2R4P0402_47X55_COLAY" list(509.000000 3535.000000) nil) | 0@@list("RN5705" "TX_2R4P0402_47X55_COLAY" list(647.000000 3461.000000) nil) | 0@@list("T0400" "NB_TPC26T_50" list(4797.000000 2844.500000) nil) | 0@@list("T0401" "NB_TPC26T_50" list(5269.000000 2754.000000) nil) | 0@@list("T0402" "NB_TPC26T_50" list(5267.000000 2819.000000) nil) | 0@@list("T0403" "NB_TPC26T_50" list(5320.000000 2829.000000) nil) | 0@@list("T0405" "NB_TPC26T_50" list(4858.000000 2786.500000) nil) | 0@@list("T0406" "NB_TPC26T_50" list(4760.500000 2775.500000) nil) | 0@@list("T0409" "NB_TPC26T_50" list(4671.000000 1270.000000) nil) | 0@@list("T0411" "NB_TPC26T_50" list(4792.000000 2719.000000) nil) | 0@@list("T0412" "NB_TPC26T_50" list(4807.500000 2795.000000) nil) | 0@@list("T0902" "NB_TPC26T_50" list(4104.750000 2841.410000) nil) | 0@@list("T0903" "NB_TPC26T_50" list(5268.000000 2877.000000) nil) | 0@@list("T0905" "NB_TPC26T_50" list(4045.000000 2811.000000) nil) | 0@@list("T0908" "NB_TPC26T_50" list(4859.320000 3370.040000) nil) | 0@@list("T0909" "NB_TPC26T_50" list(4888.320000 3434.040000) nil) | 0@@list("T0910" "NB_TPC26T_50" list(4770.320000 3274.040000) nil) | 0@@list("T0911" "NB_TPC26T_50" list(4749.320000 3373.040000) nil) | 0@@list("T0912" "NB_TPC26T_50" list(4788.320000 3421.040000) nil) | 0@@list("T0913" "NB_TPC26T_50" list(4844.320000 3473.040000) nil) | 0@@list("T0914" "NB_TPC26T_50" list(4742.320000 3473.040000) nil) | 0@@list("T0915" "NB_TPC26T_50" list(4762.320000 3324.040000) nil) | 0@@list("T0916" "NB_TPC26T_50" list(4738.320000 3422.040000) nil) | 0@@list("T0917" "NB_TPC26T_50" list(4793.320000 3472.040000) nil) | 0@@list("T0918" "NB_TPC26T_50" list(4896.320000 3336.040000) nil) | 0@@list("T0919" "NB_TPC26T_50" list(4908.320000 3386.040000) nil) | 0@@list("T0920" "NB_TPC26T_50" list(4839.320000 3420.040000) nil) | 0@@list("T0921" "NB_TPC26T_50" list(4809.320000 3371.040000) nil) | 0@@list("T1002" "NB_TPC26T_50" list(3977.000000 2025.000000) nil) | 0@@list("T1003" "NB_TPC26T_50" list(3514.000000 1880.000000) nil) | 0@@list("T1005" "NB_TPC26T_50" list(4720.000000 2507.000000) nil) | 0@@list("T1006" "NB_TPC26T_50" list(4707.000000 2557.000000) nil) | 0@@list("T1105" "NB_TPC26T_50" list(3499.000000 1555.000000) nil) | 0@@list("T1106" "NB_TPC26T_50" list(4046.000000 1500.000000) nil) | 0@@list("T1107" "NB_TPC26T_50" list(4309.910000 1155.900000) nil) | 0@@list("T1203" "NB_TPC26T_50" list(4214.000000 1915.000000) nil) | 0@@list("T1204" "NB_TPC26T_50" list(3461.000000 1471.000000) nil) | 0@@list("T1205" "NB_TPC26T_50" list(3324.000000 1374.000000) nil) | 0@@list("T1207" "NB_TPC26T_50" list(3400.000000 1818.000000) nil) | 0@@list("T1400" "NB_TPC26T_50" list(4853.000000 2701.000000) nil) | 0@@list("T1500" "NB_TPC26T_50" list(3488.000000 1832.000000) nil) | 0@@list("T1504" "NB_TPC26T_50" list(4487.000000 1234.000000) nil) | 0@@list("T1505" "NB_TPC26T_50" list(4370.000000 1417.000000) nil) | 0@@list("T1509" "NB_TPC26T_50" list(4520.000000 1150.000000) nil) | 0@@list("T1510" "NB_TPC26T_50" list(4101.710000 1509.310000) nil) | 0@@list("T1511" "NB_TPC26T_50" list(4020.000000 1456.000000) nil) | 0@@list("T1512" "NB_TPC26T_50" list(4197.000000 1173.000000) nil) | 0@@list("T1513" "NB_TPC26T_50" list(4500.000000 1925.500000) nil) | 0@@list("T5700" "MX_TPC26T_S4_68" list(666.000000 3560.500000) nil) | 0@@list("T5701" "MX_TPC26T_S4_68" list(627.000000 3631.000000) nil) | 0@@list("T5801" "MX_TPC26T_S4_68" list(1153.000000 3517.000000) nil) | 0@@list("T6300" "MX_TPC26T_S4_68" list(6276.000000 3309.000000) nil) | 0@@list("T6301" "MX_TPC26T_S4_68" list(6447.000000 3439.000000) nil) | 0@@list("T6302" "NB_TPC26T_50" list(6437.000000 3915.000000) nil) | 0@@list("T6303" "NB_TPC26T_50" list(6401.000000 3628.000000) nil) | 0@@list("T6900" "NB_TPC26T_50" list(6364.000000 3426.000000) nil) | 0@@list("T6905" "NB_TPC26T_50" list(6034.000000 2975.000000) nil) | 0@@list("T6906" "NB_TPC26T_50" list(5672.000000 3258.000000) nil) | 0@@list("T6907" "NB_TPC26T_50" list(5634.000000 3295.000000) nil) | 0@@list("T6908" "NB_TPC26T_50" list(5845.000000 3129.000000) nil) | 0@@list("T6909" "NB_TPC26T_50" list(5711.000000 3221.000000) nil) | 0@@list("T6910" "NB_TPC26T_50" list(5762.000000 3198.000000) nil) | 0@@list("T6911" "NB_TPC26T_50" list(5887.000000 3093.000000) nil) | 0@@list("T6912" "NB_TPC26T_50" list(5927.000000 3001.000000) nil) | 0@@list("T6913" "NB_TPC26T_50" list(5926.000000 3054.000000) nil) | 0@@list("T6915" "NB_TPC26T_50" list(5978.000000 2954.000000) nil) | 0@@list("T6916" "NB_TPC26T_50" list(5927.000000 2948.000000) nil) | 0@@list("T6917" "NB_TPC26T_50" list(5979.000000 3004.000000) nil) | 0@@list("T6925" "NB_TPC26T_50" list(6223.000000 3387.000000) nil) | 0@@list("T6926" "NB_TPC26T_50" list(6270.000000 3368.000000) nil) | 0@@list("T6927" "NB_TPC26T_50" list(5597.000000 3258.000000) nil) | 0@@list("T6928" "NB_TPC26T_50" list(6105.000000 3614.000000) nil) | 0@@list("T6929" "NB_TPC26T_50" list(5608.000000 3208.000000) nil) | 0@@list("T6935" "NB_TPC26T_50" list(6178.000000 3417.000000) nil) | 0@@list("T6937" "NB_TPC26T_50" list(5555.000000 3230.000000) nil) | 0@@list("T6938" "NB_TPC26T_50" list(5489.000000 3393.000000) nil) | 0@@list("T6940" "NB_TPC26T_50" list(5699.000000 3891.000000) nil) | 0@@list("T6941" "NB_TPC26T_50" list(6173.000000 3501.000000) nil) | 0@@list("T6943" "NB_TPC26T_50" list(6789.000000 3062.000000) nil) | 0@@list("T6944" "NB_TPC26T_50" list(6226.000000 3483.000000) nil) | 0@@list("T6945" "NB_TPC26T_50" list(6780.000000 3003.000000) nil) | 0@@list("T6946" "NB_TPC26T_50" list(6780.000000 2928.000000) nil) | 0@@list("TR3700" "TX_R0402_H24" list(3953.000000 2078.000000) nil) | 0@@list("U2300" "TX_QFP_128P_16_559X559" list(1155.000000 1675.000000) nil) | 0@@list("U2500" "A_BGA_153P_20_516X457_H39" list(3756.730000 1121.270000) nil) | 0@@list("U3701" "TX_LGA_12P_20_87X87_ST" list(5848.000000 1100.000000) nil) | 0@@list("U3901" "A_QFN_32P_20_S197_PAD_T01" list(1185.900000 2667.900000) nil) | 0@@list("U5703" "TX_QFN_40P_16_161X240_PD_8V" list(840.650000 3509.630000) nil) | 0@@list("U5800" "TX_QFN_40P_20_S240_P_4V" list(1380.000000 3275.000000) nil) | 0@@list("X1001" "TX_XTAL_2P_126X59" list(3368.060000 1914.000000) nil) | 0@@list("X2300" "TX_XTAL_2P_126X59" list(1597.310000 2043.490000) nil) | 100@@5n-armani13.a00@@P16C000357-PC@@Iris_Chen@@Aug 25 13:18:03 2017 | 10@@list("U3800" "TX_QFN_48P_16_S240_P_9V_REA" list(460.000000 1405.000000) t) | 11@@list("CON2100" "A_DDR4_260P_20_4HOLD_FOX" list(1892.610000 2614.130000) t) | 11@@list("CON3602" "TX_WTOB_2P_49_2H_ACES_H138" list(2144.580000 931.060000) t) | 11@@list("CON5104" "TX_WTOB_20P_20_4HOLD" list(7468.990000 936.180000) t) | 12@@list("" "INDEXB_CROSS" list(7832.000000 4239.000000) nil) | 12@@list("" "INDEXB_CROSS" list(7850.500000 1109.000000) nil) | 12@@list("" "INDEXB_CROSS" list(816.000000 631.000000) nil) | 12@@list("C0600" "TX_C0603_T02_H39" list(3959.000000 2297.000000) nil) | 12@@list("C0601" "TX_C0603_T02_H39" list(3958.000000 2573.000000) nil) | 12@@list("C0602" "TX_C0603_T02_H39" list(4019.000000 2206.000000) nil) | 12@@list("C0603" "TX_C0402_T02_H28" list(4038.100000 2096.030000) nil) | 12@@list("C0604" "TX_C0402_T02_H28" list(3933.000000 2166.000000) nil) | 12@@list("C0605" "TX_C0402_T02_H28" list(3933.000000 2230.000000) nil) | 12@@list("C0606" "TX_C0402_T02_H28" list(3932.000000 2410.000000) nil) | 12@@list("C0609" "TX_C0402" list(4177.000000 2183.000000) nil) | 12@@list("C0610" "TX_C0402" list(4181.000000 2233.000000) nil) | 12@@list("C0611" "TX_C0402" list(4620.090000 2130.360000) nil) | 12@@list("C0612" "TX_C0402_T02_H28" list(4109.830000 2499.790000) nil) | 12@@list("C0613" "TX_C0402" list(4266.060000 2113.000000) nil) | 12@@list("C0614" "TX_C0402" list(4395.780000 2114.790000) nil) | 12@@list("C0615" "TX_C0402" list(4303.060000 2113.000000) nil) | 12@@list("C0616" "TX_C0402" list(4339.780000 2112.790000) nil) | 12@@list("C0617" "TX_C0402" list(4619.710000 2168.280000) nil) | 12@@list("C0618" "TX_C0402" list(4432.820000 2114.710000) nil) | 12@@list("C0619" "TX_C0402" list(4850.000000 1992.000000) nil) | 12@@list("C0620" "TX_C0402" list(4778.060000 2045.000000) nil) | 12@@list("C0621" "TX_C0402" list(4192.000000 2121.060000) nil) | 12@@list("C0622" "TX_C0402" list(4633.060000 2066.000000) nil) | 12@@list("C0623" "TX_C0402" list(4596.060000 2066.000000) nil) | 12@@list("C0700" "TX_C0402" list(4174.790000 2276.290000) nil) | 12@@list("C0701" "TX_C0402" list(4174.860000 2313.410000) nil) | 12@@list("C0702" "TX_C0402" list(4174.790000 2350.250000) nil) | 12@@list("C0703" "TX_C0402" list(4268.000000 2323.000000) nil) | 12@@list("C0704" "TX_C0402" list(4855.000000 2396.000000) nil) | 12@@list("C0705" "TX_C0402" list(4680.380000 2366.720000) nil) | 12@@list("C0706" "TX_C0402" list(4784.000000 2286.000000) nil) | 12@@list("C0711" "TX_C0402" list(4854.000000 2624.000000) nil) | 12@@list("C0712" "TX_C0402" list(4522.880000 2381.000000) nil) | 12@@list("C0717" "TX_C0402" list(4679.880000 2438.000000) nil) | 12@@list("C0718" "TX_C0402" list(4625.620000 2367.000000) nil) | 12@@list("C0719" "TX_C0402" list(4818.120000 2385.500000) nil) | 12@@list("C0720" "TX_C0402" list(4276.000000 2830.000000) nil) | 12@@list("C0721" "TX_C0402" list(4543.000000 2830.000000) nil) | 12@@list("C0722" "TX_C0402" list(4615.880000 2807.220000) nil) | 12@@list("C0723" "TX_C0402" list(4543.000000 2766.000000) nil) | 12@@list("C0724" "TX_C0402" list(4491.000000 2830.000000) nil) | 12@@list("C0725" "TX_C0402" list(4615.880000 2656.220000) nil) | 12@@list("C0726" "TX_C0402" list(4616.000000 2693.000000) nil) | 12@@list("C0727" "TX_C0402" list(4615.880000 2733.220000) nil) | 12@@list("C0728" "TX_C0402" list(4615.880000 2770.220000) nil) | 12@@list("C0729" "TX_C0402" list(4383.000000 2830.000000) nil) | 12@@list("C0730" "TX_C0402" list(4438.000000 2830.000000) nil) | 12@@list("C0731" "TX_C0402" list(4494.000000 3259.000000) nil) | 12@@list("C0732" "TX_C0402" list(4558.000000 3259.000000) nil) | 12@@list("C0733" "TX_C0402" list(4328.000000 2830.000000) nil) | 12@@list("C0740" "TX_C0402" list(4175.300000 2423.500000) nil) | 12@@list("C0741" "TX_C0402" list(4270.000000 2404.000000) nil) | 12@@list("C0742" "TX_C0402" list(4625.000000 2437.500000) nil) | 12@@list("C0743" "TX_C0402" list(4626.000000 2301.000000) nil) | 12@@list("C0744" "TX_C0402" list(4175.300000 2387.000000) nil) | 12@@list("C0745" "TX_C0402" list(4614.620000 2616.690000) nil) | 12@@list("C0746" "TX_C0402" list(4614.620000 2579.690000) nil) | 12@@list("C0747" "TX_C0402" list(4781.380000 2648.310000) nil) | 12@@list("C0748" "TX_C0402" list(4183.880000 2606.810000) nil) | 12@@list("C0749" "TX_C0402" list(4183.880000 2569.810000) nil) | 12@@list("C1002" "TX_C0402" list(3448.000000 1991.500000) nil) | 12@@list("C1003" "TX_C0402" list(3473.880000 1917.000000) nil) | 12@@list("C1100" "TX_C0402" list(3394.000000 1647.000000) nil) | 12@@list("C1101" "TX_C0402" list(3435.000000 1647.000000) nil) | 12@@list("C1102" "TX_C0402" list(3472.000000 1647.000000) nil) | 12@@list("C1103" "TX_C0402" list(3508.000000 1647.000000) nil) | 12@@list("C1201" "TX_C0402" list(2371.000000 684.000000) nil) | 12@@list("C1202" "TX_C0402" list(2410.000000 684.000000) nil) | 12@@list("C1204" "TX_C0402" list(3393.000000 1451.000000) nil) | 12@@list("C1205" "TX_C0402" list(3396.000000 1307.000000) nil) | 12@@list("C1600" "TX_C0402" list(4347.000000 2004.000000) nil) | 12@@list("C1601" "TX_C0402" list(4347.000000 1940.000000) nil) | 12@@list("C1602" "TX_C0402" list(4464.500000 1433.000000) nil) | 12@@list("C1603" "TX_C0402" list(4464.500000 1396.000000) nil) | 12@@list("C1605" "TX_C0402" list(4401.000000 2005.500000) nil) | 12@@list("C1606" "TX_C0402" list(4551.000000 1924.440000) nil) | 12@@list("C1608" "TX_C0402" list(4581.100000 1456.780000) nil) | 12@@list("C1611" "TX_C0402" list(4142.400000 1491.300000) nil) | 12@@list("C1612" "TX_C0402" list(4388.000000 1469.000000) nil) | 12@@list("C1613" "TX_C0402" list(4592.100000 1420.290000) nil) | 12@@list("C1614" "TX_C0402" list(4445.060000 2025.000000) nil) | 12@@list("C1615" "TX_C0402" list(4432.000000 1919.600000) nil) | 12@@list("C1618" "TX_C0402" list(3590.000000 1535.000000) nil) | 12@@list("C1619" "TX_C0402" list(4306.000000 2018.000000) nil) | 12@@list("C1620" "TX_C0402" list(4269.000000 1997.000000) nil) | 12@@list("C1621" "TX_C0603_T02_H39" list(4691.800000 1948.610000) nil) | 12@@list("C1622" "TX_C0402" list(4436.000000 1955.700000) nil) | 12@@list("C1623" "TX_C0603_T02_H39" list(4689.300000 2061.680000) nil) | 12@@list("C1624" "TX_C0603_T02_H39" list(4745.000000 1982.500000) nil) | 12@@list("C1625" "TX_C0402" list(4496.500000 1990.000000) nil) | 12@@list("C1626" "TX_C0402" list(4534.000000 2019.000000) nil) | 12@@list("C1629" "TX_C0402" list(4468.000000 1359.000000) nil) | 12@@list("C1630" "TX_C0402" list(4488.000000 1090.000000) nil) | 12@@list("C1632" "TX_C0402" list(5041.000000 1127.000000) nil) | 12@@list("C1800" "TX_C0402" list(297.000000 935.000000) nil) | 12@@list("C1903" "TX_C0402" list(1361.000000 3577.000000) nil) | 12@@list("C1904" "TX_C0402" list(942.000000 2439.000000) nil) | 12@@list("C1905" "TX_C0402" list(2695.000000 930.000000) nil) | 12@@list("C1906" "TX_C0402" list(2714.000000 1146.000000) nil) | 12@@list("C2000" "TX_C0402" list(2235.000000 1323.000000) nil) | 12@@list("C2001" "TX_C0402" list(2548.000000 1278.000000) nil) | 12@@list("C2002" "TX_C0402" list(2235.000000 2841.000000) nil) | 12@@list("C2003" "TX_C0402" list(4052.000000 1297.000000) nil) | 12@@list("C2004" "TX_C0402" list(4052.000000 1260.350000) nil) | 12@@list("C2005" "TX_C0402" list(2550.000000 1363.000000) nil) | 12@@list("C2006" "TX_C0402" list(2235.000000 1365.000000) nil) | 12@@list("C2007" "TX_C0402" list(2127.310000 2229.620000) nil) | 12@@list("C2008" "TX_C0402" list(2127.310000 2192.620000) nil) | 12@@list("C2009" "TX_C0402" list(2211.810000 2242.620000) nil) | 12@@list("C2010" "TX_C0402" list(2211.810000 2130.620000) nil) | 12@@list("C2011" "TX_C0402" list(2234.000000 2804.000000) nil) | 12@@list("C2012" "TX_C0402" list(2548.000000 1314.000000) nil) | 12@@list("C2100" "TX_C0402" list(1644.130000 1242.340000) nil) | 12@@list("C2101" "TX_C0402" list(2056.000000 1327.000000) nil) | 12@@list("C2102" "TX_C0402" list(1596.000000 2721.000000) nil) | 12@@list("C2103" "TX_C0402" list(2056.000000 1409.000000) nil) | 12@@list("C2104" "TX_C0402" list(1827.000000 1238.000000) nil) | 12@@list("C2105" "TX_C0402" list(2056.000000 1450.000000) nil) | 12@@list("C2106" "TX_C0402" list(2056.000000 1368.000000) nil) | 12@@list("C2107" "TX_C0402" list(1861.000000 1313.000000) nil) | 12@@list("C2108" "TX_C0402" list(1661.560000 2243.510000) nil) | 12@@list("C2109" "TX_C0402" list(1661.560000 2282.510000) nil) | 12@@list("C2110" "TX_C0402" list(1741.780000 2103.620000) nil) | 12@@list("C2111" "TX_C0402" list(1741.780000 2140.400000) nil) | 12@@list("C2200" "TX_C0402_T02_H28" list(2246.000000 3320.000000) nil) | 12@@list("C2201" "TX_C0402_T02_H28" list(2513.770000 2722.910000) nil) | 12@@list("C2202" "TX_C0402_T02_H28" list(2318.000000 2339.000000) nil) | 12@@list("C2203" "TX_C0402_T02_H28" list(2477.000000 1485.000000) nil) | 12@@list("C2204" "TX_C0402_T02_H28" list(2532.270000 2078.620000) nil) | 12@@list("C2205" "TX_C0402_T02_H28" list(2522.000000 2268.000000) nil) | 12@@list("C2206" "TX_C0402_T02_H28" list(2245.690000 3003.230000) nil) | 12@@list("C2207" "TX_C0402_T02_H28" list(2556.000000 2648.000000) nil) | 12@@list("C2208" "TX_C0402_T02_H28" list(1532.630000 1242.340000) nil) | 12@@list("C2209" "TX_C0402_T02_H28" list(2172.950000 1269.030000) nil) | 12@@list("C2210" "TX_C0402_T02_H28" list(1733.000000 3819.000000) nil) | 12@@list("C2211" "TX_C0402_T02_H28" list(1849.660000 2172.650000) nil) | 12@@list("C2212" "TX_C0402_T02_H28" list(2055.000000 2291.000000) nil) | 12@@list("C2213" "TX_C0402_T02_H28" list(1735.960000 2396.640000) nil) | 12@@list("C2214" "TX_C0402_T02_H28" list(1737.000000 2315.000000) nil) | 12@@list("C2215" "TX_C0402_T02_H28" list(2045.000000 2971.000000) nil) | 12@@list("C2216" "TX_C0402_T02_H28" list(2046.000000 2930.000000) nil) | 12@@list("C2217" "TX_C0402_T02_H28" list(2051.000000 2766.000000) nil) | 12@@list("C2218" "TX_C0402_T02_H28" list(2039.570000 3624.950000) nil) | 12@@list("C2219" "TX_C0402_T02_H28" list(1870.280000 2014.260000) nil) | 12@@list("C2220" "TX_C0402" list(2248.950000 1269.030000) nil) | 12@@list("C2221" "TX_C0402" list(2211.950000 1269.030000) nil) | 12@@list("C2222" "TX_C0402" list(1607.630000 1242.340000) nil) | 12@@list("C2223" "TX_C0402" list(1571.130000 1242.340000) nil) | 12@@list("C2224" "TX_C0402" list(2548.000000 3193.000000) nil) | 12@@list("C2225" "TX_C0402" list(2386.000000 2649.000000) nil) | 12@@list("C2226" "TX_C0402" list(2558.000000 2570.000000) nil) | 12@@list("C2227" "TX_C0402" list(2200.000000 3708.000000) nil) | 12@@list("C2228" "TX_C0402" list(2266.000000 1760.000000) nil) | 12@@list("C2229" "TX_C0402" list(2555.810000 3611.550000) nil) | 12@@list("C2230" "TX_C0402" list(2541.520000 1789.400000) nil) | 12@@list("C2231" "TX_C0402" list(2385.930000 2606.780000) nil) | 12@@list("C2232" "TX_C0402_T02_H28" list(2014.810000 1267.620000) nil) | 12@@list("C2233" "TX_C0402_T02_H28" list(2055.810000 1267.620000) nil) | 12@@list("C2234" "TX_C0402" list(2069.000000 2709.000000) nil) | 12@@list("C2235" "TX_C0402" list(2055.000000 2252.000000) nil) | 12@@list("C2236" "TX_C0402" list(2073.000000 2347.000000) nil) | 12@@list("C2237" "TX_C0402" list(2050.810000 3217.790000) nil) | 12@@list("C2238" "TX_C0402" list(1838.000000 1912.000000) nil) | 12@@list("C2239" "TX_C0402" list(1771.810000 3378.810000) nil) | 12@@list("C2240" "TX_C0402" list(2141.000000 1450.000000) nil) | 12@@list("C2241" "TX_C0402" list(2045.310000 1930.900000) nil) | 12@@list("C2242" "TX_C0402" list(2514.000000 1209.000000) nil) | 12@@list("C2243" "TX_C0402" list(2550.000000 1209.000000) nil) | 12@@list("C2300" "TX_C0402" list(1096.000000 2105.000000) nil) | 12@@list("C2301" "TX_C0402" list(1343.000000 2110.000000) nil) | 12@@list("C2302" "TX_C0402" list(1605.000000 1442.000000) nil) | 12@@list("C2303" "TX_C0402" list(1185.000000 1270.000000) nil) | 12@@list("C2304" "TX_C0402" list(1551.000000 1744.000000) nil) | 12@@list("C2305" "TX_C0402" list(737.150000 1788.160000) nil) | 12@@list("C2306" "TX_C0402" list(1058.000000 2105.000000) nil) | 12@@list("C2307" "TX_C0402" list(866.000000 1306.000000) nil) | 12@@list("C2308" "TX_C0402" list(1630.000000 1880.100000) nil) | 12@@list("C2309" "TX_C0402" list(740.000000 1573.000000) nil) | 12@@list("C2310" "TX_C0402" list(1147.000000 2070.000000) nil) | 12@@list("C2311" "TX_C0402" list(1604.000000 2128.000000) nil) | 12@@list("C2312" "TX_C0402" list(1511.000000 1961.000000) nil) | 12@@list("C2313" "TX_C0402" list(1661.000000 1497.000000) nil) | 12@@list("C2314" "TX_C0402" list(1560.000000 1607.000000) nil) | 12@@list("C2315" "TX_C0402" list(1402.000000 1267.000000) nil) | 12@@list("C2316" "TX_C0402_T02_H28" list(810.760000 2026.360000) nil) | 12@@list("C2317" "TX_C0402" list(1544.000000 1557.000000) nil) | 12@@list("C2318" "TX_C0402" list(1476.930000 2031.050000) nil) | 12@@list("C2319" "TX_C0402" list(1643.350000 1978.010000) nil) | 12@@list("C2321" "TX_C0402" list(1565.000000 1694.000000) nil) | 12@@list("C2400" "TX_C0402_T02_H26" list(822.000000 1172.000000) nil) | 12@@list("C2401" "TX_C0402" list(1020.000000 2105.000000) nil) | 12@@list("C2500" "TX_C0402" list(3455.000000 1214.650000) nil) | 12@@list("C2501" "TX_C0402_T02_H26" list(3381.000000 1214.350000) nil) | 12@@list("C2502" "TX_C0402_T02_H28" list(3632.500000 768.000000) nil) | 12@@list("C2503" "TX_C0402" list(3494.000000 1214.350000) nil) | 12@@list("C2504" "TX_C0402" list(3419.000000 1214.350000) nil) | 12@@list("C2505" "TX_C0402" list(3458.000000 1420.000000) nil) | 12@@list("C2506" "TX_C0402_T02_H26" list(3632.500000 809.000000) nil) | 12@@list("C2600" "TX_C0402" list(401.000000 3130.000000) nil) | 12@@list("C2601" "TX_C0402_T02_H28" list(442.000000 3130.000000) nil) | 12@@list("C2908" "TX_C0402" list(775.000000 2909.000000) nil) | 12@@list("C2909" "TX_C0402" list(882.000000 2740.000000) nil) | 12@@list("C3003" "TX_C0402" list(2023.000000 4193.500000) nil) | 12@@list("C3100" "TX_C0402_T02_H28" list(8622.000000 1012.000000) nil) | 12@@list("C3101" "TX_C0402" list(8622.000000 1126.000000) nil) | 12@@list("C3102" "TX_C0402" list(8622.000000 1052.000000) nil) | 12@@list("C3103" "TX_C0402" list(8622.000000 1089.000000) nil) | 12@@list("C3108" "TX_C0402_T02_H28" list(8621.000000 894.000000) nil) | 12@@list("C3109" "TX_C0402" list(8622.000000 972.000000) nil) | 12@@list("C3110" "TX_C0402" list(8621.000000 933.000000) nil) | 12@@list("C3111" "TX_C0402" list(8231.000000 827.800000) nil) | 12@@list("C3112" "TX_C0402" list(8231.000000 864.000000) nil) | 12@@list("C3113" "TX_C0402" list(8307.000000 613.200000) nil) | 12@@list("C3114" "TX_C0402" list(8307.000000 577.000000) nil) | 12@@list("C3115" "TX_C0402" list(8521.000000 519.000000) nil) | 12@@list("C3116" "TX_C0402_T02_H28" list(8608.000000 352.000000) nil) | 12@@list("C3117" "TX_C0402" list(8608.000000 313.000000) nil) | 12@@list("C3118" "TX_C0402" list(8608.000000 391.000000) nil) | 12@@list("C3119" "TX_C0402" list(8612.000000 428.000000) nil) | 12@@list("C3605" "TX_C0402" list(3823.000000 3557.000000) nil) | 12@@list("C3701" "TX_C0402" list(225.000000 2453.000000) nil) | 12@@list("C3702" "TX_C0402" list(5738.000000 996.000000) nil) | 12@@list("C3703" "TX_C0402" list(5723.000000 1157.000000) nil) | 12@@list("C3704" "TX_C0402" list(5872.000000 1195.000000) nil) | 12@@list("C3705" "TX_C0402_T02_H28" list(5872.000000 1234.000000) nil) | 12@@list("C3707" "TX_C0402" list(3953.000000 2115.000000) nil) | 12@@list("C3801" "TX_C0402" list(535.000000 1168.000000) nil) | 12@@list("C3804" "TX_C0402_T02_H28" list(496.000000 1521.000000) nil) | 12@@list("C3805" "TX_C0402" list(547.390000 1637.720000) nil) | 12@@list("C3806" "TX_C0402" list(457.000000 1529.000000) nil) | 12@@list("C3807" "TX_C0402" list(464.550000 1686.320000) nil) | 12@@list("C3817" "TX_C0402_T02_H28" list(510.000000 1227.000000) nil) | 12@@list("C3818" "TX_C0603" list(338.610000 1229.710000) nil) | 12@@list("C3821" "TX_C0603" list(264.000000 1279.000000) nil) | 12@@list("C3823" "TX_C0402_T02_H28" list(402.000000 1288.000000) nil) | 12@@list("C3824" "TX_C0402_T02_H28" list(341.000000 1567.000000) nil) | 12@@list("C3832" "TX_C0402_T02_H28" list(538.760000 1528.390000) nil) | 12@@list("C3835" "TX_C0402" list(-30.000000 1035.000000) nil) | 12@@list("C3836" "TX_C0402" list(25.000000 1037.000000) nil) | 12@@list("C3837" "TX_C0402" list(78.190000 1035.880000) nil) | 12@@list("C3838" "TX_C0402" list(121.190000 1035.880000) nil) | 12@@list("C3901" "TX_C0402" list(1303.000000 2506.000000) nil) | 12@@list("C3902" "TX_C0402_T02_H28" list(1224.000000 2506.000000) nil) | 12@@list("C3903" "TX_C0402" list(1024.000000 2621.000000) nil) | 12@@list("C3904" "TX_C0402" list(1352.000000 2688.000000) nil) | 12@@list("C3905" "TX_C0402_T02_H28" list(1024.000000 2540.000000) nil) | 12@@list("C3906" "TX_C0402_T02_H28" list(1352.000000 2768.000000) nil) | 12@@list("C3907" "TX_C0402" list(1201.000000 2826.000000) nil) | 12@@list("C3908" "TX_C0402_T02_H26" list(1352.000000 2727.000000) nil) | 12@@list("C3909" "TX_C0402" list(1353.000000 2543.000000) nil) | 12@@list("C3910" "TX_C0402_T02_H26" list(1264.000000 2506.000000) nil) | 12@@list("C3911" "TX_C0402" list(1352.000000 2651.000000) nil) | 12@@list("C3913" "TX_C0402_T02_H26" list(1024.000000 2582.000000) nil) | 12@@list("C3914" "TX_C0402" list(1165.000000 2826.000000) nil) | 12@@list("C5111" "TX_C0402" list(2934.790000 615.020000) nil) | 12@@list("C5112" "TX_C0402" list(2862.240000 615.620000) nil) | 12@@list("C5113" "TX_C0402" list(2898.430000 615.620000) nil) | 12@@list("C5114" "TX_C0402" list(2789.660000 615.620000) nil) | 12@@list("C5115" "TX_C0402" list(2825.870000 615.620000) nil) | 12@@list("C5116" "TX_C0402" list(2970.910000 615.280000) nil) | 12@@list("C5118" "TX_C0402" list(3043.970000 614.420000) nil) | 12@@list("C5119" "TX_C0402" list(3007.350000 614.290000) nil) | 12@@list("C5120" "TX_C0402" list(3080.880000 614.420000) nil) | 12@@list("C5126" "TX_C0402" list(2089.600000 565.000000) nil) | 12@@list("C5127" "TX_C0402" list(1789.500000 565.000000) nil) | 12@@list("C5128" "TX_C0402" list(1899.000000 565.000000) nil) | 12@@list("C5129" "TX_C0402" list(2017.000000 565.000000) nil) | 12@@list("C5130" "TX_C0402" list(2115.000000 670.000000) nil) | 12@@list("C5131" "TX_C0402" list(297.000000 897.000000) nil) | 12@@list("C5301" "TX_C0402" list(1465.000000 2559.000000) nil) | 12@@list("C5700" "TX_C0402" list(682.000000 3645.000000) nil) | 12@@list("C5701" "TX_C0402" list(967.000000 3641.000000) nil) | 12@@list("C5702" "TX_C0402" list(701.000000 3340.000000) nil) | 12@@list("C5703" "TX_C0402" list(889.000000 3300.000000) nil) | 12@@list("C5704" "TX_C0402" list(1008.000000 3641.000000) nil) | 12@@list("C5705" "TX_C0402" list(1006.000000 3351.000000) nil) | 12@@list("C5706" "TX_C0402" list(1005.000000 3311.000000) nil) | 12@@list("C5707" "TX_C0402" list(852.000000 3302.000000) nil) | 12@@list("C5708" "TX_C0402" list(814.000000 3302.000000) nil) | 12@@list("C5709" "TX_C0402" list(1000.000000 3392.000000) nil) | 12@@list("C5710" "TX_C0402" list(1000.000000 3429.000000) nil) | 12@@list("C5711" "TX_C0402" list(1080.000000 3448.000000) nil) | 12@@list("C5712" "TX_C0402" list(1080.000000 3485.000000) nil) | 12@@list("C5713" "TX_C0402" list(1006.000000 3503.000000) nil) | 12@@list("C5714" "TX_C0402" list(1006.000000 3541.000000) nil) | 12@@list("C5715" "TX_C0402" list(1100.000000 3571.000000) nil) | 12@@list("C5716" "TX_C0402" list(1100.000000 3609.000000) nil) | 12@@list("C5717" "TX_C0402" list(692.000000 3793.000000) nil) | 12@@list("C5718" "TX_C0402" list(655.000000 3793.000000) nil) | 12@@list("C5719" "TX_C0402" list(366.000000 3580.000000) nil) | 12@@list("C5720" "TX_C0402" list(366.000000 3539.000000) nil) | 12@@list("C5721" "TX_C0402" list(366.000000 3459.000000) nil) | 12@@list("C5722" "TX_C0402" list(366.000000 3498.000000) nil) | 12@@list("C5800" "TX_C0402" list(1405.000000 3096.500000) nil) | 12@@list("C5801" "TX_C0402" list(1355.000000 3080.000000) nil) | 12@@list("C5802" "TX_C0402" list(1286.000000 3113.000000) nil) | 12@@list("C5803" "TX_C0402" list(1304.000000 3063.000000) nil) | 12@@list("C5804" "TX_C0402" list(1430.000000 3453.300000) nil) | 12@@list("C5805" "TX_C0402" list(1576.090000 3248.530000) nil) | 12@@list("C5806" "TX_C0402" list(1576.000000 3357.000000) nil) | 12@@list("C5807" "TX_C0402" list(1578.000000 3403.000000) nil) | 12@@list("C5811" "TX_C0402" list(1561.000000 3306.000000) nil) | 12@@list("C5812" "TX_C0402" list(1598.000000 3306.000000) nil) | 12@@list("C5813" "TX_C0402" list(863.000000 2462.000000) nil) | 12@@list("C5814" "TX_C0402" list(881.000000 2678.000000) nil) | 12@@list("C5906" "TX_C0402" list(532.000000 3749.000000) nil) | 12@@list("C5912" "TX_C0402" list(494.000000 3749.000000) nil) | 12@@list("C6000" "TX_C0402" list(5267.990000 3555.000000) nil) | 12@@list("C6001" "TX_C0402" list(5293.990000 3529.000000) nil) | 12@@list("C6002" "TX_C0402" list(5346.000000 3477.000000) nil) | 12@@list("C6003" "TX_C0402" list(5320.100000 3502.810000) nil) | 12@@list("C6004" "TX_C0402" list(5241.860000 3581.060000) nil) | 12@@list("C6005" "TX_C0402" list(5215.990000 3607.000000) nil) | 12@@list("C6006" "TX_C0402" list(5180.990000 3635.000000) nil) | 12@@list("C6007" "TX_C0402" list(5155.260000 3660.600000) nil) | 12@@list("C6201" "TX_C0402" list(5895.490000 3875.500000) nil) | 12@@list("C6202" "TX_C0402" list(5802.000000 3769.000000) nil) | 12@@list("C6203" "TX_C0402" list(5799.000000 3891.000000) nil) | 12@@list("C6300" "TX_C0402_H20" list(6892.000000 3398.000000) nil) | 12@@list("C6303" "TX_C0402" list(6370.000000 3365.500000) nil) | 12@@list("C6304" "TX_C0402" list(6407.000000 3327.000000) nil) | 12@@list("C6305" "TX_C0402" list(6955.000000 3324.000000) nil) | 12@@list("C6615" "TX_C0402" list(7074.000000 4355.000000) nil) | 12@@list("C6616" "TX_C0402" list(7058.000000 3965.000000) nil) | 12@@list("C6617" "TX_C0402" list(7679.000000 4329.000000) nil) | 12@@list("C6618" "TX_C0402" list(7676.000000 3992.000000) nil) | 12@@list("C6619" "TX_C0402" list(7477.680000 4453.000000) nil) | 12@@list("C6620" "TX_C0402" list(7048.000000 3610.000000) nil) | 12@@list("C6621" "TX_C0402" list(7057.000000 3266.000000) nil) | 12@@list("C6622" "TX_C0402" list(7691.000000 3527.000000) nil) | 12@@list("C6623" "TX_C0402" list(7680.000000 3171.000000) nil) | 12@@list("C6624" "TX_C0402" list(7401.000000 3072.000000) nil) | 12@@list("C6625" "TX_C0402" list(7038.000000 4355.000000) nil) | 12@@list("C6626" "TX_C0402" list(7058.000000 3925.000000) nil) | 12@@list("C6627" "TX_C0402" list(7679.000000 4370.000000) nil) | 12@@list("C6628" "TX_C0402" list(7676.000000 3950.000000) nil) | 12@@list("C6629" "TX_C0402_T02_H28" list(7691.000000 3488.000000) nil) | 12@@list("C6632" "TX_C0402" list(7680.000000 3132.000000) nil) | 12@@list("C6633" "TX_C0402" list(7057.000000 3229.000000) nil) | 12@@list("C6636" "TX_C0402" list(7048.000000 3652.000000) nil) | 12@@list("C6637" "TX_C0402" list(7691.000000 3563.000000) nil) | 12@@list("C6700" "TX_C0402" list(6026.000000 3946.000000) nil) | 12@@list("C6701" "TX_C0402" list(6042.510000 3710.500000) nil) | 12@@list("C6702" "TX_C0402" list(6152.510000 3933.500000) nil) | 12@@list("C6703" "TX_C0402" list(6014.500000 3650.510000) nil) | 12@@list("C6704" "TX_C0402" list(6265.500000 3676.510000) nil) | 12@@list("C6705" "TX_C0402" list(6100.270000 3556.490000) nil) | 12@@list("C6706" "TX_C0402" list(6220.750000 3556.820000) nil) | 12@@list("C6707" "TX_C0402" list(6088.210000 3825.820000) nil) | 12@@list("C6708" "TX_C0402" list(6051.790000 3871.180000) nil) | 12@@list("C6709" "TX_C0402" list(6231.790000 3917.180000) nil) | 12@@list("C6710" "TX_C0402" list(6144.820000 3896.790000) nil) | 12@@list("C6711" "TX_C0402" list(6189.210000 3824.820000) nil) | 12@@list("C6712" "TX_C0402" list(6289.000000 3828.000000) nil) | 12@@list("C6713" "TX_C0402" list(6239.000000 3842.000000) nil) | 12@@list("C6714" "TX_C0402" list(6158.570000 3609.030000) nil) | 12@@list("C6715" "TX_C0402" list(5974.050000 3572.320000) nil) | 12@@list("C6716" "TX_C0402" list(6126.720000 3749.900000) nil) | 12@@list("C6717" "TX_C0402" list(6154.990000 3560.570000) nil) | 12@@list("C6718" "TX_C0402_T02_H28" list(6374.500000 3531.500000) nil) | 12@@list("C6719" "TX_C0402_T02_H28" list(5862.220000 3688.980000) nil) | 12@@list("C6720" "TX_C0402_T02_H28" list(5737.180000 3772.350000) nil) | 12@@list("C6721" "TX_C0402" list(5867.500000 4497.510000) nil) | 12@@list("C6722" "TX_C0402_T02_H28" list(5962.510000 3770.500000) nil) | 12@@list("C6723" "TX_C0402_T02_H28" list(6401.180000 4129.350000) nil) | 12@@list("C6724" "TX_C0402_T02_H28" list(6061.160000 3504.720000) nil) | 12@@list("C6725" "TX_C0402_T02_H28" list(6226.500000 3676.510000) nil) | 12@@list("C6726" "TX_C0402_T02_H28" list(6057.500000 3638.510000) nil) | 12@@list("C6727" "TX_C0402_T02_H28" list(6288.000000 3567.000000) nil) | 12@@list("C6728" "TX_C0402_T02_H28" list(6151.000000 3825.000000) nil) | 12@@list("C6729" "TX_C0402_T02_H28" list(6258.000000 3751.000000) nil) | 12@@list("C6730" "TX_C0402_T02_H28" list(6191.510000 3751.500000) nil) | 12@@list("C6731" "TX_C0402_T02_H28" list(6167.500000 3679.510000) nil) | 12@@list("C6732" "TX_C0402" list(6374.500000 3493.000000) nil) | 12@@list("C6733" "TX_C0402" list(5802.490000 3731.500000) nil) | 12@@list("C6734" "TX_C0402" list(5822.500000 4497.510000) nil) | 12@@list("C6735" "TX_C0402" list(6474.510000 4159.500000) nil) | 12@@list("C6736" "TX_C0402" list(6316.490000 4103.500000) nil) | 12@@list("C6737" "TX_C0402" list(6268.500000 3941.510000) nil) | 12@@list("C6738" "TX_C0402" list(6216.490000 4006.500000) nil) | 12@@list("C6739" "TX_C0402" list(6369.510000 4065.500000) nil) | 12@@list("C6740" "TX_C0402" list(5897.510000 3785.500000) nil) | 12@@list("C6741" "TX_C0402" list(6216.510000 3968.500000) nil) | 12@@list("C6742" "TX_C0402" list(6030.790000 3573.530000) nil) | 12@@list("C6743" "TX_C0402" list(6355.510000 3884.500000) nil) | 12@@list("C6744" "TX_C0402" list(6350.510000 3921.500000) nil) | 12@@list("C6745" "TX_C0402" list(6366.510000 3570.500000) nil) | 12@@list("C6746" "TX_C0402_T02_H28" list(6357.490000 3683.500000) nil) | 12@@list("C6747" "TX_C0402" list(6356.510000 3739.500000) nil) | 12@@list("C6748" "TX_C0402" list(6356.510000 3776.500000) nil) | 12@@list("C6749" "TX_C0402" list(6461.000000 3631.000000) nil) | 12@@list("C6750" "TX_C0402" list(6547.500000 4174.490000) nil) | 12@@list("C6751" "TX_C0402" list(6437.180000 4004.210000) nil) | 12@@list("C6752" "TX_C0402" list(6382.510000 3823.500000) nil) | 12@@list("C6753" "TX_C0402" list(6474.490000 3730.500000) nil) | 12@@list("C6754" "TX_C0402" list(6282.510000 3991.500000) nil) | 12@@list("C6800" "TX_C0402" list(7690.000000 3368.000000) nil) | 12@@list("C6802" "TX_C0402" list(7077.000000 4144.000000) nil) | 12@@list("C6907" "TX_C0402" list(5913.450000 3609.080000) nil) | 12@@list("C6908" "TX_C0402" list(5989.000000 3946.000000) nil) | 12@@list("C7100" "TX_C0402_T02_H28" list(5897.490000 3746.500000) nil) | 12@@list("C7101" "TX_C0402_T02_H28" list(6216.510000 4066.500000) nil) | 12@@list("C7102" "TX_C0402" list(5897.510000 3824.500000) nil) | 12@@list("C7103" "TX_C0402" list(6316.490000 4028.500000) nil) | 12@@list("D2400" "TX_SOD323_H39" list(418.000000 2308.080000) nil) | 12@@list("D2401" "TX_SOT323_PAN" list(211.000000 1001.000000) nil) | 12@@list("D2500" "TX_SOD523_1D7_H28" list(3106.000000 1055.000000) nil) | 12@@list("D2600" "TX_ESD_2P_33_39X24_H24" list(303.000000 3298.000000) nil) | 12@@list("D2900" "TX_ESD_2P_33_39X24_H24" list(385.000000 3005.000000) nil) | 12@@list("D2901" "TX_ESD_2P_33_39X24_H24" list(385.000000 2860.000000) nil) | 12@@list("D2902" "TX_SOT323" list(485.000000 2925.000000) nil) | 12@@list("D3604" "TX_SOD523_1D7_H28" list(3710.000000 3559.000000) nil) | 12@@list("D3605" "TX_SOD523_1D7_H28" list(2150.000000 1198.000000) nil) | 12@@list("D5100" "TX_ESD_2P_33_39X24_H24" list(1790.000000 670.000000) nil) | 12@@list("D5101" "TX_ESD_2P_33_39X24_H24" list(1885.000000 670.000000) nil) | 12@@list("D5102" "TX_ESD_2P_33_39X24_H24" list(2015.000000 670.000000) nil) | 12@@list("D5103" "TX_ESD_2P_33_39X24_H24" list(2065.000000 670.000000) nil) | 12@@list("D5702" "TX_ESD_2P_33_39X24_H24" list(240.000000 3777.000000) nil) | 12@@list("D5703" "TX_ESD_2P_33_39X24_H24" list(240.000000 3695.000000) nil) | 12@@list("D5704" "TX_ESD_2P_33_39X24_H24" list(317.000000 3663.000000) nil) | 12@@list("D5707" "TX_ESD_2P_33_39X24_H24" list(238.000000 3884.000000) nil) | 12@@list("F2600" "TX_POLYSWITCH_2P_87X59" list(543.000000 3134.000000) nil) | 12@@list("L3800" "TX_L0603_T015" list(544.380000 1122.860000) nil) | 12@@list("L3805" "TX_L0603_T015" list(594.050000 1680.920000) nil) | 12@@list("L5701" "TX_CHOKE_4P_49X39_MURA" list(321.000000 3729.000000) nil) | 12@@list("L5702" "TX_CHOKE_4P_49X39_MURA" list(491.000000 3619.000000) nil) | 12@@list("L5703" "TX_CHOKE_4P_49X39_MURA" list(473.000000 3354.000000) nil) | 12@@list("L5704" "TX_CHOKE_4P_49X39_MURA" list(509.000000 3535.000000) nil) | 12@@list("L5705" "TX_CHOKE_4P_49X39_MURA" list(647.000000 3461.000000) nil) | 12@@list("L6700" "TX_L0402_T02" list(5697.280000 3820.100000) nil) | 12@@list("L6701" "TX_L0402_T02" list(5916.000000 4497.510000) nil) | 12@@list("L6702" "TX_L0402" list(6437.800000 3504.000000) nil) | 12@@list("PC7600" "TX_C0402_H22" list(2060.000000 4548.000000) nil) | 12@@list("PC7602" "TX_C0402" list(1973.000000 4550.000000) nil) | 12@@list("PC7603" "TX_C0402" list(1190.000000 3778.000000) nil) | 12@@list("PC7604" "TX_C0402" list(2500.000000 4096.000000) nil) | 12@@list("PC7606" "TX_C0603_T015_H37" list(2105.000000 4548.000000) nil) | 12@@list("PC7607" "TX_C0603_T015_H37" list(1401.000000 4192.000000) nil) | 12@@list("PC7609" "TX_C0603" list(985.000000 4224.000000) nil) | 12@@list("PC7610" "TX_C0402" list(1295.000000 4263.560000) nil) | 12@@list("PC7611" "TX_C0603_T015_H37" list(1226.500000 4091.510000) nil) | 12@@list("PC7612" "TX_C0603_T015_H37" list(1257.000000 4163.000000) nil) | 12@@list("PC7807" "TX_C0402" list(6779.000000 2347.500000) nil) | 12@@list("PC7808" "TX_C0402" list(6742.000000 2346.000000) nil) | 12@@list("PC7809" "TX_C0402" list(6880.000000 2091.000000) nil) | 12@@list("PC7810" "TX_C0402_H22" list(6880.000000 2128.000000) nil) | 12@@list("PC7811" "TX_C0402" list(6840.000000 2010.000000) nil) | 12@@list("PC7813" "TX_C0402" list(6840.000000 1945.000000) nil) | 12@@list("PC7819" "TX_C0402" list(6678.000000 2438.000000) nil) | 12@@list("PC7821" "TX_C0402" list(6883.000000 2225.000000) nil) | 12@@list("PC7824" "TX_C0402" list(6572.000000 2378.000000) nil) | 12@@list("PC7825" "TX_C0402" list(6746.000000 2213.000000) nil) | 12@@list("PC7826" "TX_C0402" list(6880.000000 2165.000000) nil) | 12@@list("PC7827" "TX_C0402" list(6372.500000 2076.000000) nil) | 12@@list("PC7828" "TX_C0402_H22" list(6409.000000 2076.000000) nil) | 12@@list("PC7829" "TX_C0402" list(6285.000000 2084.000000) nil) | 12@@list("PC7830" "TX_C0402" list(6553.000000 1993.000000) nil) | 12@@list("PC7832" "TX_C0402" list(6787.000000 1929.000000) nil) | 12@@list("PC7836" "TX_C0402" list(6402.000000 2201.000000) nil) | 12@@list("PC7914" "TX_C0402" list(5729.000000 2215.000000) nil) | 12@@list("PC7915" "TX_C0402" list(5632.060000 2778.000000) nil) | 12@@list("PC8004" "TX_C0402" list(5681.060000 1794.000000) nil) | 12@@list("PC8012" "TX_C0402" list(5652.000000 3071.000000) nil) | 12@@list("PC8013" "TX_C0402" list(5690.060000 3120.000000) nil) | 12@@list("PC8100" "TX_C0603_T02_H39" list(4624.000000 2517.000000) nil) | 12@@list("PC8101" "TX_C0603_T02_H39" list(4335.000000 2519.500000) nil) | 12@@list("PC8102" "TX_C0603_T02_H39" list(4769.000000 2480.000000) nil) | 12@@list("PC8103" "TX_C0603_T02_H39" list(4776.000000 2571.500000) nil) | 12@@list("PC8104" "TX_C0603_T02_H39" list(4388.120000 2519.500000) nil) | 12@@list("PC8107" "TX_C0603_T02_H39" list(4475.620000 2415.000000) nil) | 12@@list("PC8108" "TX_C0603_T02_H39" list(4422.120000 2415.000000) nil) | 12@@list("PC8109" "TX_C0603_T02_H39" list(4367.120000 2415.000000) nil) | 12@@list("PC8110" "TX_C0603_T02_H39" list(4314.620000 2415.000000) nil) | 12@@list("PC8111" "TX_C0603_T02_H39" list(5450.000000 1709.000000) nil) | 12@@list("PC8112" "TX_C0603_T02_H39" list(5450.000000 1655.000000) nil) | 12@@list("PC8113" "TX_C0603_T02_H39" list(5445.000000 1600.000000) nil) | 12@@list("PC8114" "TX_C0603_T02_H39" list(5358.000000 1608.000000) nil) | 12@@list("PC8115" "TX_C0603_T02_H39" list(5450.000000 1762.000000) nil) | 12@@list("PC8116" "TX_C0603_T02_H39" list(5436.000000 1834.000000) nil) | 12@@list("PC8117" "TX_C0603_T02_H39" list(5381.000000 1845.000000) nil) | 12@@list("PC8118" "TX_C0603_T02_H39" list(4821.120000 2480.000000) nil) | 12@@list("PC8119" "TX_C0603_T02_H39" list(4418.120000 2310.000000) nil) | 12@@list("PC8120" "TX_C0603_T02_H39" list(4365.120000 2310.000000) nil) | 12@@list("PC8121" "TX_C0603_T02_H39" list(4312.120000 2310.000000) nil) | 12@@list("PC8122" "TX_C0603_T02_H39" list(4771.880000 2390.000000) nil) | 12@@list("PC8124" "TX_C0603_T02_H39" list(4471.120000 2310.000000) nil) | 12@@list("PC8125" "TX_C0603_T02_H39" list(4366.120000 2205.000000) nil) | 12@@list("PC8126" "TX_C0603_T02_H39" list(4523.120000 2205.000000) nil) | 12@@list("PC8127" "TX_C0603_T02_H39" list(4471.120000 2205.000000) nil) | 12@@list("PC8128" "TX_C0603_T02_H39" list(5447.100000 1961.000000) nil) | 12@@list("PC8129" "TX_C0603_T02_H39" list(4313.120000 2205.000000) nil) | 12@@list("PC8130" "TX_C0603_T02_H39" list(5376.560000 1951.000000) nil) | 12@@list("PC8131" "TX_C0603_T02_H39" list(5324.560000 1951.000000) nil) | 12@@list("PC8132" "TX_C0603_T02_H39" list(5457.000000 2015.000000) nil) | 12@@list("PC8133" "TX_C0603_T02_H39" list(4418.620000 2205.000000) nil) | 12@@list("PC8134" "TX_C0603_T02_H39" list(4261.120000 2205.000000) nil) | 12@@list("PC8135" "TX_C0603_T02_H39" list(4441.000000 2519.500000) nil) | 12@@list("PC8136" "TX_C0603_T02_H39" list(5457.000000 2068.000000) nil) | 12@@list("PC8137" "TX_C0603_T02_H39" list(4443.000000 2750.000000) nil) | 12@@list("PC8138" "TX_C0603_T02_H39" list(4390.000000 2750.000000) nil) | 12@@list("PC8139" "TX_C0603_T02_H39" list(4337.000000 2750.000000) nil) | 12@@list("PC8141" "TX_C0603_T02_H39" list(4674.000000 3305.000000) nil) | 12@@list("PC8142" "TX_C0603_T02_H39" list(4443.120000 2622.500000) nil) | 12@@list("PC8143" "TX_C0603_T02_H39" list(4334.880000 2622.500000) nil) | 12@@list("PC8144" "TX_C0603_T02_H39" list(4284.120000 2750.000000) nil) | 12@@list("PC8145" "TX_C0603_T02_H39" list(4180.500000 2781.000000) nil) | 12@@list("PC8146" "TX_C0603_T02_H39" list(4180.000000 2708.000000) nil) | 12@@list("PC8150" "TX_C0603_T02_H39" list(4390.120000 2622.500000) nil) | 12@@list("PC8153" "TX_C0603_T02_H39" list(4281.880000 2622.500000) nil) | 12@@list("PC8154" "TX_C0603_T02_H39" list(4171.620000 2654.000000) nil) | 12@@list("PC8155" "TX_C0603_T02_H39" list(4188.000000 3402.000000) nil) | 12@@list("PC8157" "TX_C0603_T02_H39" list(4532.120000 2102.000000) nil) | 12@@list("PC8158" "TX_C0603_T02_H39" list(4790.120000 2222.500000) nil) | 12@@list("PC8159" "TX_C0603_T02_H39" list(4477.120000 2102.000000) nil) | 12@@list("PC8160" "TX_C0603_T02_H39" list(4844.120000 2222.500000) nil) | 12@@list("PC8161" "TX_C0603_T02_H39" list(5304.060000 1623.000000) nil) | 12@@list("PC8163" "TX_C0603_T02_H39" list(4564.000000 3412.000000) nil) | 12@@list("PC8165" "TX_C0603_T02_H39" list(4188.940000 3455.000000) nil) | 12@@list("PC8168" "TX_C0603_T02_H39" list(4475.000000 3689.000000) nil) | 12@@list("PC8169" "TX_C0603_T02_H39" list(4674.000000 3414.000000) nil) | 12@@list("PC8170" "TX_C0603_T02_H39" list(4693.000000 3689.000000) nil) | 12@@list("PC8171" "TX_C0603_T02_H39" list(4639.000000 3689.000000) nil) | 12@@list("PC8172" "TX_C0603_T02_H39" list(4564.000000 3305.000000) nil) | 12@@list("PC8173" "TX_C0603_T02_H39" list(4900.000000 3689.000000) nil) | 12@@list("PC8174" "TX_C0603_T02_H39" list(4845.000000 3689.000000) nil) | 12@@list("PC8175" "TX_C0603_T02_H39" list(4564.000000 3358.000000) nil) | 12@@list("PC8178" "TX_C0603_T02_H39" list(5272.000000 1951.000000) nil) | 12@@list("PC8179" "TX_C0603_T02_H39" list(4282.000000 2519.500000) nil) | 12@@list("PC8180" "TX_C0603_T02_H39" list(5489.000000 2121.000000) nil) | 12@@list("PC8181" "TX_C0603_T02_H39" list(5489.000000 2176.000000) nil) | 12@@list("PC8182" "TX_C0603_T02_H39" list(5489.000000 2231.000000) nil) | 12@@list("PC8183" "TX_C0603_T02_H39" list(4674.000000 3360.000000) nil) | 12@@list("PC8185" "TX_C0603_T02_H39" list(4530.000000 3689.000000) nil) | 12@@list("PC8186" "TX_C0603_T02_H39" list(4585.000000 3689.000000) nil) | 12@@list("PC8600" "TX_C0402" list(3770.000000 4230.000000) nil) | 12@@list("PC8601" "TX_C0402" list(3613.000000 4165.000000) nil) | 12@@list("PC8604" "TX_C0402" list(3059.000000 4367.000000) nil) | 12@@list("PC8605" "TX_C0402" list(3877.000000 4043.000000) nil) | 12@@list("PC8609" "TX_C0402" list(3895.000000 4171.000000) nil) | 12@@list("PC8610" "TX_C0402" list(3033.000000 4536.000000) nil) | 12@@list("PC8611" "TX_C0402" list(3839.000000 3971.000000) nil) | 12@@list("PC8612" "TX_C0402" list(3890.000000 3957.000000) nil) | 12@@list("PC8613" "TX_C0402_T02_H28" list(3581.000000 4022.000000) nil) | 12@@list("PC8614" "TX_C0402_T02_H28" list(3645.000000 4000.000000) nil) | 12@@list("PC8615" "TX_C0402_T02_H28" list(3645.000000 3959.800000) nil) | 12@@list("PC8616" "TX_C0402" list(3759.000000 3956.000000) nil) | 12@@list("PC8621" "TX_C0402" list(4027.000000 4113.000000) nil) | 12@@list("PC8801" "TX_C0402" list(1393.000000 1029.000000) nil) | 12@@list("PC8802" "TX_C0402" list(1398.000000 874.500000) nil) | 12@@list("PC8803" "TX_C0402" list(1411.000000 962.500000) nil) | 12@@list("PC8810" "TX_C0402" list(4152.000000 4702.000000) nil) | 12@@list("PC8811" "TX_C0402" list(4018.000000 4752.000000) nil) | 12@@list("PC8814" "TX_C0402" list(1564.000000 787.000000) nil) | 12@@list("PC8921" "TX_C0402" list(7728.000000 2584.000000) nil) | 12@@list("PC9000" "TX_C0402" list(1222.000000 3113.000000) nil) | 12@@list("PC9001" "TX_C0402" list(1335.000000 3015.000000) nil) | 12@@list("PC9002" "TX_C0402" list(1079.000000 3000.500000) nil) | 12@@list("PC9003" "TX_C0402" list(1172.000000 2917.000000) nil) | 12@@list("PC9004" "TX_C0402" list(1236.000000 2917.000000) nil) | 12@@list("PC9005" "TX_C0402" list(1633.000000 3004.000000) nil) | 12@@list("PC9007" "TX_C0402" list(1092.000000 3037.000000) nil) | 12@@list("PC9205" "TX_C0402" list(5453.000000 1202.000000) nil) | 12@@list("PC9507" "TX_C0402" list(6187.790000 2823.700000) nil) | 12@@list("PC9515" "TX_C0402" list(6431.000000 4620.000000) nil) | 12@@list("PC9516" "TX_C0603" list(6728.000000 4731.000000) nil) | 12@@list("PC9604" "TX_C0402" list(5199.000000 4339.000000) nil) | 12@@list("PC9625" "TX_C0402" list(4865.000000 4596.000000) nil) | 12@@list("PC9804" "TX_C0402_H22" list(7338.000000 2878.000000) nil) | 12@@list("PC9808" "TX_C0402" list(7325.000000 3020.000000) nil) | 12@@list("PC9809" "TX_C0402" list(7323.000000 2762.000000) nil) | 12@@list("PC9811" "TX_C0402" list(1158.000000 3113.000000) nil) | 12@@list("PCE8601" "TX_SOD523_1D7_H28" list(3931.970000 3832.750000) nil) | 12@@list("PD7602" "TX_ESD_2P_33_39X24_COLAY" list(1595.000000 4015.500000) nil) | 12@@list("PD8800" "TX_SOD323_H39" list(1663.000000 745.000000) nil) | 12@@list("PL7600" "TX_L0603_T015" list(1499.000000 4260.000000) nil) | 12@@list("PL7601" "TX_L0603_T015" list(1599.000000 4258.000000) nil) | 12@@list("PL7602" "TX_L0603_T015" list(1910.000000 4288.000000) nil) | 12@@list("PL7603" "TX_L0603_T015" list(1205.000000 4163.000000) nil) | 12@@list("PL7604" "TX_L0603_T015" list(1150.000000 4163.000000) nil) | 12@@list("PL7605" "TX_L0402_H24" list(1595.000000 4056.000000) nil) | 12@@list("PL7606" "TX_L0603_T015" list(1086.000000 4199.000000) nil) | 12@@list("PQ7600" "TX_SI7501DN_H44" list(1606.500000 4530.480000) nil) | 12@@list("PQ7603" "TX_SC70_S6_H47" list(2381.000000 4140.000000) nil) | 12@@list("PQ7605" "TX_SOT363_PHILIPS" list(2582.000000 4428.000000) nil) | 12@@list("PQ7606" "TX_SOT363_PHILIPS" list(2581.970000 4531.900000) nil) | 12@@list("PQ7607" "TX_SI7501DN_H44" list(1865.000000 4536.000000) nil) | 12@@list("PQ7608" "TX_SC70_S6_H47" list(973.000000 4332.500000) nil) | 12@@list("PQ7609" "TX_SOT363_PHILIPS" list(2347.030000 4480.960000) nil) | 12@@list("PQ7610" "TX_SOT363_PHILIPS" list(1137.470000 4566.800000) nil) | 12@@list("PQ7611" "TX_SOT363_PHILIPS" list(973.000000 4497.300000) nil) | 12@@list("PQ7612" "TX_SC70_S6_H47" list(1125.900000 4471.490000) nil) | 12@@list("PQ7613" "TX_SI7501DN_H44" list(1273.980000 4399.920000) nil) | 12@@list("PQ7614" "TX_SI7501DN_H44" list(1414.010000 4468.580000) nil) | 12@@list("PR7601" "TX_R0402" list(2528.000000 4602.000000) nil) | 12@@list("PR7611" "TX_R0402" list(1270.000000 3778.000000) nil) | 12@@list("PR7612" "TX_R0402" list(1230.000000 3778.000000) nil) | 12@@list("PR7613" "TX_R0402" list(1220.000000 3607.000000) nil) | 12@@list("PR7614" "TX_R0402_0OHM" list(1297.000000 3644.000000) nil) | 12@@list("PR7615" "TX_R0402" list(2398.000000 4257.000000) nil) | 12@@list("PR7616" "TX_R0402" list(2472.000000 4257.000000) nil) | 12@@list("PR7617" "TX_R0402" list(2463.000000 4096.000000) nil) | 12@@list("PR7618" "TX_R0402" list(2538.000000 4096.000000) nil) | 12@@list("PR7620" "TX_R0402" list(2688.000000 4415.000000) nil) | 12@@list("PR7621" "TX_R0402" list(2688.000000 4478.500000) nil) | 12@@list("PR7622" "TX_R0402" list(2672.000000 4602.000000) nil) | 12@@list("PR7623" "TX_R0402" list(2736.000000 4602.000000) nil) | 12@@list("PR7624" "TX_R0402" list(2688.000000 4542.000000) nil) | 12@@list("PR7625" "TX_R0402" list(2009.550000 4550.000000) nil) | 12@@list("PR7626" "TX_R0402" list(1992.000000 4601.000000) nil) | 12@@list("PR7627" "TX_R0402" list(2463.000000 4477.000000) nil) | 12@@list("PR7628" "TX_R0402" list(2245.000000 4462.000000) nil) | 12@@list("PR7629" "TX_R0805_H26" list(1111.000000 4285.000000) nil) | 12@@list("PR7633" "TX_R0402" list(1143.000000 4397.000000) nil) | 12@@list("PR7634" "TX_R0402" list(1295.000000 4227.510000) nil) | 12@@list("PR7635" "TX_R0402" list(1076.000000 4398.000000) nil) | 12@@list("PR7636" "TX_R0402" list(1238.500000 4519.000000) nil) | 12@@list("PR7637" "TX_R0402" list(1256.000000 4575.000000) nil) | 12@@list("PR7638" "TX_R0402" list(917.000000 4395.000000) nil) | 12@@list("PR7639" "TX_R0402" list(981.000000 4396.000000) nil) | 12@@list("PR7640" "TX_R0402" list(1036.500000 4529.000000) nil) | 12@@list("PR7641" "TX_R0402" list(904.000000 4445.000000) nil) | 12@@list("PR7643" "TX_R0402" list(2423.000000 4555.000000) nil) | 12@@list("PR7644" "TX_R0402_0OHM" list(999.000000 4169.000000) nil) | 12@@list("PR7645" "TX_R0402" list(1316.000000 4506.000000) nil) | 12@@list("PR7646" "TX_R0402" list(2607.500000 4602.000000) nil) | 12@@list("PR7705" "TX_R0603_H24" list(7504.000000 1420.000000) nil) | 12@@list("PR7706" "TX_R0402" list(7586.000000 1420.000000) nil) | 12@@list("PR7711" "TX_R0402_0OHM" list(7603.000000 1192.000000) nil) | 12@@list("PR7805" "TX_R0402" list(5501.000000 2876.000000) nil) | 12@@list("PR7807" "TX_R0402" list(6890.000000 2053.800000) nil) | 12@@list("PR7808" "TX_R0402_0OHM" list(6814.000000 2477.000000) nil) | 12@@list("PR7809" "TX_R0402" list(6815.000000 2060.000000) nil) | 12@@list("PR7810" "TX_R0402" list(6803.000000 2010.000000) nil) | 12@@list("PR7811" "TX_R0402_0OHM" list(6759.000000 2474.000000) nil) | 12@@list("PR7819" "TX_R0402_0OHM" list(6641.000000 2484.000000) nil) | 12@@list("PR7823" "TX_R0402" list(6691.000000 2350.000000) nil) | 12@@list("PR7824" "TX_R0402" list(6599.000000 2441.000000) nil) | 12@@list("PR7825" "TX_R0402" list(6746.000000 2176.800000) nil) | 12@@list("PR7826" "TX_R0402" list(6767.000000 2127.000000) nil) | 12@@list("PR7827" "TX_R0402" list(6285.000000 2048.000000) nil) | 12@@list("PR7828" "TX_R0402" list(6635.000000 2359.000000) nil) | 12@@list("PR7831" "TX_R0402" list(6336.000000 2076.000000) nil) | 12@@list("PR7832" "TX_R0402" list(6506.000000 2115.000000) nil) | 12@@list("PR7833" "TX_R0402" list(6500.000000 2078.000000) nil) | 12@@list("PR7835" "TX_R0402" list(6516.000000 1993.000000) nil) | 12@@list("PR7838" "TX_R0402" list(6521.000000 1943.000000) nil) | 12@@list("PR7839" "TX_R0402" list(6506.000000 2152.000000) nil) | 12@@list("PR7840" "TX_R0402_SHORT" list(6474.000000 2200.000000) nil) | 12@@list("PR7842" "TX_R0402" list(6730.000000 1975.000000) nil) | 12@@list("PR7843" "TX_R0402" list(6505.000000 2240.000000) nil) | 12@@list("PR7844" "TX_R0402_0OHM" list(6286.000000 2127.000000) nil) | 12@@list("PR7845" "TX_R0402" list(6617.000000 1916.000000) nil) | 12@@list("PR7846" "TX_R0402" list(6381.000000 2259.000000) nil) | 12@@list("PR7847" "TX_R0402" list(6412.000000 2145.000000) nil) | 12@@list("PR7848" "TX_R0402" list(6655.000000 1916.000000) nil) | 12@@list("PR7850" "TX_R0402_0OHM" list(6555.000000 2255.000000) nil) | 12@@list("PR7853" "TX_R0402" list(6817.000000 2383.000000) nil) | 12@@list("PR7856" "TX_R0402" list(6572.000000 2341.000000) nil) | 12@@list("PR7914" "TX_R0805_0OHM_H26" list(5639.060000 2196.000000) nil) | 12@@list("PR7916" "TX_R0805_0OHM_H26" list(5615.000000 2701.060000) nil) | 12@@list("PR8001" "TX_R0805_0OHM_H26" list(5754.060000 1715.000000) nil) | 12@@list("PR8002" "TX_R0402" list(5681.060000 1758.000000) nil) | 12@@list("PR8009" "TX_R0402" list(5464.000000 2910.000000) nil) | 12@@list("PR8010" "TX_R0402" list(5427.000000 2910.000000) nil) | 12@@list("PR8012" "TX_R0805_0OHM_H26" list(5587.940000 3133.000000) nil) | 12@@list("PR8600" "TX_R0603_H24" list(3814.000000 4223.000000) nil) | 12@@list("PR8601" "TX_R0805_0OHM_H26" list(3585.000000 4114.000000) nil) | 12@@list("PR8602" "TX_R0402" list(3895.000000 4133.000000) nil) | 12@@list("PR8603" "TX_R0402_SHORT" list(3975.000000 4010.000000) nil) | 12@@list("PR8604" "TX_R0402" list(3975.000000 3973.000000) nil) | 12@@list("PR8605" "TX_R0402" list(3059.000000 4330.000000) nil) | 12@@list("PR8606" "TX_R0402" list(3895.000000 4096.000000) nil) | 12@@list("PR8608" "TX_R0402" list(3033.000000 4573.000000) nil) | 12@@list("PR8609" "TX_R0402" list(3803.000000 3971.000000) nil) | 12@@list("PR8610" "TX_R0402" list(3890.000000 3993.000000) nil) | 12@@list("PR8611" "TX_R0402" list(3732.000000 4230.000000) nil) | 12@@list("PR8612" "TX_R0402_SHORT" list(3709.000000 3975.000000) nil) | 12@@list("PR8614" "TX_R0402_SHORT" list(3976.000000 4096.000000) nil) | 12@@list("PR8615" "TX_R0402_0OHM" list(3874.390000 3822.400000) nil) | 12@@list("PR8616" "TX_R0402" list(3836.390000 3820.900000) nil) | 12@@list("PR8617" "TX_R0805_0OHM_H26" list(2969.620000 4324.840000) nil) | 12@@list("PR8618" "TX_R0805_0OHM_H26" list(3008.620000 4481.840000) nil) | 12@@list("PR8802" "TX_R0402" list(1337.000000 962.500000) nil) | 12@@list("PR8803" "TX_R0402" list(1374.000000 962.500000) nil) | 12@@list("PR8804" "TX_R0402" list(1398.000000 912.000000) nil) | 12@@list("PR8805" "TX_R0402" list(4091.000000 4752.000000) nil) | 12@@list("PR8807" "TX_R0402" list(4152.000000 4660.000000) nil) | 12@@list("PR8810" "TX_R0402" list(4173.000000 4752.000000) nil) | 12@@list("PR8812" "TX_R0402" list(1616.000000 773.000000) nil) | 12@@list("PR8813" "TX_R0402" list(1616.000000 708.000000) nil) | 12@@list("PR8814" "TX_R0402" list(1481.000000 790.000000) nil) | 12@@list("PR8900" "TX_R0603_H24" list(7507.450000 2620.160000) nil) | 12@@list("PR8912" "TX_R0402" list(7664.000000 2532.000000) nil) | 12@@list("PR9000" "TX_R0402_SHORT" list(1415.000000 2975.000000) nil) | 12@@list("PR9001" "TX_R0402" list(1333.000000 2973.000000) nil) | 12@@list("PR9004" "TX_R0402_SHORT" list(1513.000000 3039.000000) nil) | 12@@list("PR9005" "TX_R0402" list(1420.000000 3016.000000) nil) | 12@@list("PR9200" "TX_R0402_SHORT" list(5432.000000 1133.000000) nil) | 12@@list("PR9201" "TX_R0402" list(5373.000000 1119.000000) nil) | 12@@list("PR9205" "TX_R0402_SHORT" list(5406.000000 1272.000000) nil) | 12@@list("PR9207" "TX_R0402" list(5370.000000 1272.000000) nil) | 12@@list("PR9500" "TX_R0402" list(6241.010000 2771.000000) nil) | 12@@list("PR9503" "TX_R0402" list(6214.000000 2797.000000) nil) | 12@@list("PR9505" "TX_R0402" list(6288.000000 4569.000000) nil) | 12@@list("PR9506" "TX_R0805_H26" list(6623.000000 4718.000000) nil) | 12@@list("PR9508" "TX_R0402" list(6493.000000 4640.000000) nil) | 12@@list("PR9801" "TX_R0402_0OHM" list(7338.000000 2920.000000) nil) | 12@@list("PR9805" "TX_R0402" list(7338.000000 2840.000000) nil) | 12@@list("PR9809" "TX_R0402" list(7365.000000 3020.000000) nil) | 12@@list("PR9814" "TX_R0402" list(7362.000000 2762.000000) nil) | 12@@list("PR9815" "TX_R0402_SHORT" list(7399.000000 2762.000000) nil) | 12@@list("PT7701" "NB_TPC26T_50" list(7551.000000 1346.000000) nil) | 12@@list("PT8700" "NB_TPC28T_68" list(6555.000000 1782.000000) nil) | 12@@list("PT8704" "NB_TPC28T_68" list(6613.000000 1864.000000) nil) | 12@@list("PT9500" "NB_TPC28T_68" list(6287.000000 2758.000000) nil) | 12@@list("PT9501" "NB_TPC28T_68" list(6113.000000 2845.000000) nil) | 12@@list("PT9502" "NB_TPC28T_68" list(6031.000000 2889.000000) nil) | 12@@list("PT9503" "NB_TPC28T_68" list(6088.000000 2931.000000) nil) | 12@@list("PT9504" "NB_TPC28T_68" list(5976.000000 2848.000000) nil) | 12@@list("PT9505" "NB_TPC28T_68" list(5776.000000 2556.000000) nil) | 12@@list("PT9508" "NB_TPC28T_68" list(6355.000000 4575.000000) nil) | 12@@list("PT9513" "NB_TPC28T_68" list(5784.000000 2885.000000) nil) | 12@@list("PT9514" "NB_TPC28T_68" list(5783.000000 2814.000000) nil) | 12@@list("PT9800" "NB_TPC28T_68" list(7479.000000 2942.000000) nil) | 12@@list("PU9000" "TX_SC70_S5_TI" list(1639.000000 3101.000000) nil) | 12@@list("Q2400" "TX_SC70_S6_H47" list(565.000000 2304.000000) nil) | 12@@list("Q2401" "TX_SC70_S6_H47" list(860.000000 1090.000000) nil) | 12@@list("Q2600" "TX_SOT23_2D4_122X55_H43" list(695.000000 3026.000000) nil) | 12@@list("Q2601" "TX_SOT23_2D4_H44" list(838.000000 3052.000000) nil) | 12@@list("Q2900" "TX_SC70_S6_H47" list(838.000000 2841.000000) nil) | 12@@list("Q2901" "TX_SC70_S6_H47" list(948.000000 2925.000000) nil) | 12@@list("R0401" "TX_R0402" list(4893.000000 3283.000000) nil) | 12@@list("R0402" "TX_R0402" list(4929.000000 3283.000000) nil) | 12@@list("R0404" "TX_R0402" list(4085.000000 1963.000000) nil) | 12@@list("R0405" "TX_R0402" list(3956.000000 1971.000000) nil) | 12@@list("R0406" "TX_R0402" list(4832.000000 3283.000000) nil) | 12@@list("R0407" "TX_R0402" list(4615.880000 2843.720000) nil) | 12@@list("R0408" "TX_R0402_SHORT" list(4754.500000 1406.000000) nil) | 12@@list("R0411" "TX_R0402" list(4756.000000 1258.000000) nil) | 12@@list("R0413" "TX_R0402" list(4730.320000 2690.000000) nil) | 12@@list("R0414" "TX_R0402" list(4758.000000 1331.000000) nil) | 12@@list("R0415" "TX_R0402" list(4795.000000 1399.000000) nil) | 12@@list("R0500" "TX_R0402" list(4122.000000 1945.000000) nil) | 12@@list("R0501" "TX_R0402" list(4048.000000 1963.000000) nil) | 12@@list("R0502" "TX_R0402" list(3995.000000 1971.000000) nil) | 12@@list("R0600" "TX_R0402_0OHM" list(4028.960000 2486.590000) nil) | 12@@list("R0606" "TX_R0402" list(4694.000000 2306.000000) nil) | 12@@list("R0607" "TX_R0402" list(4732.000000 2250.000000) nil) | 12@@list("R0702" "TX_R0402" list(6857.000000 2275.000000) nil) | 12@@list("R0703" "TX_R0402" list(6913.000000 2262.000000) nil) | 12@@list("R0900" "TX_R0402" list(4733.500000 2830.000000) nil) | 12@@list("R1002" "TX_R0402" list(3908.000000 1452.000000) nil) | 12@@list("R1003" "TX_R0402" list(3982.000000 1452.000000) nil) | 12@@list("R1004" "TX_R0402" list(3871.000000 1452.000000) nil) | 12@@list("R1005" "TX_R0402" list(4788.000000 2323.000000) nil) | 12@@list("R1006" "TX_R0402" list(4854.920000 2316.000000) nil) | 12@@list("R1007" "TX_R0402" list(3516.120000 1965.500000) nil) | 12@@list("R1008" "TX_R0402_0OHM" list(3436.880000 1917.000000) nil) | 12@@list("R1010" "TX_R0402" list(3945.000000 1452.000000) nil) | 12@@list("R1017" "TX_R0402" list(4658.000000 1217.000000) nil) | 12@@list("R1018" "TX_R0402" list(4722.000000 1218.990000) nil) | 12@@list("R1022" "TX_R0402" list(4215.000000 1285.000000) nil) | 12@@list("R1023" "TX_R0402" list(4224.400000 1375.200000) nil) | 12@@list("R1024" "TX_R0402" list(4251.000000 1285.000000) nil) | 12@@list("R1025" "TX_R0402" list(4287.000000 1285.000000) nil) | 12@@list("R1026" "TX_R0402" list(4323.000000 1285.000000) nil) | 12@@list("R1027" "TX_R0402" list(4261.000000 1375.000000) nil) | 12@@list("R1028" "TX_R0402" list(4286.200000 1484.300000) nil) | 12@@list("R1029" "TX_R0402" list(4305.000000 1377.300000) nil) | 12@@list("R1030" "TX_R0402" list(3834.000000 1452.000000) nil) | 12@@list("R1100" "TX_R0402" list(4709.500000 1383.500000) nil) | 12@@list("R1101" "TX_R0402" list(4652.000000 1391.000000) nil) | 12@@list("R1106" "TX_R0402" list(4178.300000 1338.900000) nil) | 12@@list("R1110" "TX_R0402" list(3508.000000 1712.000000) nil) | 12@@list("R1111" "TX_R0402" list(3472.000000 1712.000000) nil) | 12@@list("R1112" "TX_R0402" list(3435.000000 1712.000000) nil) | 12@@list("R1113" "TX_R0402" list(3394.000000 1712.000000) nil) | 12@@list("R1114" "TX_R0402" list(4614.200000 1369.990000) nil) | 12@@list("R1200" "TX_R0402" list(3538.000000 1549.000000) nil) | 12@@list("R1204" "TX_R0402" list(3437.000000 1370.000000) nil) | 12@@list("R1205" "TX_R0402" list(5275.000000 1544.000000) nil) | 12@@list("R1208" "TX_R0402" list(3363.500000 1371.000000) nil) | 12@@list("R1209" "TX_R0402" list(3400.000000 1371.000000) nil) | 12@@list("R1210" "TX_R0402" list(4359.000000 1285.000000) nil) | 12@@list("R1211" "TX_R0402_SHORT" list(4836.000000 1298.000000) nil) | 12@@list("R1212" "TX_R0402" list(4836.000000 1233.000000) nil) | 12@@list("R1217" "TX_R0402_0OHM" list(2567.000000 562.000000) nil) | 12@@list("R1218" "TX_R0402" list(2378.000000 779.000000) nil) | 12@@list("R1220" "TX_R0402" list(2300.000000 765.000000) nil) | 12@@list("R1221" "TX_R0402_0OHM" list(2235.000000 765.000000) nil) | 12@@list("R1226" "TX_R0402" list(3359.500000 1307.000000) nil) | 12@@list("R1229" "TX_R0402_0OHM" list(3356.000000 1451.000000) nil) | 12@@list("R1503" "TX_R0402" list(4468.000000 1154.000000) nil) | 12@@list("R1507" "TX_R0402" list(4142.000000 1339.000000) nil) | 12@@list("R1508" "TX_R0402" list(4143.600000 1410.400000) nil) | 12@@list("R1517" "TX_R0402" list(3445.000000 1528.000000) nil) | 12@@list("R1519" "TX_R0402" list(4463.000000 1298.500000) nil) | 12@@list("R1604" "TX_R0402_SHORT" list(4520.000000 1309.000000) nil) | 12@@list("R1606" "TX_R0402_SHORT" list(4751.000000 1920.000000) nil) | 12@@list("R1607" "TX_R0402" list(4395.500000 1245.000000) nil) | 12@@list("R1608" "TX_R0402" list(4207.400000 1491.600000) nil) | 12@@list("R1610" "TX_R0402_SHORT" list(4750.000000 2083.000000) nil) | 12@@list("R1611" "TX_R0402_SHORT" list(4790.000000 1994.000000) nil) | 12@@list("R1612" "TX_R0402_SHORT" list(4877.000000 1298.000000) nil) | 12@@list("R1615" "TX_R0402_0OHM" list(4578.000000 1369.990000) nil) | 12@@list("R1621" "TX_R0402_SHORT" list(5045.000000 1319.000000) nil) | 12@@list("R1622" "TX_R0402_SHORT" list(4264.000000 1934.000000) nil) | 12@@list("R1623" "TX_R0402_SHORT" list(4093.000000 1193.000000) nil) | 12@@list("R1624" "TX_R0402_SHORT" list(4528.000000 1396.000000) nil) | 12@@list("R1800" "TX_R0402_SHORT" list(2362.000000 567.000000) nil) | 12@@list("R1801" "TX_R0402_SHORT" list(2325.000000 567.000000) nil) | 12@@list("R1802" "TX_R0402" list(2420.000000 567.000000) nil) | 12@@list("R1803" "TX_R0402_SHORT" list(2486.000000 571.000000) nil) | 12@@list("R1804" "TX_R0402" list(2567.000000 680.000000) nil) | 12@@list("R1805" "TX_R0402_SHORT" list(2523.000000 571.000000) nil) | 12@@list("R1806" "TX_R0402_0OHM" list(2515.000000 666.000000) nil) | 12@@list("R1807" "TX_R0402" list(2528.000000 779.000000) nil) | 12@@list("R1914" "TX_R0402_SHORT" list(2735.000000 922.000000) nil) | 12@@list("R1915" "TX_R0402" list(2808.010000 952.000000) nil) | 12@@list("R1916" "TX_R0402_SHORT" list(1545.000000 1112.000000) nil) | 12@@list("R1917" "TX_R0402" list(2772.000000 952.000000) nil) | 12@@list("R1918" "TX_R0402" list(2747.000000 1081.990000) nil) | 12@@list("R1919" "TX_R0402" list(2720.000000 866.000000) nil) | 12@@list("R1920" "TX_R0402" list(3254.000000 647.000000) nil) | 12@@list("R1921" "TX_R0402" list(2836.000000 810.000000) nil) | 12@@list("R2000" "TX_R0402" list(2234.000000 2728.000000) nil) | 12@@list("R2001" "TX_R0402_0OHM" list(2234.000000 2765.000000) nil) | 12@@list("R2002" "TX_R0402" list(2386.000000 2569.000000) nil) | 12@@list("R2003" "TX_R0402" list(2211.810000 2093.620000) nil) | 12@@list("R2004" "TX_R0402" list(2211.810000 2167.620000) nil) | 12@@list("R2005" "TX_R0402" list(2211.810000 2205.620000) nil) | 12@@list("R2006" "TX_R0402" list(2127.310000 2155.620000) nil) | 12@@list("R2100" "TX_R0402" list(1755.810000 2455.700000) nil) | 12@@list("R2101" "TX_R0402" list(1742.000000 2250.000000) nil) | 12@@list("R2102" "TX_R0402" list(1742.000000 2213.000000) nil) | 12@@list("R2103" "TX_R0402" list(1741.810000 2176.620000) nil) | 12@@list("R2104" "TX_R0402" list(1661.560000 2319.510000) nil) | 12@@list("R2300" "TX_R0402" list(1365.000000 1267.000000) nil) | 12@@list("R2301" "TX_R0402_SHORT" list(1685.000000 1741.000000) nil) | 12@@list("R2302" "TX_R0402_SHORT" list(1562.000000 1794.000000) nil) | 12@@list("R2305" "TX_R0402" list(1674.000000 1672.000000) nil) | 12@@list("R2306" "TX_R0402" list(1631.000000 1817.000000) nil) | 12@@list("R2307" "TX_R0402_SHORT" list(1563.000000 2128.000000) nil) | 12@@list("R2308" "TX_R0402_SHORT" list(1559.000000 1866.500000) nil) | 12@@list("R2309" "TX_R0402" list(1632.200000 2431.220000) nil) | 12@@list("R2310" "TX_R0402" list(1632.000000 2505.000000) nil) | 12@@list("R2311" "TX_R0402" list(1607.500000 1557.000000) nil) | 12@@list("R2312" "TX_R0402" list(1588.000000 1493.500000) nil) | 12@@list("R2313" "TX_R0402" list(1624.000000 1493.500000) nil) | 12@@list("R2314" "TX_R0402" list(1632.000000 1607.000000) nil) | 12@@list("R2315" "TX_R0402" list(1596.000000 1607.000000) nil) | 12@@list("R2316" "TX_R0402" list(1305.000000 2110.000000) nil) | 12@@list("R2317" "TX_R0402" list(1264.000000 2091.000000) nil) | 12@@list("R2318" "TX_R0402" list(1283.000000 2309.000000) nil) | 12@@list("R2319" "TX_R0402" list(1313.910000 2205.350000) nil) | 12@@list("R2320" "TX_R0402" list(963.000000 1258.000000) nil) | 12@@list("R2321" "TX_R0402_SHORT" list(1439.000000 1267.000000) nil) | 12@@list("R2322" "TX_R0402" list(979.000000 2190.000000) nil) | 12@@list("R2323" "TX_R0402_SHORT" list(975.000000 2107.000000) nil) | 12@@list("R2324" "TX_R0402" list(1635.000000 1727.500000) nil) | 12@@list("R2325" "TX_R0402" list(1635.000000 1764.000000) nil) | 12@@list("R2326" "TX_R0402" list(1214.000000 2093.000000) nil) | 12@@list("R2328" "TX_R0402_0OHM" list(1565.000000 1658.000000) nil) | 12@@list("R2329" "TX_R0402_0OHM" list(1575.000000 1942.000000) nil) | 12@@list("R2330" "TX_R0402_0OHM" list(1577.000000 1983.000000) nil) | 12@@list("R2331" "TX_R0402" list(738.790000 1611.390000) nil) | 12@@list("R2332" "TX_R0402" list(1560.000000 1830.000000) nil) | 12@@list("R2333" "TX_R0402" list(1258.000000 1236.000000) nil) | 12@@list("R2334" "TX_R0402" list(738.000000 1994.000000) nil) | 12@@list("R2335" "TX_R0402" list(740.000000 1702.500000) nil) | 12@@list("R2336" "TX_R0402_SHORT" list(739.000000 1648.000000) nil) | 12@@list("R2337" "TX_R0402" list(1172.000000 1174.000000) nil) | 12@@list("R2338" "TX_R0402" list(1135.000000 1174.000000) nil) | 12@@list("R2339" "TX_R0402" list(1537.000000 2417.000000) nil) | 12@@list("R2341" "TX_R0402" list(1381.000000 2111.000000) nil) | 12@@list("R2342" "TX_R0402" list(1501.600000 2135.600000) nil) | 12@@list("R2343" "TX_R0402" list(1550.000000 1495.000000) nil) | 12@@list("R2344" "TX_R0402" list(915.000000 1260.000000) nil) | 12@@list("R2345" "TX_R0402_SHORT" list(737.000000 1893.000000) nil) | 12@@list("R2346" "TX_R0402_SHORT" list(934.000000 2103.000000) nil) | 12@@list("R2347" "TX_R0402" list(737.000000 1751.000000) nil) | 12@@list("R2348" "TX_R0402" list(1495.780000 2416.400000) nil) | 12@@list("R2349" "TX_R0402" list(1056.000000 1262.000000) nil) | 12@@list("R2351" "TX_R0402" list(1636.000000 1390.000000) nil) | 12@@list("R2400" "TX_R0402_SHORT" list(1221.000000 1237.000000) nil) | 12@@list("R2401" "TX_R0402_SHORT" list(494.000000 2190.000000) nil) | 12@@list("R2402" "TX_R0402_SHORT" list(495.000000 2259.000000) nil) | 12@@list("R2403" "TX_R0402_SHORT" list(316.000000 1012.000000) nil) | 12@@list("R2404" "TX_R0402_0OHM" list(479.000000 2418.000000) nil) | 12@@list("R2405" "TX_R0402" list(495.000000 2330.000000) nil) | 12@@list("R2406" "TX_R0402" list(653.000000 2278.000000) nil) | 12@@list("R2407" "TX_R0402" list(659.000000 2319.000000) nil) | 12@@list("R2408" "TX_R0402" list(653.000000 2237.000000) nil) | 12@@list("R2409" "TX_R0402_SHORT" list(866.000000 1212.000000) nil) | 12@@list("R2410" "TX_R0402_SHORT" list(891.000000 1171.000000) nil) | 12@@list("R2411" "TX_R0402" list(802.000000 1212.000000) nil) | 12@@list("R2412" "TX_R0402" list(1061.000000 2190.000000) nil) | 12@@list("R2413" "TX_R0402" list(1020.000000 2190.000000) nil) | 12@@list("R2414" "TX_R0402" list(991.000000 1056.000000) nil) | 12@@list("R2423" "TX_R0402" list(1007.000000 1258.000000) nil) | 12@@list("R2424" "TX_R0402" list(280.000000 1012.000000) nil) | 12@@list("R2500" "TX_R0402_0OHM" list(3493.000000 1115.650000) nil) | 12@@list("R2501" "TX_R0402" list(3581.000000 1452.650000) nil) | 12@@list("R2502" "TX_R0402" list(3654.000000 1452.650000) nil) | 12@@list("R2503" "TX_R0402" list(3730.000000 1452.650000) nil) | 12@@list("R2504" "TX_R0402" list(3508.000000 1452.650000) nil) | 12@@list("R2505" "TX_R0402" list(3544.500000 1452.650000) nil) | 12@@list("R2506" "TX_R0402" list(3617.500000 1452.650000) nil) | 12@@list("R2507" "TX_R0402" list(3693.000000 1452.650000) nil) | 12@@list("R2508" "TX_R0402" list(3767.000000 1452.650000) nil) | 12@@list("R2509" "TX_R0402" list(3420.000000 1122.650000) nil) | 12@@list("R2510" "TX_R0402_SHORT" list(3343.000000 1214.350000) nil) | 12@@list("R2511" "TX_R0402_SHORT" list(3494.000000 1279.000000) nil) | 12@@list("R2512" "TX_R0402" list(3457.000000 1122.650000) nil) | 12@@list("R2513" "TX_R0402" list(3346.000000 1144.650000) nil) | 12@@list("R2514" "TX_R0402" list(3383.000000 1124.650000) nil) | 12@@list("R2600" "TX_R0402" list(922.000000 3101.000000) nil) | 12@@list("R2601" "TX_R0402" list(656.000000 3128.000000) nil) | 12@@list("R2602" "TX_R0402" list(351.000000 3287.000000) nil) | 12@@list("R2900" "TX_R0402" list(813.000000 2747.000000) nil) | 12@@list("R2901" "TX_R0402" list(913.000000 2813.000000) nil) | 12@@list("R2903" "TX_R0402" list(622.000000 2821.000000) nil) | 12@@list("R2904" "TX_R0402" list(622.000000 2784.800000) nil) | 12@@list("R2905" "TX_R0402" list(654.000000 2729.000000) nil) | 12@@list("R2906" "TX_R0402" list(654.000000 2692.800000) nil) | 12@@list("R2907" "TX_R0402" list(654.000000 2633.000000) nil) | 12@@list("R2908" "TX_R0402" list(654.000000 2596.800000) nil) | 12@@list("R2909" "TX_R0402" list(655.990000 2912.000000) nil) | 12@@list("R2910" "TX_R0402" list(656.000000 2875.800000) nil) | 12@@list("R2911" "TX_R0402" list(385.000000 2905.000000) nil) | 12@@list("R2912" "TX_R0402" list(384.000000 2950.000000) nil) | 12@@list("R2913" "TX_R0402" list(957.000000 3024.000000) nil) | 12@@list("R3004" "TX_R0402_SHORT" list(2019.000000 4153.500000) nil) | 12@@list("R3009" "TX_R0402" list(2008.000000 4058.000000) nil) | 12@@list("R3102" "TX_R0402_0OHM" list(8424.000000 888.000000) nil) | 12@@list("R3103" "TX_R0402_SHORT" list(8445.000000 512.000000) nil) | 12@@list("R3104" "TX_R0402_SHORT" list(8521.000000 482.000000) nil) | 12@@list("R3105" "TX_R0402" list(8370.000000 429.000000) nil) | 12@@list("R3106" "TX_R0402_0OHM" list(8314.000000 411.000000) nil) | 12@@list("R3107" "TX_R0402" list(8370.000000 356.600000) nil) | 12@@list("R3113" "TX_R0402" list(8522.000000 445.000000) nil) | 12@@list("R3114" "TX_R0402" list(8370.000000 392.800000) nil) | 12@@list("R3116" "TX_R0402_0OHM" list(8505.000000 922.000000) nil) | 12@@list("R3609" "TX_R0402" list(2222.000000 1186.000000) nil) | 12@@list("R3612" "TX_R0402" list(2171.000000 1159.000000) nil) | 12@@list("R3613" "TX_R0402" list(3689.000000 3647.000000) nil) | 12@@list("R3614" "TX_R0402" list(3663.000000 3445.000000) nil) | 12@@list("R3700" "TX_R0402" list(5723.000000 1120.000000) nil) | 12@@list("R3701" "TX_R0402" list(5723.000000 1083.000000) nil) | 12@@list("R3702" "TX_R0402_SHORT" list(5872.000000 1272.000000) nil) | 12@@list("R3703" "TX_R0402" list(5723.000000 1046.000000) nil) | 12@@list("R3704" "TX_R0402_SHORT" list(5822.000000 1229.000000) nil) | 12@@list("R3705" "TX_R0402_SHORT" list(5723.000000 1211.000000) nil) | 12@@list("R3706" "TX_R0402_SHORT" list(5872.000000 1322.000000) nil) | 12@@list("R3707" "TX_R0402" list(125.000000 2472.000000) nil) | 12@@list("R3709" "TX_R0402" list(3497.000000 2056.000000) nil) | 12@@list("R3801" "TX_R0402" list(336.730000 1376.340000) nil) | 12@@list("R3804" "TX_R0402_0OHM" list(401.000000 1667.000000) nil) | 12@@list("R3806" "TX_R0603_0OHM_H24" list(-22.000000 877.480000) nil) | 12@@list("R3807" "TX_R0603_0OHM_H24" list(32.000000 877.480000) nil) | 12@@list("R3812" "TX_R0603_0OHM_H24" list(84.000000 876.480000) nil) | 12@@list("R3813" "TX_R0603_0OHM_H24" list(138.000000 876.480000) nil) | 12@@list("R3814" "TX_R0402" list(341.000000 1606.000000) nil) | 12@@list("R3815" "TX_R0402_0OHM" list(407.000000 2083.000000) nil) | 12@@list("R3816" "TX_R0402_0OHM" list(357.280000 1444.770000) nil) | 12@@list("R3817" "TX_R0402_0OHM" list(79.000000 1721.000000) nil) | 12@@list("R3819" "TX_R0402_0OHM" list(354.000000 2438.000000) nil) | 12@@list("R3821" "TX_R0402_0OHM" list(277.810000 1169.190000) nil) | 12@@list("R3826" "TX_R0402" list(271.000000 1106.000000) nil) | 12@@list("R3827" "TX_R0402_0OHM" list(401.040000 1704.320000) nil) | 12@@list("R3901" "TX_R0402_SHORT" list(1274.000000 2826.000000) nil) | 12@@list("R3902" "TX_R0402_SHORT" list(1186.000000 2506.000000) nil) | 12@@list("R3903" "TX_R0402_0OHM" list(1150.000000 2506.000000) nil) | 12@@list("R3904" "TX_R0402_0OHM" list(1353.000000 2615.000000) nil) | 12@@list("R3905" "TX_R0402_SHORT" list(1128.000000 2827.000000) nil) | 12@@list("R3907" "TX_R0402" list(1020.010000 2791.300000) nil) | 12@@list("R3908" "TX_R0402_SHORT" list(1020.010000 2718.500000) nil) | 12@@list("R3909" "TX_R0402" list(1009.010000 2682.000000) nil) | 12@@list("R3910" "TX_R0402" list(1076.000000 2506.010000) nil) | 12@@list("R3911" "TX_R0402" list(1114.000000 2506.000000) nil) | 12@@list("R3912" "TX_R0402_0OHM" list(1024.000000 2501.000000) nil) | 12@@list("R3913" "TX_R0402" list(1020.000000 2755.000000) nil) | 12@@list("R3914" "TX_R0402_0OHM" list(1353.000000 2579.000000) nil) | 12@@list("R3915" "TX_R0402_0OHM" list(1238.000000 2826.000000) nil) | 12@@list("R3916" "TX_R0402" list(1089.000000 2827.000000) nil) | 12@@list("R3917" "TX_R0402_0OHM" list(1323.500000 2843.000000) nil) | 12@@list("R3918" "TX_R0402_0OHM" list(1323.500000 2807.000000) nil) | 12@@list("R5000" "TX_R0402" list(289.000000 3878.000000) nil) | 12@@list("R5001" "TX_R0402" list(299.000000 3915.000000) nil) | 12@@list("R5002" "TX_R0402" list(730.000000 3793.000000) nil) | 12@@list("R5004" "TX_R0402" list(1028.000000 3928.000000) nil) | 12@@list("R5102" "TX_R0402" list(1943.500000 565.000000) nil) | 12@@list("R5103" "TX_R0402" list(1825.990000 565.000000) nil) | 12@@list("R5104" "TX_R0402" list(1862.500000 565.000000) nil) | 12@@list("R5105" "TX_R0402" list(2053.400000 565.000000) nil) | 12@@list("R5106" "TX_R0402" list(2125.800000 565.000000) nil) | 12@@list("R5107" "TX_R0402" list(1480.000000 520.000000) nil) | 12@@list("R5108" "TX_R0402" list(1980.000000 565.000000) nil) | 12@@list("R5109" "TX_R0402_SHORT" list(1477.000000 590.000000) nil) | 12@@list("R5704" "TX_R0402" list(663.930000 3313.460000) nil) | 12@@list("R5705" "TX_R0402" list(685.500000 3263.000000) nil) | 12@@list("R5706" "TX_R0402_0OHM" list(777.000000 3302.000000) nil) | 12@@list("R5707" "TX_R0402" list(740.000000 3302.000000) nil) | 12@@list("R5710" "TX_R0402" list(833.000000 3707.000000) nil) | 12@@list("R5711" "TX_R0402" list(762.000000 3707.000000) nil) | 12@@list("R5714" "TX_R0402_SHORT" list(926.000000 3300.000000) nil) | 12@@list("R5716" "TX_R0402_0OHM" list(1170.000000 3408.000000) nil) | 12@@list("R5717" "TX_R0402" list(1090.000000 3368.000000) nil) | 12@@list("R5718" "TX_R0402" list(1090.000000 3408.000000) nil) | 12@@list("R5719" "TX_R0402_SHORT" list(885.000000 3704.000000) nil) | 12@@list("R5720" "TX_R0402_0OHM" list(1170.000000 3368.000000) nil) | 12@@list("R5725" "TX_R0402" list(751.000000 3670.000000) nil) | 12@@list("R5800" "TX_R0402" list(824.000000 2582.000000) nil) | 12@@list("R5801" "TX_R0402_SHORT" list(824.000000 2647.000000) nil) | 12@@list("R5802" "TX_R0402" list(1578.000000 3440.000000) nil) | 12@@list("R5803" "TX_R0402" list(1430.000000 3526.000000) nil) | 12@@list("R5804" "TX_R0402" list(1430.000000 3489.500000) nil) | 12@@list("R5805" "TX_R0402_SHORT" list(1245.000000 3465.000000) nil) | 12@@list("R5806" "TX_R0402" list(1286.000000 3465.000000) nil) | 12@@list("R5807" "TX_R0402" list(1197.000000 3275.000000) nil) | 12@@list("R5808" "TX_R0402" list(1488.000000 3108.000000) nil) | 12@@list("R5809" "TX_R0402" list(1613.000000 3208.000000) nil) | 12@@list("R5810" "TX_R0402" list(1323.000000 3465.000000) nil) | 12@@list("R5811" "TX_R0402" list(1360.000000 3465.000000) nil) | 12@@list("R5812" "TX_R0402" list(1366.000000 3526.500000) nil) | 12@@list("R5816" "TX_R0402_0OHM" list(1405.000000 3060.000000) nil) | 12@@list("R5817" "TX_R0402" list(1136.000000 3820.000000) nil) | 12@@list("R5818" "TX_R0402" list(1158.500000 3150.000000) nil) | 12@@list("R5821" "TX_R0402" list(1202.000000 3311.000000) nil) | 12@@list("R5822" "TX_R0402" list(1197.000000 3203.000000) nil) | 12@@list("R5823" "TX_R0402" list(1197.000000 3239.000000) nil) | 12@@list("R5826" "TX_R0402" list(1518.000000 3466.000000) nil) | 12@@list("R5827" "TX_R0402" list(1481.000000 3466.000000) nil) | 12@@list("R5904" "TX_R0402" list(457.000000 3749.000000) nil) | 12@@list("R5906" "TX_R0402" list(570.000000 3749.000000) nil) | 12@@list("R5907" "TX_R0402" list(283.000000 3795.000000) nil) | 12@@list("R6200" "TX_R0402" list(5945.000000 3938.000000) nil) | 12@@list("R6202" "TX_R0402" list(5895.000000 3914.000000) nil) | 12@@list("R6203" "TX_R0402" list(5895.000000 3951.000000) nil) | 12@@list("R6204" "TX_R0402" list(5813.000000 3820.000000) nil) | 12@@list("R6205" "TX_R0402" list(5762.000000 3817.000000) nil) | 12@@list("R6206" "TX_R0402" list(5831.000000 3934.000000) nil) | 12@@list("R6207" "TX_R0402" list(5762.000000 3854.000000) nil) | 12@@list("R6300" "TX_R0402" list(6889.000000 3324.000000) nil) | 12@@list("R6301" "TX_R0402" list(6888.000000 3453.000000) nil) | 12@@list("R6302" "TX_R0402" list(6889.000000 3361.000000) nil) | 12@@list("R6308" "TX_R0402" list(6370.000000 3302.500000) nil) | 12@@list("R6309" "TX_R0402" list(6387.000000 3239.500000) nil) | 12@@list("R6803" "TX_R0402" list(7063.000000 4080.000000) nil) | 12@@list("R6805" "TX_R0402" list(7689.990000 3328.000000) nil) | 12@@list("R6808" "TX_R0402" list(7002.000000 4144.000000) nil) | 12@@list("R6809" "TX_R0402" list(7039.000000 4144.000000) nil) | 12@@list("R6818" "TX_R0402" list(7678.000000 3243.000000) nil) | 12@@list("R6908" "TX_R0402_0OHM" list(6271.000000 3482.000000) nil) | 12@@list("R6934" "TX_R0402" list(6108.000000 3452.990000) nil) | 12@@list("R6935" "TX_R0402" list(6138.000000 3482.990000) nil) | 12@@list("R6936" "TX_R0402" list(6426.000000 3390.000000) nil) | 12@@list("R6937" "TX_R0402" list(5372.000000 3451.000000) nil) | 12@@list("R6938" "TX_R0402" list(5786.000000 3152.000000) nil) | 12@@list("R6939" "TX_R0402" list(5697.000000 4355.000000) nil) | 12@@list("R6940" "TX_R0402" list(5659.000000 4355.000000) nil) | 12@@list("R6941" "TX_R0402" list(5418.000000 3401.000000) nil) | 12@@list("RN5701" "TX_2R4P0402_47X55_COLAY" list(321.000000 3729.000000) nil) | 12@@list("RN5702" "TX_2R4P0402_47X55_COLAY" list(491.000000 3619.000000) nil) | 12@@list("RN5703" "TX_2R4P0402_47X55_COLAY" list(473.000000 3353.000000) nil) | 12@@list("RN5704" "TX_2R4P0402_47X55_COLAY" list(509.000000 3535.000000) nil) | 12@@list("RN5705" "TX_2R4P0402_47X55_COLAY" list(647.000000 3461.000000) nil) | 12@@list("T0400" "NB_TPC26T_50" list(4797.000000 2844.500000) nil) | 12@@list("T0401" "NB_TPC26T_50" list(5269.000000 2754.000000) nil) | 12@@list("T0402" "NB_TPC26T_50" list(5267.000000 2819.000000) nil) | 12@@list("T0403" "NB_TPC26T_50" list(5320.000000 2829.000000) nil) | 12@@list("T0405" "NB_TPC26T_50" list(4858.000000 2786.500000) nil) | 12@@list("T0406" "NB_TPC26T_50" list(4760.500000 2775.500000) nil) | 12@@list("T0409" "NB_TPC26T_50" list(4671.000000 1270.000000) nil) | 12@@list("T0411" "NB_TPC26T_50" list(4792.000000 2719.000000) nil) | 12@@list("T0412" "NB_TPC26T_50" list(4807.500000 2795.000000) nil) | 12@@list("T0902" "NB_TPC26T_50" list(4104.750000 2841.410000) nil) | 12@@list("T0903" "NB_TPC26T_50" list(5268.000000 2877.000000) nil) | 12@@list("T0905" "NB_TPC26T_50" list(4045.000000 2811.000000) nil) | 12@@list("T0908" "NB_TPC26T_50" list(4859.320000 3370.040000) nil) | 12@@list("T0909" "NB_TPC26T_50" list(4888.320000 3434.040000) nil) | 12@@list("T0910" "NB_TPC26T_50" list(4770.320000 3274.040000) nil) | 12@@list("T0911" "NB_TPC26T_50" list(4749.320000 3373.040000) nil) | 12@@list("T0912" "NB_TPC26T_50" list(4788.320000 3421.040000) nil) | 12@@list("T0913" "NB_TPC26T_50" list(4844.320000 3473.040000) nil) | 12@@list("T0914" "NB_TPC26T_50" list(4742.320000 3473.040000) nil) | 12@@list("T0915" "NB_TPC26T_50" list(4762.320000 3324.040000) nil) | 12@@list("T0916" "NB_TPC26T_50" list(4738.320000 3422.040000) nil) | 12@@list("T0917" "NB_TPC26T_50" list(4793.320000 3472.040000) nil) | 12@@list("T0918" "NB_TPC26T_50" list(4896.320000 3336.040000) nil) | 12@@list("T0919" "NB_TPC26T_50" list(4908.320000 3386.040000) nil) | 12@@list("T0920" "NB_TPC26T_50" list(4839.320000 3420.040000) nil) | 12@@list("T0921" "NB_TPC26T_50" list(4809.320000 3371.040000) nil) | 12@@list("T1002" "NB_TPC26T_50" list(3977.000000 2025.000000) nil) | 12@@list("T1003" "NB_TPC26T_50" list(3514.000000 1880.000000) nil) | 12@@list("T1005" "NB_TPC26T_50" list(4720.000000 2507.000000) nil) | 12@@list("T1006" "NB_TPC26T_50" list(4707.000000 2557.000000) nil) | 12@@list("T1105" "NB_TPC26T_50" list(3499.000000 1555.000000) nil) | 12@@list("T1106" "NB_TPC26T_50" list(4046.000000 1500.000000) nil) | 12@@list("T1107" "NB_TPC26T_50" list(4309.910000 1155.900000) nil) | 12@@list("T1203" "NB_TPC26T_50" list(4214.000000 1915.000000) nil) | 12@@list("T1204" "NB_TPC26T_50" list(3461.000000 1471.000000) nil) | 12@@list("T1205" "NB_TPC26T_50" list(3324.000000 1374.000000) nil) | 12@@list("T1207" "NB_TPC26T_50" list(3400.000000 1818.000000) nil) | 12@@list("T1400" "NB_TPC26T_50" list(4853.000000 2701.000000) nil) | 12@@list("T1500" "NB_TPC26T_50" list(3488.000000 1832.000000) nil) | 12@@list("T1504" "NB_TPC26T_50" list(4487.000000 1234.000000) nil) | 12@@list("T1505" "NB_TPC26T_50" list(4370.000000 1417.000000) nil) | 12@@list("T1509" "NB_TPC26T_50" list(4520.000000 1150.000000) nil) | 12@@list("T1510" "NB_TPC26T_50" list(4101.710000 1509.310000) nil) | 12@@list("T1511" "NB_TPC26T_50" list(4020.000000 1456.000000) nil) | 12@@list("T1512" "NB_TPC26T_50" list(4197.000000 1173.000000) nil) | 12@@list("T1513" "NB_TPC26T_50" list(4500.000000 1925.500000) nil) | 12@@list("T2300" "TPC40T_68" list(1439.000000 1325.000000) nil) | 12@@list("T2301" "TPC40T_68" list(757.000000 1947.000000) nil) | 12@@list("T2302" "TPC40T_68" list(672.000000 1833.000000) nil) | 12@@list("T2303" "TPC40T_68" list(1573.000000 1380.000000) nil) | 12@@list("T2305" "TPC40T_68" list(1465.000000 1389.000000) nil) | 12@@list("T2306" "TPC40T_68" list(1514.000000 1334.000000) nil) | 12@@list("T2307" "TPC40T_68" list(1254.000000 1294.000000) nil) | 12@@list("T2308" "TPC40T_68" list(790.470000 1378.620000) nil) | 12@@list("T3600" "TPC40T_68" list(3786.000000 757.000000) nil) | 12@@list("T5700" "MX_TPC26T_S4_68" list(666.000000 3560.500000) nil) | 12@@list("T5701" "MX_TPC26T_S4_68" list(627.000000 3631.000000) nil) | 12@@list("T5801" "MX_TPC26T_S4_68" list(1153.000000 3517.000000) nil) | 12@@list("T6300" "MX_TPC26T_S4_68" list(6276.000000 3309.000000) nil) | 12@@list("T6301" "MX_TPC26T_S4_68" list(6447.000000 3439.000000) nil) | 12@@list("T6302" "NB_TPC26T_50" list(6437.000000 3915.000000) nil) | 12@@list("T6303" "NB_TPC26T_50" list(6401.000000 3628.000000) nil) | 12@@list("T6900" "NB_TPC26T_50" list(6364.000000 3426.000000) nil) | 12@@list("T6905" "NB_TPC26T_50" list(6034.000000 2975.000000) nil) | 12@@list("T6906" "NB_TPC26T_50" list(5672.000000 3258.000000) nil) | 12@@list("T6907" "NB_TPC26T_50" list(5634.000000 3295.000000) nil) | 12@@list("T6908" "NB_TPC26T_50" list(5845.000000 3129.000000) nil) | 12@@list("T6909" "NB_TPC26T_50" list(5711.000000 3221.000000) nil) | 12@@list("T6910" "NB_TPC26T_50" list(5762.000000 3198.000000) nil) | 12@@list("T6911" "NB_TPC26T_50" list(5887.000000 3093.000000) nil) | 12@@list("T6912" "NB_TPC26T_50" list(5927.000000 3001.000000) nil) | 12@@list("T6913" "NB_TPC26T_50" list(5926.000000 3054.000000) nil) | 12@@list("T6915" "NB_TPC26T_50" list(5978.000000 2954.000000) nil) | 12@@list("T6916" "NB_TPC26T_50" list(5927.000000 2948.000000) nil) | 12@@list("T6917" "NB_TPC26T_50" list(5979.000000 3004.000000) nil) | 12@@list("T6925" "NB_TPC26T_50" list(6223.000000 3387.000000) nil) | 12@@list("T6926" "NB_TPC26T_50" list(6270.000000 3368.000000) nil) | 12@@list("T6927" "NB_TPC26T_50" list(5597.000000 3258.000000) nil) | 12@@list("T6928" "NB_TPC26T_50" list(6105.000000 3614.000000) nil) | 12@@list("T6929" "NB_TPC26T_50" list(5608.000000 3208.000000) nil) | 12@@list("T6935" "NB_TPC26T_50" list(6178.000000 3417.000000) nil) | 12@@list("T6937" "NB_TPC26T_50" list(5555.000000 3230.000000) nil) | 12@@list("T6938" "NB_TPC26T_50" list(5489.000000 3393.000000) nil) | 12@@list("T6940" "NB_TPC26T_50" list(5699.000000 3891.000000) nil) | 12@@list("T6941" "NB_TPC26T_50" list(6173.000000 3501.000000) nil) | 12@@list("T6943" "NB_TPC26T_50" list(6789.000000 3062.000000) nil) | 12@@list("T6944" "NB_TPC26T_50" list(6226.000000 3483.000000) nil) | 12@@list("T6945" "NB_TPC26T_50" list(6780.000000 3003.000000) nil) | 12@@list("T6946" "NB_TPC26T_50" list(6780.000000 2928.000000) nil) | 12@@list("TR3700" "TX_R0402_H24" list(3953.000000 2078.000000) nil) | 12@@list("U2500" "A_BGA_153P_20_516X457_H39" list(3756.730000 1121.270000) nil) | 12@@list("U3701" "TX_LGA_12P_20_87X87_ST" list(5848.000000 1100.000000) nil) | 12@@list("U5800" "TX_QFN_40P_20_S240_P_4V" list(1380.000000 3275.000000) nil) | 12@@list("U6801" "TX_BGA_170P_31_555X476" list(7370.000000 4135.000000) nil) | 12@@list("U6803" "TX_BGA_170P_31_555X476" list(7370.410000 3387.730000) nil) | 12@@list("X1001" "TX_XTAL_2P_126X59" list(3368.060000 1914.000000) nil) | 12@@list("X2300" "TX_XTAL_2P_126X59" list(1597.310000 2043.490000) nil) | 13@@list("J5300" "TX_FPC_12P_20_2HD_RA_PANA" list(3293.000000 432.820000) nil) | 13@@list("J5301" "TX_FPC_12P_20_2HD_RA_PANA" list(1525.180000 2747.000000) nil) | 13@@list("PU8600" "TX_QFN_20P_16_S118_P_H31_4V" list(3745.000000 4105.000000) nil) | 13@@list("PU9001" "TX_DFN_10P_16_122X83_P_COLA" list(1200.200000 3015.000000) nil) | 13@@list("U3901" "A_QFN_32P_20_S197_PAD_T01" list(1185.900000 2667.900000) nil) | 13@@list("U5703" "TX_QFN_40P_16_161X240_PD_8V" list(840.650000 3509.630000) nil) | 14@@list("U2300" "TX_QFP_128P_16_559X559" list(1155.000000 1675.000000) nil) | 15@@list("" "INDEXB_CROSS" list(1125.000000 485.000000) t) | 15@@list("" "INDEXB_CROSS" list(7804.000000 4283.990000) t) | 15@@list("" "INDEXB_CROSS" list(8156.010000 1138.930000) t) | 15@@list("C0400" "TX_C0402" list(5056.000000 3227.000000) t) | 15@@list("C0500" "TX_C0402" list(3515.450000 4545.940000) t) | 15@@list("C0607" "TX_C0402" list(5064.000000 1200.800000) t) | 15@@list("C0608" "TX_C0402" list(5027.000000 1200.800000) t) | 15@@list("C0707" "TX_C0402" list(5008.000000 2205.000000) t) | 15@@list("C0708" "TX_C0402" list(5211.710000 2683.280000) t) | 15@@list("C0709" "TX_C0402" list(5212.000000 2574.000000) t) | 15@@list("C0710" "TX_C0402" list(4943.280000 2205.290000) t) | 15@@list("C0713" "TX_C0402" list(5196.000000 2485.000000) t) | 15@@list("C0714" "TX_C0402" list(5202.000000 2139.000000) t) | 15@@list("C0715" "TX_C0402" list(5211.710000 2646.780000) t) | 15@@list("C0716" "TX_C0402" list(5202.000000 2102.000000) t) | 15@@list("C0734" "TX_C0402" list(5212.000000 2538.000000) t) | 15@@list("C0735" "TX_C0402" list(5212.000000 2610.000000) t) | 15@@list("C0736" "TX_C0402" list(5202.000000 2176.000000) t) | 15@@list("C0737" "TX_C0402" list(5151.000000 2202.000000) t) | 15@@list("C0738" "TX_C0402" list(5113.050000 2201.600000) t) | 15@@list("C0739" "TX_C0402" list(5045.000000 2205.000000) t) | 15@@list("C0900" "TX_C0402" list(4788.000000 1325.000000) t) | 15@@list("C0901" "TX_C0402" list(4915.000000 1331.000000) t) | 15@@list("C1000" "TX_C0402" list(5007.000000 2273.000000) t) | 15@@list("C1001" "TX_C0402" list(5007.060000 2401.000000) t) | 15@@list("C1004" "TX_C0402" list(3609.020000 1996.000000) t) | 15@@list("C1005" "TX_C0402" list(4148.000000 1115.000000) t) | 15@@list("C1006" "TX_C0402" list(4066.000000 1131.000000) t) | 15@@list("C1104" "TX_C0402" list(3752.000000 1452.000000) t) | 15@@list("C1105" "TX_C0402" list(3678.000000 1452.000000) t) | 15@@list("C1200" "TX_C0402" list(3769.000000 1314.000000) t) | 15@@list("C1203" "TX_C0402" list(3706.000000 1879.000000) t) | 15@@list("C1206" "TX_C0402" list(3650.000000 888.000000) t) | 15@@list("C1207" "TX_C0402" list(3628.000000 1273.000000) t) | 15@@list("C1604" "TX_C0402" list(4389.510000 1249.010000) t) | 15@@list("C1607" "TX_C0603_T02_H39" list(4974.000000 1331.000000) t) | 15@@list("C1609" "TX_C0603_T02_H39" list(5087.000000 1419.800000) t) | 15@@list("C1610" "TX_C0402" list(4946.000000 1439.500000) t) | 15@@list("C1616" "TX_C0603_T02_H39" list(5012.620000 1528.000000) t) | 15@@list("C1617" "TX_C0402" list(3715.000000 1452.000000) t) | 15@@list("C1627" "TX_C0603_T02_H39" list(5234.000000 1490.000000) t) | 15@@list("C1628" "TX_C0603_T02_H39" list(4238.000000 1036.000000) t) | 15@@list("C1631" "TX_C0402" list(4344.000000 1195.000000) t) | 15@@list("C1633" "TX_C0603_T02_H39" list(4281.000000 1264.000000) t) | 15@@list("C1634" "TX_C0603_T02_H39" list(4562.000000 1369.000000) t) | 15@@list("C1900" "TX_C0402" list(3909.000000 962.000000) t) | 15@@list("C1901" "TX_C0402" list(509.000000 2190.000000) t) | 15@@list("C1902" "TX_C0402" list(568.000000 1962.000000) t) | 15@@list("C2900" "TX_C0402" list(653.000000 2729.200000) t) | 15@@list("C2901" "TX_C0402" list(656.000000 2912.000000) t) | 15@@list("C2902" "TX_C0402" list(654.000000 2632.200000) t) | 15@@list("C2903" "TX_C0402" list(654.000000 2596.000000) t) | 15@@list("C2904" "TX_C0402" list(622.000000 2822.000000) t) | 15@@list("C2905" "TX_C0402" list(656.000000 2875.800000) t) | 15@@list("C2906" "TX_C0402" list(653.000000 2693.000000) t) | 15@@list("C2907" "TX_C0402" list(622.000000 2785.800000) t) | 15@@list("C3000" "TX_C0402_T02_H26" list(1784.000000 4126.000000) t) | 15@@list("C3001" "TX_C0402" list(2184.500000 4125.500000) t) | 15@@list("C3002" "TX_C0402" list(2146.000000 4106.000000) t) | 15@@list("C3004" "TX_C0402" list(2540.000000 4152.600000) t) | 15@@list("C3005" "TX_C0402" list(2502.000000 4152.600000) t) | 15@@list("C3006" "TX_C0402" list(2465.000000 4101.100000) t) | 15@@list("C3007" "TX_C0402" list(2428.800000 4101.100000) t) | 15@@list("C3008" "TX_C0402" list(2352.000000 4138.600000) t) | 15@@list("C3009" "TX_C0402" list(2388.200000 4138.600000) t) | 15@@list("C3010" "TX_C0402" list(1525.000000 4151.000000) t) | 15@@list("C3011" "TX_C0402" list(2230.000000 4121.000000) t) | 15@@list("C3104" "TX_C0402" list(8142.000000 995.000000) t) | 15@@list("C3105" "TX_C0402" list(8136.000000 958.900000) t) | 15@@list("C3106" "TX_C0402" list(8199.000000 943.000000) t) | 15@@list("C3107" "TX_C0402" list(8197.000000 907.000000) t) | 15@@list("C3120" "TX_C0402" list(4579.000000 811.000000) t) | 15@@list("C3121" "TX_C0402" list(4578.790000 775.000000) t) | 15@@list("C3122" "TX_C0402" list(4579.000000 738.210000) t) | 15@@list("C3123" "TX_C0402" list(4579.000000 702.000000) t) | 15@@list("C3124" "TX_C0603_T02_H39" list(4127.000000 894.000000) t) | 15@@list("C3125" "TX_C0402" list(4189.000000 926.000000) t) | 15@@list("C3127" "TX_C0603_T02_H39" list(4075.000000 894.000000) t) | 15@@list("C3600" "TX_C0402" list(8012.000000 3624.000000) t) | 15@@list("C3601" "TX_C0402" list(8012.000000 3662.000000) t) | 15@@list("C3602" "TX_C0402" list(7880.000000 2730.000000) t) | 15@@list("C3603" "TX_C0402" list(8012.000000 3741.000000) t) | 15@@list("C3604" "TX_C0402" list(5381.780000 995.000000) t) | 15@@list("C3700" "TX_C0402" list(4763.000000 3775.000000) t) | 15@@list("C3706" "TX_C0402" list(7836.000000 4425.000000) t) | 15@@list("C3800" "TX_C0402_T02_H28" list(649.180000 1481.150000) t) | 15@@list("C3802" "TX_C0402_T02_H28" list(497.000000 1191.000000) t) | 15@@list("C3803" "TX_C0402" list(509.000000 1229.000000) t) | 15@@list("C3808" "TX_C0805_T02_H55" list(335.000000 1843.000000) t) | 15@@list("C3809" "TX_C0805_T02_H55" list(261.000000 1843.000000) t) | 15@@list("C3810" "TX_C0402" list(12.500000 1816.000000) t) | 15@@list("C3811" "TX_C0402" list(-10.000000 2380.000000) t) | 15@@list("C3812" "TX_C0402" list(359.500000 2207.500000) t) | 15@@list("C3813" "TX_C0402" list(254.000000 2384.000000) t) | 15@@list("C3814" "TX_C0402" list(632.000000 1290.000000) t) | 15@@list("C3815" "TX_C0402_T02_H28" list(244.780000 1422.210000) t) | 15@@list("C3816" "TX_C0402" list(683.060000 1316.020000) t) | 15@@list("C3819" "TX_C0402_T02_H28" list(341.500000 1606.500000) t) | 15@@list("C3820" "TX_C0402" list(364.000000 1660.000000) t) | 15@@list("C3822" "TX_C0402" list(341.460000 1567.660000) t) | 15@@list("C3825" "TX_C0402_T02_H28" list(335.460000 1214.950000) t) | 15@@list("C3826" "TX_C0402" list(374.280000 1214.950000) t) | 15@@list("C3827" "TX_C0402_T02_H28" list(462.080000 1666.830000) t) | 15@@list("C3828" "TX_C0402" list(424.080000 1666.830000) t) | 15@@list("C3829" "TX_C0402_T02_H28" list(298.320000 1660.000000) t) | 15@@list("C3830" "TX_C0402" list(232.000000 1302.000000) t) | 15@@list("C3831" "TX_C0402" list(290.000000 1279.000000) t) | 15@@list("C3833" "TX_C0402" list(648.070000 1563.620000) t) | 15@@list("C3834" "TX_C0402" list(262.000000 1169.000000) t) | 15@@list("C3839" "TX_C0402" list(649.180000 1443.130000) t) | 15@@list("C3840" "TX_C0402" list(647.710000 1602.370000) t) | 15@@list("C3841" "TX_C0402" list(356.000000 2430.000000) t) | 15@@list("C3842" "TX_C0402" list(89.000000 2426.000000) t) | 15@@list("C3843" "TX_C0402" list(262.000000 1103.000000) t) | 15@@list("C5100" "TX_C0402" list(3036.170000 809.090000) t) | 15@@list("C5101" "TX_C0402" list(3108.350000 809.010000) t) | 15@@list("C5102" "TX_C0402" list(3072.170000 809.090000) t) | 15@@list("C5103" "TX_C0402" list(2962.350000 805.010000) t) | 15@@list("C5104" "TX_C0402" list(3180.350000 809.010000) t) | 15@@list("C5105" "TX_C0402" list(2345.360000 838.690000) t) | 15@@list("C5106" "TX_C0402" list(3217.170000 809.090000) t) | 15@@list("C5107" "TX_C0402" list(2382.360000 838.690000) t) | 15@@list("C5108" "TX_C0402" list(2495.360000 837.690000) t) | 15@@list("C5109" "TX_C0402" list(3144.350000 809.010000) t) | 15@@list("C5110" "TX_C0402" list(2418.360000 837.690000) t) | 15@@list("C5117" "TX_C0402" list(2569.360000 837.690000) t) | 15@@list("C5121" "TX_C0402" list(2454.360000 837.690000) t) | 15@@list("C5122" "TX_C0402" list(2533.360000 837.690000) t) | 15@@list("C5123" "TX_C0402" list(2606.360000 837.690000) t) | 15@@list("C5124" "TX_C0402" list(7767.380000 2154.520000) t) | 15@@list("C5125" "TX_C0402" list(6581.380000 1022.520000) t) | 15@@list("C5132" "TX_C0402" list(2999.170000 805.090000) t) | 15@@list("C5133" "TX_C0402" list(7802.000000 1495.000000) t) | 15@@list("C5134" "TX_C0402" list(7802.000000 1531.000000) t) | 15@@list("C5135" "TX_C0402" list(7317.000000 1144.000000) t) | 15@@list("C5136" "TX_C0402" list(7280.000000 1144.000000) t) | 15@@list("C5300" "TX_C0402" list(3650.000000 4582.550000) t) | 15@@list("C5723" "TX_C0603_T02_H39" list(290.000000 3684.000000) t) | 15@@list("C5724" "TX_C0402" list(462.000000 3292.000000) t) | 15@@list("C5808" "TX_C0402" list(472.000000 2978.000000) t) | 15@@list("C5809" "TX_C0402" list(340.000000 3216.000000) t) | 15@@list("C5810" "TX_C0402" list(683.000000 3002.000000) t) | 15@@list("C5900" "TX_C0603_T02_H39" list(343.000000 3688.000000) t) | 15@@list("C5903" "TX_C0603_T02_H39" list(275.000000 3907.000000) t) | 15@@list("C5905" "TX_C0402" list(615.000000 3762.000000) t) | 15@@list("C5907" "TX_C0603_T02_H39" list(514.000000 3975.000000) t) | 15@@list("C5908" "TX_C0603_T02_H39" list(621.000000 3975.000000) t) | 15@@list("C5909" "TX_C0603_T02_H39" list(674.000000 3870.000000) t) | 15@@list("C5910" "TX_C0603_T02_H39" list(567.000000 3975.000000) t) | 15@@list("C5911" "TX_C0603_T02_H39" list(620.000000 3870.000000) t) | 15@@list("C5913" "TX_C0603_T02_H39" list(674.000000 3975.000000) t) | 15@@list("C6008" "TX_C0402" list(5865.000000 4340.000000) t) | 15@@list("C6009" "TX_C0402" list(5902.000000 4340.000000) t) | 15@@list("C6010" "TX_C0402" list(5940.000000 4340.000000) t) | 15@@list("C6011" "TX_C0402" list(5978.000000 4340.000000) t) | 15@@list("C6012" "TX_C0402" list(6014.990000 4340.010000) t) | 15@@list("C6013" "TX_C0402" list(6052.010000 4340.020000) t) | 15@@list("C6014" "TX_C0402" list(6089.000000 4340.000000) t) | 15@@list("C6015" "TX_C0402" list(6126.000000 4340.000000) t) | 15@@list("C6016" "TX_C0402" list(5303.000000 3694.000000) t) | 15@@list("C6200" "TX_C0402" list(5588.500000 3861.490000) t) | 15@@list("C6301" "TX_C0402" list(6453.000000 4361.000000) t) | 15@@list("C6302" "TX_C0402" list(6268.000000 4364.000000) t) | 15@@list("C6600" "TX_C0402" list(7052.000000 4348.000000) t) | 15@@list("C6601" "TX_C0402" list(7057.000000 3962.000000) t) | 15@@list("C6602" "TX_C0402" list(7680.000000 4316.000000) t) | 15@@list("C6603" "TX_C0402" list(7680.000000 3907.000000) t) | 15@@list("C6604" "TX_C0402" list(7511.680000 4452.000000) t) | 15@@list("C6605" "TX_C0402" list(7052.000000 3612.000000) t) | 15@@list("C6606" "TX_C0402" list(7058.000000 3260.000000) t) | 15@@list("C6607" "TX_C0402" list(7678.000000 3533.000000) t) | 15@@list("C6608" "TX_C0402" list(7680.000000 3171.000000) t) | 15@@list("C6609" "TX_C0402" list(7385.000000 3075.000000) t) | 15@@list("C6610" "TX_C0402" list(7053.000000 4385.000000) t) | 15@@list("C6611" "TX_C0402" list(7680.000000 4355.000000) t) | 15@@list("C6612" "TX_C0402" list(7057.000000 3925.000000) t) | 15@@list("C6613" "TX_C0402" list(7680.000000 3866.000000) t) | 15@@list("C6614" "TX_C0402_T02_H28" list(7678.000000 3609.000000) t) | 15@@list("C6630" "TX_C0402" list(7678.000000 3570.000000) t) | 15@@list("C6631" "TX_C0402" list(7680.000000 3134.000000) t) | 15@@list("C6634" "TX_C0402" list(7062.000000 3172.000000) t) | 15@@list("C6635" "TX_C0402" list(7052.000000 3650.000000) t) | 15@@list("C6801" "TX_C0402" list(7048.000000 4128.000000) t) | 15@@list("C6803" "TX_C0402" list(7683.000000 3367.000000) t) | 15@@list("C6900" "TX_C0402" list(5625.500000 3747.000000) t) | 15@@list("C6901" "TX_C0402" list(5589.000000 3663.000000) t) | 15@@list("C7001" "TX_C0402" list(7321.000000 4634.000000) t) | 15@@list("C7005" "TX_C0402" list(7304.000000 4520.000000) t) | 15@@list("C7006" "TX_C0402" list(7343.000000 4520.000000) t) | 15@@list("C7007" "TX_C0402" list(7078.000000 4597.000000) t) | 15@@list("C7008" "TX_C0402" list(7078.000000 4560.000000) t) | 15@@list("CON2100" "A_DDR4_260P_20_4HOLD_FOX" list(1892.610000 2614.130000) t) | 15@@list("CON3100" "TX_NGFF_67P_20_4HOLD_ARG" list(8498.910000 710.590000) t) | 15@@list("CON3101" "TX_FPC_12P_20_2H_RA_ACES_B" list(4294.180000 694.840000) t) | 15@@list("CON3601" "TX_WTOB_10P_79_2HOLD_ACES" list(5144.580000 667.260000) t) | 15@@list("CON3602" "TX_WTOB_2P_49_2H_ACES_H138" list(2144.580000 931.060000) t) | 15@@list("CON3800" "WTOB_6P_39_2H_RA_CVI" list(97.340000 905.470000) t) | 15@@list("CON5104" "TX_WTOB_20P_20_4HOLD" list(7468.990000 936.180000) t) | 15@@list("CON7600" "TX_WTOB_7P_49_2HD_RA_ACES" list(1278.440000 4399.570000) t) | 15@@list("D1800" "TX_SOD323_H39" list(2247.000000 647.000000) t) | 15@@list("D3000" "TX_SOT23_2D4_H43" list(3034.000000 4191.000000) t) | 15@@list("D3001" "TX_ESD_2P_33_39X24_H24" list(2000.000000 4134.000000) t) | 15@@list("D3002" "TX_ESD_2P_33_39X24_H24" list(2069.000000 4134.000000) t) | 15@@list("D3600" "TX_SOD523_1D7_H28" list(7845.000000 2905.000000) t) | 15@@list("D3601" "TX_ESD_2P_33_39X24_COLAY" list(5084.000000 973.000000) t) | 15@@list("D3602" "TX_ESD_2P_33_39X24_COLAY" list(5173.780000 973.000000) t) | 15@@list("D3603" "TX_ESD_2P_33_39X24_COLAY" list(5304.000000 983.000000) t) | 15@@list("D3700" "TX_SOD323_H39" list(4968.000000 3950.000000) t) | 15@@list("D3800" "TX_ESD_2P_33_39X24_H24" list(-41.000000 1719.000000) t) | 15@@list("D3801" "TX_ESD_2P_33_39X24_H24" list(-51.000000 2380.000000) t) | 15@@list("D3802" "TX_ESD_2P_33_39X24_H24" list(376.820000 2310.630000) t) | 15@@list("D3803" "TX_ESD_2P_33_39X24_H24" list(218.000000 2423.000000) t) | 15@@list("D3804" "TX_ESD_2P_33_39X24_COLAY" list(541.000000 1691.000000) t) | 15@@list("D3805" "TX_SOT23_2D4_H43" list(1734.000000 772.000000) t) | 15@@list("D3806" "TX_ESD_2P_33_39X24_H24" list(407.220000 1807.000000) t) | 15@@list("D3807" "TX_SOT323" list(616.030000 1788.290000) t) | 15@@list("D5700" "TX_ESD_2P_33_39X24_H24" list(271.000000 3494.000000) t) | 15@@list("D5701" "TX_ESD_2P_33_39X24_H24" list(271.000000 3563.000000) t) | 15@@list("D5705" "TX_ESD_2P_33_39X24_H24" list(303.000000 3435.000000) t) | 15@@list("D5706" "TX_ESD_2P_33_39X24_H24" list(303.000000 3381.000000) t) | 15@@list("D5708" "TX_DFN1006_2P_43X28_WIL" list(274.200000 3830.500000) t) | 15@@list("D5709" "TX_DFN1006_2P_43X28_WIL" list(274.200000 3766.500000) t) | 15@@list("D5800" "TX_SOT23_2D4_H43" list(575.000000 3216.000000) t) | 15@@list("F5100" "TX_POLYSWITCH_0603_71X39" list(6699.000000 1032.000000) t) | 15@@list("J3800" "TX_AUDIO_JACK_6P_TECHK" list(-172.350000 2120.040000) t) | 15@@list("L2600" "TX_CHOKE_4P_49X39_MURA" list(451.000000 2799.000000) t) | 15@@list("L2601" "TX_CHOKE_4P_49X39_MURA" list(450.000000 2716.000000) t) | 15@@list("L2602" "TX_CHOKE_4P_49X39_MURA" list(450.000000 2625.000000) t) | 15@@list("L2603" "TX_CHOKE_4P_49X39_MURA" list(450.000000 2889.000000) t) | 15@@list("L3000" "CHOKE_4P_49X39_MURA" list(1889.000000 4133.000000) t) | 15@@list("L3601" "TX_L0603_T015" list(4872.100000 996.000000) t) | 15@@list("L3602" "TX_L0603_T015" list(4936.100000 997.000000) t) | 15@@list("L3603" "TX_L0603_T015" list(5004.100000 997.000000) t) | 15@@list("L3801" "TX_L0603_T02_H37" list(345.310000 2141.200000) t) | 15@@list("L3802" "TX_L0603_T02_H37" list(57.800000 2367.810000) t) | 15@@list("L3803" "TX_L0603_T02_H37" list(321.800000 2368.310000) t) | 15@@list("L3804" "TX_L0603_T02_H37" list(22.440000 1861.000000) t) | 15@@list("L3806" "TX_L0603_T015" list(402.470000 1724.240000) t) | 15@@list("L5700" "TX_CHOKE_4P_49X39_MURA" list(365.000000 3523.000000) t) | 15@@list("PC7601" "TX_C0603" list(1501.000000 4196.000000) t) | 15@@list("PC7605" "TX_C0805_T02_H57" list(994.000000 4102.000000) t) | 15@@list("PC7608" "TX_C0402" list(582.000000 2525.000000) t) | 15@@list("PC7700" "TX_C0805_T02_H57" list(7180.000000 1194.900000) t) | 15@@list("PC7701" "TX_C0805_T02_H57" list(7180.000000 1335.300000) t) | 15@@list("PC7702" "TX_C0805_T02_H57" list(7180.000000 1265.100000) t) | 15@@list("PC7703" "TX_C0805_T02_H57" list(7180.000000 1124.200000) t) | 15@@list("PC7704" "TX_C0805_T02_H57" list(6123.000000 1362.000000) t) | 15@@list("PC7705" "TX_C0805_T02_H57" list(6195.000000 1545.000000) t) | 15@@list("PC7706" "TX_C0805_T02_H57" list(6051.000000 1367.000000) t) | 15@@list("PC7707" "TX_C0805_T02_H57" list(5956.000000 1307.000000) t) | 15@@list("PC7708" "TX_C0402_T02_H26" list(7359.000000 1313.000000) t) | 15@@list("PC7709" "TX_C0603_T015_H37" list(7289.000000 1341.300000) t) | 15@@list("PC7710" "TX_C0603_T015_H37" list(7284.800000 1252.000000) t) | 15@@list("PC7711" "TX_C0603" list(7364.000000 1236.000000) t) | 15@@list("PC7712" "TX_C0603_T015_H37" list(7376.000000 1409.000000) t) | 15@@list("PC7713" "TX_C0402_T02_H26" list(7441.000000 1415.000000) t) | 15@@list("PC7714" "TX_C0402_T02_H26" list(7372.500000 1127.000000) t) | 15@@list("PC7715" "TX_C0603" list(7450.500000 1130.140000) t) | 15@@list("PC7716" "TX_C0402" list(7479.800000 1415.000000) t) | 15@@list("PC7717" "TX_C0603_T015_H37" list(7695.000000 1097.000000) t) | 15@@list("PC7718" "TX_C0402" list(7612.500000 1134.000000) t) | 15@@list("PC7719" "TX_C0603" list(7695.000000 1148.000000) t) | 15@@list("PC7720" "TX_C0805_T02_H57" list(5852.000000 1205.000000) t) | 15@@list("PC7721" "TX_C0402" list(7691.000000 1410.000000) t) | 15@@list("PC7722" "TX_C0402" list(5701.720000 1172.000000) t) | 15@@list("PC7723" "TX_C0402" list(7756.000000 1292.000000) t) | 15@@list("PC7800" "TX_C0402" list(6739.500000 2373.000000) t) | 15@@list("PC7801" "TX_C0402" list(6495.000000 2166.000000) t) | 15@@list("PC7802" "TX_C0603" list(6405.000000 2168.290000) t) | 15@@list("PC7803" "TX_C0402" list(6739.000000 2409.500000) t) | 15@@list("PC7804" "TX_C0603" list(6495.000000 2109.000000) t) | 15@@list("PC7805" "TX_C0402" list(6746.500000 2332.000000) t) | 15@@list("PC7806" "TX_C0402" list(6820.000000 2406.000000) t) | 15@@list("PC7812" "TX_C0402" list(6610.000000 2353.000000) t) | 15@@list("PC7814" "TX_C0402" list(6850.000000 2198.000000) t) | 15@@list("PC7815" "TX_C0402" list(6618.500000 2503.000000) t) | 15@@list("PC7816" "TX_C0402" list(6919.000000 2234.000000) t) | 15@@list("PC7817" "TX_C0402" list(6724.000000 2585.000000) t) | 15@@list("PC7818" "TX_C0402" list(6827.000000 2118.000000) t) | 15@@list("PC7820" "TX_C0402" list(6669.000000 2442.000000) t) | 15@@list("PC7822" "TX_C0402" list(6932.000000 2178.500000) t) | 15@@list("PC7823" "TX_C0402" list(6689.000000 2353.500000) t) | 15@@list("PC7831" "TX_C0402" list(6716.000000 2010.000000) t) | 15@@list("PC7833" "TX_C0402" list(6516.000000 1999.000000) t) | 15@@list("PC7834" "TX_C0402" list(6679.900000 2010.000000) t) | 15@@list("PC7835" "TX_C0402" list(6770.000000 2010.000000) t) | 15@@list("PC7837" "TX_C0402" list(6590.000000 1985.000000) t) | 15@@list("PC7838" "TX_C0402" list(6625.000000 1935.000000) t) | 15@@list("PC7839" "TX_C0402" list(6829.000000 2480.000000) t) | 15@@list("PC7840" "TX_C0402" list(6792.160000 2479.880000) t) | 15@@list("PC7841" "TX_C0402" list(6673.000000 2524.500000) t) | 15@@list("PC7900" "TX_C0402_T02_H26" list(6050.000000 1904.000000) t) | 15@@list("PC7901" "TX_C0805_T02_H57" list(5825.060000 1994.000000) t) | 15@@list("PC7902" "TX_C0805_T02_H57" list(5825.060000 1924.000000) t) | 15@@list("PC7903" "TX_C0402" list(5944.000000 2195.000000) t) | 15@@list("PC7904" "TX_C0603" list(6001.060000 2033.000000) t) | 15@@list("PC7905" "TX_C0402" list(5675.060000 2002.000000) t) | 15@@list("PC7906" "TX_C0805_T02_H57" list(5943.000000 2342.000000) t) | 15@@list("PC7907" "TX_C0805_T02_H57" list(5786.000000 2552.000000) t) | 15@@list("PC7908" "TX_C0805_T02_H57" list(5786.000000 2481.000000) t) | 15@@list("PC7909" "TX_C0402_T02_H26" list(6138.060000 2307.000000) t) | 15@@list("PC7910" "TX_C0402" list(5949.060000 2737.000000) t) | 15@@list("PC7911" "TX_C0603" list(6003.000000 2409.000000) t) | 15@@list("PC7912" "TX_C0402" list(5693.000000 2566.000000) t) | 15@@list("PC7913" "TX_C0805_T02_H57" list(5949.000000 1953.000000) t) | 15@@list("PC8000" "TX_C0603" list(5606.000000 1504.000000) t) | 15@@list("PC8001" "TX_C0805_T02_H57" list(5945.060000 1661.000000) t) | 15@@list("PC8002" "TX_C0402_T02_H26" list(5418.000000 1385.000000) t) | 15@@list("PC8003" "TX_C0805_T02_H57" list(5945.000000 1732.000000) t) | 15@@list("PC8005" "TX_C0402" list(5777.000000 1617.000000) t) | 15@@list("PC8006" "TX_C0402_T02_H26" list(6160.000000 2708.000000) t) | 15@@list("PC8007" "TX_C0805_T02_H57" list(5948.060000 2871.000000) t) | 15@@list("PC8008" "TX_C0805_T02_H57" list(5805.060000 2926.000000) t) | 15@@list("PC8009" "TX_C0805_T02_H57" list(5805.060000 2856.000000) t) | 15@@list("PC8010" "TX_C0402" list(5927.060000 3142.000000) t) | 15@@list("PC8011" "TX_C0603" list(6029.560000 2817.000000) t) | 15@@list("PC8105" "TX_C0603_T02_H39" list(5247.000000 2449.000000) t) | 15@@list("PC8106" "TX_C0603_T02_H39" list(5247.000000 1982.000000) t) | 15@@list("PC8123" "TX_C0603_T02_H39" list(5253.000000 2826.000000) t) | 15@@list("PC8140" "TX_C0603_T02_H39" list(4339.000000 3549.000000) t) | 15@@list("PC8147" "TX_C0603_T02_H39" list(4812.000000 3412.000000) t) | 15@@list("PC8148" "TX_C0603_T02_H39" list(4564.000000 3358.000000) t) | 15@@list("PC8149" "TX_C0603_T02_H39" list(4674.000000 3305.000000) t) | 15@@list("PC8151" "TX_C0603_T02_H39" list(4866.000000 3412.000000) t) | 15@@list("PC8152" "TX_C0603_T02_H39" list(4577.000000 3595.000000) t) | 15@@list("PC8156" "TX_C0603_T02_H39" list(4673.000000 3414.000000) t) | 15@@list("PC8162" "TX_C0603_T02_H39" list(5316.060000 1623.000000) t) | 15@@list("PC8164" "TX_C0603_T02_H39" list(4338.060000 3604.000000) t) | 15@@list("PC8166" "TX_C0603_T02_H39" list(4564.000000 3412.000000) t) | 15@@list("PC8167" "TX_C0603_T02_H39" list(4756.000000 3412.000000) t) | 15@@list("PC8176" "TX_C0603_T02_H39" list(4564.000000 3305.000000) t) | 15@@list("PC8177" "TX_C0603_T02_H39" list(4674.000000 3360.000000) t) | 15@@list("PC8184" "TX_C0603_T02_H39" list(4339.000000 3494.000000) t) | 15@@list("PC8187" "TX_C0603_T02_H39" list(4479.000000 3595.000000) t) | 15@@list("PC8602" "TX_C0805_T02_H57" list(3034.000000 4359.000000) t) | 15@@list("PC8603" "TX_C0805_T02_H57" list(3034.000000 4289.000000) t) | 15@@list("PC8606" "TX_C0402" list(3084.000000 4628.000000) t) | 15@@list("PC8607" "TX_C0402" list(3084.000000 4591.000000) t) | 15@@list("PC8608" "TX_C0402_T02_H28" list(3458.000000 4531.000000) t) | 15@@list("PC8617" "TX_C0603_T02_H39" list(3659.000000 4092.000000) t) | 15@@list("PC8618" "TX_C0603_T02_H39" list(3683.000000 4309.500000) t) | 15@@list("PC8619" "TX_C0603_T02_H39" list(3658.500000 4201.000000) t) | 15@@list("PC8620" "TX_C0603_T02_H39" list(3683.000000 4255.500000) t) | 15@@list("PC8622" "TX_C0402" list(2944.000000 4344.000000) t) | 15@@list("PC8700" "TX_C0805_T02_H57" list(6806.000000 1643.000000) t) | 15@@list("PC8701" "TX_C0603_T02_H39" list(6650.000000 1492.000000) t) | 15@@list("PC8702" "TX_C0603_T02_H39" list(6240.000000 2060.000000) t) | 15@@list("PC8703" "TX_C0603_T02_H39" list(6240.000000 2113.000000) t) | 15@@list("PC8704" "TX_C0402" list(6645.000000 1414.000000) t) | 15@@list("PC8705" "TX_C0402" list(6732.000000 1558.000000) t) | 15@@list("PC8706" "TX_C0402" list(6575.000000 1776.500000) t) | 15@@list("PC8707" "TX_C0603_T02_H39" list(6169.000000 2241.000000) t) | 15@@list("PC8708" "TX_C0603_T02_H39" list(6331.000000 2073.000000) t) | 15@@list("PC8709" "TX_C0603" list(6503.000000 1861.000000) t) | 15@@list("PC8710" "TX_C0603_T02_H39" list(6669.000000 1563.500000) t) | 15@@list("PC8711" "TX_C0603_T02_H39" list(6335.000000 2177.000000) t) | 15@@list("PC8712" "TX_C0603_T02_H39" list(6240.000000 2166.000000) t) | 15@@list("PC8713" "TX_C0402" list(6724.000000 1789.500000) t) | 15@@list("PC8714" "TX_C0805_T02_H57" list(6877.000000 1643.000000) t) | 15@@list("PC8715" "TX_C0402" list(6931.000000 1657.000000) t) | 15@@list("PC8800" "TX_C0805_T02_H57" list(1523.000000 1007.000000) t) | 15@@list("PC8804" "TX_C0603_T02_H39" list(1807.000000 1066.000000) t) | 15@@list("PC8805" "TX_C0603_T02_H39" list(1754.000000 1066.000000) t) | 15@@list("PC8806" "TX_C0603_T02_H39" list(1688.000000 901.000000) t) | 15@@list("PC8807" "TX_C0603_T02_H39" list(3699.500000 4624.000000) t) | 15@@list("PC8808" "TX_C0402" list(4003.000000 4754.000000) t) | 15@@list("PC8809" "TX_C0603_T02_H39" list(3673.000000 4728.000000) t) | 15@@list("PC8812" "TX_C0402" list(4168.000000 4695.000000) t) | 15@@list("PC8813" "TX_C0805_T02_H57" list(4204.000000 4627.000000) t) | 15@@list("PC8900" "TX_C0402" list(7510.000000 2548.000000) t) | 15@@list("PC8901" "TX_C0402" list(7627.000000 2720.000000) t) | 15@@list("PC8902" "TX_C0402" list(7682.000000 2720.000000) t) | 15@@list("PC8903" "TX_C0402" list(7674.000000 2451.500000) t) | 15@@list("PC8904" "TX_C0402" list(7856.630000 2613.140000) t) | 15@@list("PC8905" "TX_C0805_T02_H57" list(6837.480000 1898.000000) t) | 15@@list("PC8906" "TX_C0805_T02_H57" list(6767.380000 1898.500000) t) | 15@@list("PC8907" "TX_C0402" list(7136.000000 1872.000000) t) | 15@@list("PC8908" "TX_C0402" list(7104.000000 2113.000000) t) | 15@@list("PC8909" "TX_C0402_T02_H28" list(7740.000000 1760.000000) t) | 15@@list("PC8910" "TX_C0402" list(7018.600000 2012.400000) t) | 15@@list("PC8911" "TX_C0402" list(7742.870000 2739.530000) t) | 15@@list("PC8912" "TX_C0402" list(7710.500000 2451.500000) t) | 15@@list("PC8913" "TX_C0402" list(7852.000000 2446.500000) t) | 15@@list("PC8914" "TX_C0805_T02_H57" list(7296.000000 2246.000000) t) | 15@@list("PC8915" "TX_C0805_T02_H57" list(7221.000000 2246.000000) t) | 15@@list("PC8916" "TX_C0402" list(7423.000000 2330.000000) t) | 15@@list("PC8917" "TX_C0402" list(7801.000000 2522.000000) t) | 15@@list("PC8918" "TX_C0402" list(7330.000000 2650.000000) t) | 15@@list("PC8919" "TX_C0402_T02_H28" list(6801.000000 2570.000000) t) | 15@@list("PC8920" "TX_C0402" list(7414.000000 2451.000000) t) | 15@@list("PC8922" "TX_C0402" list(7637.500000 2452.000000) t) | 15@@list("PC8923" "TX_C0402" list(7545.000000 2443.000000) t) | 15@@list("PC8924" "TX_C0805_T02_H57" list(6697.380000 1898.500000) t) | 15@@list("PC8925" "TX_C0805_T02_H57" list(6907.480000 1898.000000) t) | 15@@list("PC9100" "TX_C0402" list(6962.000000 779.000000) t) | 15@@list("PC9101" "TX_C0402" list(6876.500000 711.000000) t) | 15@@list("PC9102" "TX_C0402" list(6864.000000 923.000000) t) | 15@@list("PC9103" "TX_C0402" list(6962.000000 842.000000) t) | 15@@list("PC9104" "TX_C0402" list(6763.000000 757.300000) t) | 15@@list("PC9105" "TX_C0402" list(6827.000000 923.000000) t) | 15@@list("PC9107" "TX_C0402" list(7615.000000 2382.000000) t) | 15@@list("PC9108" "TX_C0402" list(7761.000000 2338.000000) t) | 15@@list("PC9109" "TX_C0402" list(7680.000000 2382.000000) t) | 15@@list("PC9110" "TX_C0402" list(7520.000000 2218.000000) t) | 15@@list("PC9111" "TX_C0402" list(7520.000000 2326.000000) t) | 15@@list("PC9112" "TX_C0402" list(7761.000000 2301.000000) t) | 15@@list("PC9113" "TX_C0402" list(7761.000000 2264.000000) t) | 15@@list("PC9114" "TX_C0402" list(6760.000000 840.000000) t) | 15@@list("PC9200" "TX_C0402" list(5337.000000 1125.000000) t) | 15@@list("PC9201" "TX_C0402" list(5131.000000 1211.800000) t) | 15@@list("PC9202" "TX_C0402" list(5213.000000 1092.000000) t) | 15@@list("PC9203" "TX_C0402" list(5230.000000 1288.000000) t) | 15@@list("PC9204" "TX_C0402" list(5131.000000 1175.300000) t) | 15@@list("PC9206" "TX_C0402" list(5294.000000 1288.000000) t) | 15@@list("PC9402" "TX_C0402" list(3890.000000 4008.000000) t) | 15@@list("PC9403" "TX_C0402" list(4276.500000 4429.000000) t) | 15@@list("PC9404" "TX_C0402" list(4174.000000 4430.000000) t) | 15@@list("PC9405" "TX_C0402" list(4030.000000 4255.000000) t) | 15@@list("PC9406" "TX_C0402" list(4421.000000 4290.000000) t) | 15@@list("PC9407" "TX_C0402" list(4397.000000 4240.000000) t) | 15@@list("PC9409" "TX_C0402" list(4430.000000 4157.000000) t) | 15@@list("PC9410" "TX_C0402" list(4051.000000 3980.500000) t) | 15@@list("PC9411" "TX_C0402" list(4083.000000 3897.000000) t) | 15@@list("PC9412" "TX_C0402" list(4175.000000 4057.000000) t) | 15@@list("PC9413" "TX_C0402" list(4307.000000 4358.000000) t) | 15@@list("PC9414" "TX_C0402" list(3972.000000 3897.000000) t) | 15@@list("PC9415" "TX_C0402" list(4238.380000 4036.870000) t) | 15@@list("PC9416" "TX_C0402" list(4260.500000 3987.000000) t) | 15@@list("PC9417" "TX_C0402" list(4342.000000 3897.000000) t) | 15@@list("PC9418" "TX_C0402" list(4231.000000 3897.000000) t) | 15@@list("PC9419" "TX_C0402" list(4416.000000 3897.000000) t) | 15@@list("PC9420" "TX_C0402" list(3889.000000 4301.000000) t) | 15@@list("PC9421" "TX_C0402" list(5522.000000 3485.000000) t) | 15@@list("PC9422" "TX_C0402" list(5586.000000 3448.000000) t) | 15@@list("PC9423" "TX_C0402" list(5522.500000 3337.500000) t) | 15@@list("PC9424" "TX_C0402" list(4088.000000 3978.500000) t) | 15@@list("PC9425" "TX_C0402" list(4175.000000 4020.000000) t) | 15@@list("PC9500" "TX_C0603_T02_H39" list(6240.000000 2698.000000) t) | 15@@list("PC9501" "TX_C0603_T02_H39" list(6240.000000 2750.000000) t) | 15@@list("PC9502" "TX_C0402" list(6228.000000 2795.000000) t) | 15@@list("PC9503" "TX_C0603_T02_H39" list(6142.000000 3093.000000) t) | 15@@list("PC9504" "TX_C0603_T02_H39" list(6215.000000 3063.000000) t) | 15@@list("PC9505" "TX_C0402" list(6082.000000 3067.000000) t) | 15@@list("PC9506" "TX_C0603" list(6334.000000 2863.000000) t) | 15@@list("PC9508" "TX_C0402" list(6391.000000 2821.000000) t) | 15@@list("PC9509" "TX_C0603_T02_H39" list(6643.500000 4656.000000) t) | 15@@list("PC9510" "TX_C0603_T02_H39" list(6696.000000 4656.000000) t) | 15@@list("PC9511" "TX_C0402" list(6598.000000 4662.000000) t) | 15@@list("PC9512" "TX_C0603_T02_H39" list(6393.000000 4617.000000) t) | 15@@list("PC9513" "TX_C0603_T02_H39" list(6362.000000 4462.000000) t) | 15@@list("PC9514" "TX_C0402" list(6229.000000 4646.000000) t) | 15@@list("PC9517" "TX_C0402" list(6342.000000 4710.000000) t) | 15@@list("PC9518" "TX_C0603_T02_H39" list(6341.000000 4617.000000) t) | 15@@list("PC9600" "TX_C0805_T02_H57" list(4711.000000 4296.000000) t) | 15@@list("PC9601" "TX_C0805_T02_H57" list(4781.000000 4296.000000) t) | 15@@list("PC9602" "TX_C0402" list(4846.000000 4052.000000) t) | 15@@list("PC9603" "TX_C0402_T02_H28" list(5073.000000 4736.000000) t) | 15@@list("PC9605" "TX_C0402" list(5094.000000 4078.200000) t) | 15@@list("PC9606" "TX_C0603_T02_H39" list(5524.000000 3992.000000) t) | 15@@list("PC9607" "TX_C0603_T02_H39" list(5599.000000 4387.000000) t) | 15@@list("PC9608" "TX_C0603_T02_H39" list(5599.000000 4334.000000) t) | 15@@list("PC9609" "TX_C0603_T02_H39" list(5793.000000 4387.000000) t) | 15@@list("PC9610" "TX_C0603_T02_H39" list(5793.000000 4334.000000) t) | 15@@list("PC9611" "TX_C0603_T02_H39" list(5419.000000 3992.000000) t) | 15@@list("PC9612" "TX_C0603_T02_H39" list(5599.000000 4172.000000) t) | 15@@list("PC9613" "TX_C0603_T02_H39" list(5599.000000 4279.000000) t) | 15@@list("PC9614" "TX_C0603_T02_H39" list(5365.000000 3992.000000) t) | 15@@list("PC9615" "TX_C0805_T02_H57" list(4407.000000 4640.000000) t) | 15@@list("PC9616" "TX_C0805_T02_H57" list(4477.500000 4640.000000) t) | 15@@list("PC9617" "TX_C0603_T02_H39" list(5599.000000 4066.000000) t) | 15@@list("PC9618" "TX_C0603_T02_H39" list(5689.000000 4387.000000) t) | 15@@list("PC9619" "TX_C0603_T02_H39" list(5577.000000 3992.000000) t) | 15@@list("PC9620" "TX_C0603_T02_H39" list(5689.000000 4334.000000) t) | 15@@list("PC9621" "TX_C0603_T02_H39" list(5598.500000 4119.000000) t) | 15@@list("PC9622" "TX_C0603_T02_H39" list(5599.000000 4226.000000) t) | 15@@list("PC9623" "TX_C0603_T02_H39" list(5471.000000 3992.000000) t) | 15@@list("PC9624" "TX_C0402" list(4453.000000 4480.000000) t) | 15@@list("PC9626" "TX_C0402_T02_H28" list(5114.000000 4736.000000) t) | 15@@list("PC9627" "TX_C0402" list(4725.000000 4385.000000) t) | 15@@list("PC9800" "TX_C0402" list(7597.000000 2810.000000) t) | 15@@list("PC9801" "TX_C0805_T02_H57" list(7540.000000 2895.000000) t) | 15@@list("PC9802" "TX_C0805_T02_H57" list(7470.000000 2895.000000) t) | 15@@list("PC9803" "TX_C0402" list(7605.000000 2975.000000) t) | 15@@list("PC9805" "TX_C0603_T02_H39" list(6755.000000 2874.000000) t) | 15@@list("PC9806" "TX_C0603_T02_H39" list(6820.000000 2874.000000) t) | 15@@list("PC9807" "TX_C0603_T02_H39" list(6885.000000 2874.000000) t) | 15@@list("PCE7900" "TX_C3528_T02_H79" list(5900.000000 1510.000000) t) | 15@@list("PCE8000" "TX_C3528_T02_H79" list(6027.990000 2591.840000) t) | 15@@list("PCE8100" "TX_C7343D_T02_H83" list(5466.000000 2363.000000) t) | 15@@list("PCE8900" "TX_C3528_T02_H79" list(7028.000000 1575.000000) t) | 15@@list("PCE8901" "TX_C7343D_T02_H83" list(7335.000000 2087.000000) t) | 15@@list("PCE8902" "TX_C7343D_T02_H83" list(7101.400000 2647.600000) t) | 15@@list("PCE9600" "TX_C7343D_T02_H83" list(5616.000000 4597.000000) t) | 15@@list("PCE9601" "TX_C7343D_T02_H83" list(5809.000000 4597.000000) t) | 15@@list("PCE9602" "TX_C7343D_T02_H83" list(5344.000000 4676.000000) t) | 15@@list("PD7600" "TX_SMA_181X110" list(1683.000000 4474.500000) t) | 15@@list("PD7601" "TX_SOT323_T01X02" list(488.250000 2288.750000) t) | 15@@list("PJP8602" "TX_R0402_SHORT" list(3638.000000 3870.000000) t) | 15@@list("PL7700" "TX_INDUCTOR_2P_S260_CYN_T02" list(6622.000000 1231.000000) t) | 15@@list("PL7900" "TX_INDUCTOR_2P_278X260_H118" list(5466.060000 2133.000000) t) | 15@@list("PL7901" "TX_INDUCTOR_2P_278X260_H118" list(5441.000000 2700.000000) t) | 15@@list("PL8000" "TX_INDUCTOR_2P_274X260_CYN" list(5529.060000 1720.000000) t) | 15@@list("PL8001" "TX_INDUCTOR_2P_278X260_H118" list(5458.060000 3020.000000) t) | 15@@list("PL8600" "TX_INDUCTOR_2P_S268_MI_COLA" list(3282.000000 4422.250000) t) | 15@@list("PL8700" "TX_INDUCTOR_2P_S268_MI_COLA" list(6297.900000 1890.400000) t) | 15@@list("PL8800" "TX_INDUCTOR_2P_98X79_TA_H47" list(1625.000000 1003.000000) t) | 15@@list("PL8801" "TX_INDUCTOR_2P_98X79_TA_H47" list(3852.000000 4670.000000) t) | 15@@list("PL8901" "TX_INDUCTO_2P_287X268_COLAY" list(7034.000000 2414.000000) t) | 15@@list("PL9500" "TX_INDUCTOR_2P_98X79_TA_H47" list(6205.000000 2990.000000) t) | 15@@list("PL9501" "TX_INDUCTOR_2P_106X87" list(6454.000000 4521.000000) t) | 15@@list("PL9600" "TX_INDUCTOR_2P_278X260_H118" list(5274.000000 4314.000000) t) | 15@@list("PL9601" "TX_INDUCTOR_2P_278X260_H118" list(4965.000000 4553.000000) t) | 15@@list("PL9800" "TX_INDUCTOR_2P_S268_MI_COLA" list(7100.000000 2883.750000) t) | 15@@list("PQ7601" "TX_SC70_S6_H47" list(598.000000 2433.000000) t) | 15@@list("PQ7602" "TX_SOT23_2D4_H43" list(476.000000 2435.000000) t) | 15@@list("PQ7700" "TX_SI7850DP" list(6920.000000 1193.940000) t) | 15@@list("PQ7701" "TX_SI7501DN_H44" list(5588.080000 1272.020000) t) | 15@@list("PQ7702" "TX_SI7501DN_H44" list(6895.000000 1386.000000) t) | 15@@list("PQ7703" "TX_SI7501DN_H44" list(6230.500000 1339.000000) t) | 15@@list("PQ7704" "TX_SI7501DN_H44" list(6368.000000 1296.000000) t) | 15@@list("PQ8000" "TX_POWERPAIR_8P_2PAD_VISHAY" list(5804.060000 1735.000000) t) | 15@@list("PQ8600" "TX_POWERPAIR_8P_2PAD_VISHAY" list(3030.000000 4485.000000) t) | 15@@list("PQ8900" "TX_POWERPAIR_8P_2PAD_VISHAY" list(7009.500000 1914.000000) t) | 15@@list("PQ8901" "TX_POWERPAIR_8P_2PAD_VISHAY" list(7325.000000 2389.500000) t) | 15@@list("PR7600" "TX_R0603_H24" list(1671.000000 4294.000000) t) | 15@@list("PR7602" "TX_R0603_H24" list(1601.000000 4283.000000) t) | 15@@list("PR7603" "TX_R0603_H24" list(1597.000000 4599.000000) t) | 15@@list("PR7604" "TX_R0603_H24" list(1589.000000 4524.000000) t) | 15@@list("PR7607" "TX_R0402" list(600.000000 2305.000000) t) | 15@@list("PR7608" "TX_R0402" list(427.000000 2545.000000) t) | 15@@list("PR7609" "TX_R0402" list(600.000000 2342.000000) t) | 15@@list("PR7610" "TX_R0402" list(491.000000 2545.000000) t) | 15@@list("PR7619" "TX_R0402" list(600.000000 2268.000000) t) | 15@@list("PR7700" "TX_R1508_H35" list(7119.000000 1442.000000) t) | 15@@list("PR7701" "TX_R0603_0OHM_H24" list(7549.000000 1102.000000) t) | 15@@list("PR7702" "TX_R0402" list(7690.000000 1519.500000) t) | 15@@list("PR7703" "TX_R0402" list(7240.000000 1452.000000) t) | 15@@list("PR7704" "TX_R0402" list(7241.000000 1402.000000) t) | 15@@list("PR7707" "TX_R0402" list(7456.000000 1483.000000) t) | 15@@list("PR7708" "TX_R0603_H24" list(7367.000000 1489.000000) t) | 15@@list("PR7709" "TX_R0402" list(7690.000000 1483.000000) t) | 15@@list("PR7710" "TX_R0402" list(7520.000000 1483.000000) t) | 15@@list("PR7712" "TX_R1508_H35" list(5832.000000 1307.000000) t) | 15@@list("PR7713" "TX_R0402" list(5816.000000 1405.000000) t) | 15@@list("PR7714" "TX_R0402" list(5723.000000 1348.000000) t) | 15@@list("PR7715" "TX_R0402" list(7677.000000 1226.700000) t) | 15@@list("PR7716" "TX_R0402" list(7691.000000 1373.500000) t) | 15@@list("PR7717" "R0402" list(7691.000000 1335.500000) t) | 15@@list("PR7718" "TX_R0603_0OHM_H24" list(6995.000000 1350.000000) t) | 15@@list("PR7719" "TX_R0402_0OHM" list(7669.000000 1190.500000) t) | 15@@list("PR7720" "TX_R0402_0OHM" list(7521.800000 1414.000000) t) | 15@@list("PR7721" "TX_R0402_0OHM" list(7630.100000 1428.000000) t) | 15@@list("PR7722" "TX_R0402_0OHM" list(7557.900000 1414.000000) t) | 15@@list("PR7723" "TX_R0402_0OHM" list(7594.000000 1414.000000) t) | 15@@list("PR7724" "TX_R0402_0OHM" list(7692.000000 1298.900000) t) | 15@@list("PR7725" "TX_R0402_0OHM" list(7677.000000 1262.800000) t) | 15@@list("PR7726" "TX_R0402" list(7691.000000 1446.000000) t) | 15@@list("PR7800" "TX_R0402" list(6755.000000 2498.000000) t) | 15@@list("PR7803" "TX_R0402" list(6739.000000 2446.500000) t) | 15@@list("PR7804" "TX_R0402" list(6820.000000 2332.440000) t) | 15@@list("PR7806" "TX_R0402" list(6820.000000 2368.940000) t) | 15@@list("PR7812" "TX_R0402" list(6618.500000 2466.000000) t) | 15@@list("PR7813" "TX_R0402" list(6850.000000 2234.000000) t) | 15@@list("PR7814" "TX_R0402" list(6724.000000 2548.000000) t) | 15@@list("PR7815" "TX_R0402" list(6647.000000 2363.000000) t) | 15@@list("PR7816" "TX_R0402" list(6888.000000 2125.000000) t) | 15@@list("PR7817" "TX_R0402_0OHM" list(6969.000000 2142.000000) t) | 15@@list("PR7820" "TX_R0402" list(6670.000000 2591.000000) t) | 15@@list("PR7821" "TX_R0402" list(6876.800000 2088.000000) t) | 15@@list("PR7822" "TX_R0402" list(6880.060000 2161.500000) t) | 15@@list("PR7829" "TX_R0402_H24" list(5944.000000 2088.000000) t) | 15@@list("PR7830" "TX_R0402_H24" list(6083.060000 2676.000000) t) | 15@@list("PR7834" "TX_R0402" list(6490.500000 2205.000000) t) | 15@@list("PR7836" "TX_R0402_SHORT" list(6502.000000 2242.000000) t) | 15@@list("PR7837" "TX_R0402_0OHM" list(6502.000000 2280.000000) t) | 15@@list("PR7849" "TX_R0402" list(6806.100000 2010.000000) t) | 15@@list("PR7851" "TX_R0402" list(6643.800000 1985.000000) t) | 15@@list("PR7854" "TX_R0402" list(6618.500000 2429.000000) t) | 15@@list("PR7855" "TX_R0402" list(6633.000000 2591.000000) t) | 15@@list("PR7900" "TX_R0805_0OHM_H26" list(6055.000000 2215.000000) t) | 15@@list("PR7902" "TX_R0805_0OHM_H26" list(6039.060000 2127.000000) t) | 15@@list("PR7904" "TX_R0402" list(5483.000000 1960.000000) t) | 15@@list("PR7905" "TX_R0402" list(5447.000000 1960.000000) t) | 15@@list("PR7906" "TX_R0402" list(5519.000000 1960.000000) t) | 15@@list("PR7907" "TX_R0805_0OHM_H26" list(6017.000000 2714.440000) t) | 15@@list("PR7908" "TX_R0805_0OHM_H26" list(6068.060000 2492.000000) t) | 15@@list("PR7910" "TX_R0402" list(5493.000000 2516.000000) t) | 15@@list("PR7911" "TX_R0402" list(5530.000000 2516.000000) t) | 15@@list("PR7912" "TX_R0402" list(5435.000000 2540.000000) t) | 15@@list("PR7913" "TX_R0402" list(5981.060000 2195.000000) t) | 15@@list("PR7915" "TX_R0402" list(5912.060000 2737.000000) t) | 15@@list("PR7917" "TX_R0402_0OHM" list(6050.000000 1942.000000) t) | 15@@list("PR7918" "TX_R0402_0OHM" list(6120.000000 2149.000000) t) | 15@@list("PR7919" "TX_R0402_0OHM" list(6065.000000 2310.000000) t) | 15@@list("PR7920" "TX_R0402_0OHM" list(6144.060000 2500.000000) t) | 15@@list("PR7921" "TX_R0402" list(5410.000000 1960.000000) t) | 15@@list("PR7922" "TX_R0402" list(5384.000000 2526.000000) t) | 15@@list("PR8000" "TX_R0805_0OHM_H26" list(5684.000000 1508.000000) t) | 15@@list("PR8003" "TX_R0805_0OHM_H26" list(5751.000000 1516.000000) t) | 15@@list("PR8004" "TX_R0402" list(5530.000000 1546.000000) t) | 15@@list("PR8005" "TX_R0402" list(5494.000000 1546.000000) t) | 15@@list("PR8006" "TX_R0805_0OHM_H26" list(6016.500000 3108.940000) t) | 15@@list("PR8007" "TX_R0805_0OHM_H26" list(6069.060000 2896.800000) t) | 15@@list("PR8011" "TX_R0402" list(5964.060000 3142.000000) t) | 15@@list("PR8013" "TX_R0402_0OHM" list(5418.000000 1424.000000) t) | 15@@list("PR8014" "TX_R0402_0OHM" list(5652.890000 1419.530000) t) | 15@@list("PR8015" "TX_R0402_0OHM" list(6082.060000 2718.000000) t) | 15@@list("PR8016" "TX_R0402_0OHM" list(6149.060000 2899.500000) t) | 15@@list("PR8701" "TX_R0402_0OHM" list(6645.200000 1883.000000) t) | 15@@list("PR8702" "TX_R0402_SHORT" list(6609.200000 1883.000000) t) | 15@@list("PR8703" "TX_R0603_H24" list(6551.000000 1861.000000) t) | 15@@list("PR8704" "TX_R0805_H26" list(6498.000000 1781.500000) t) | 15@@list("PR8705" "TX_R0402" list(6643.000000 1794.000000) t) | 15@@list("PR8706" "TX_R0402_0OHM" list(6625.000000 1832.000000) t) | 15@@list("PR8707" "TX_R0402" list(6782.000000 1464.000000) t) | 15@@list("PR8708" "TX_R0402" list(6732.000000 1478.000000) t) | 15@@list("PR8709" "TX_R0402" list(6695.000000 1447.000000) t) | 15@@list("PR8710" "TX_R0402" list(6580.120000 1414.000000) t) | 15@@list("PR8711" "TX_R0402" list(6782.000000 1534.000000) t) | 15@@list("PR8712" "TX_R0402_0OHM" list(6747.500000 1825.500000) t) | 15@@list("PR8800" "TX_R0402" list(1710.000000 1057.000000) t) | 15@@list("PR8809" "TX_R0402" list(3718.000000 4737.000000) t) | 15@@list("PR8811" "TX_R0402_SHORT" list(4072.000000 4754.000000) t) | 15@@list("PR8902" "TX_R0805_H26" list(7848.160000 2664.440000) t) | 15@@list("PR8903" "TX_R0805_0OHM_H26" list(7091.000000 1801.000000) t) | 15@@list("PR8904" "TX_R0402" list(7099.000000 1872.000000) t) | 15@@list("PR8905" "TX_R0805_0OHM_H26" list(7020.000000 2127.000000) t) | 15@@list("PR8906" "TX_R0402" list(7018.600000 2048.400000) t) | 15@@list("PR8908" "TX_R0603_H24" list(7796.970000 2747.210000) t) | 15@@list("PR8909" "TX_R0402" list(7801.000000 2485.000000) t) | 15@@list("PR8910" "TX_R0402" list(7747.000000 2449.000000) t) | 15@@list("PR8911" "TX_R0402" list(7797.000000 2433.000000) t) | 15@@list("PR8914" "TX_R0805_H26" list(7520.000000 2600.000000) t) | 15@@list("PR8915" "TX_R0805_0OHM_H26" list(7369.000000 2246.000000) t) | 15@@list("PR8917" "TX_R0402" list(7460.000000 2330.000000) t) | 15@@list("PR8918" "TX_R0805_0OHM_H26" list(7420.000000 2549.000000) t) | 15@@list("PR8919" "TX_R0402" list(7454.000000 2451.000000) t) | 15@@list("PR8921" "TX_R0402" list(7600.000000 2452.000000) t) | 15@@list("PR8922" "TX_R0402" list(7545.000000 2480.000000) t) | 15@@list("PR8923" "TX_R0402" list(7800.000000 2576.000000) t) | 15@@list("PR9100" "TX_R0402_SHORT" list(6962.000000 711.000000) t) | 15@@list("PR9101" "TX_R0402" list(6925.000000 711.000000) t) | 15@@list("PR9103" "TX_R0402_0OHM" list(6800.000000 711.000000) t) | 15@@list("PR9104" "TX_R0402" list(6838.000000 711.000000) t) | 15@@list("PR9105" "TX_R0402_0OHM" list(6761.000000 941.000000) t) | 15@@list("PR9106" "TX_R0402_SHORT" list(7524.500000 2399.500000) t) | 15@@list("PR9107" "TX_R0402" list(7530.000000 2362.500000) t) | 15@@list("PR9109" "TX_R0402_SHORT" list(7519.500000 2254.000000) t) | 15@@list("PR9110" "TX_R0402" list(7520.000000 2290.000000) t) | 15@@list("PR9401" "TX_R0402" list(4042.000000 4497.000000) t) | 15@@list("PR9402" "TX_R0402" list(4022.000000 4371.000000) t) | 15@@list("PR9403" "TX_R0402" list(4025.000000 4434.000000) t) | 15@@list("PR9408" "TX_R0603_H24" list(4225.000000 4505.000000) t) | 15@@list("PR9409" "TX_R0402" list(4143.000000 4499.000000) t) | 15@@list("PR9410" "TX_R0805_H26" list(4483.000000 4211.000000) t) | 15@@list("PR9412" "TX_R0402" list(3958.000000 4323.000000) t) | 15@@list("PR9413" "TX_R0603_H24" list(3955.000000 4260.000000) t) | 15@@list("PR9415" "TX_R0402" list(4412.000000 4016.000000) t) | 15@@list("PR9416" "TX_R0402" list(4063.000000 4063.500000) t) | 15@@list("PR9417" "TX_R0805_H26" list(4377.990000 4079.000000) t) | 15@@list("PR9419" "TX_R0402" list(4124.000000 3978.500000) t) | 15@@list("PR9420" "TX_R0402" list(4009.000000 3897.000000) t) | 15@@list("PR9421" "TX_R0402_0OHM" list(4350.500000 4483.000000) t) | 15@@list("PR9422" "TX_R0402" list(4046.000000 3897.000000) t) | 15@@list("PR9423" "TX_R0402" list(4227.000000 4430.000000) t) | 15@@list("PR9424" "TX_R0402" list(4120.000000 3897.000000) t) | 15@@list("PR9425" "TX_R0402" list(4013.000000 3976.000000) t) | 15@@list("PR9426" "TX_R0402_0OHM" list(4350.500000 4418.000000) t) | 15@@list("PR9427" "TX_R0402" list(4313.500000 4418.000000) t) | 15@@list("PR9428" "TX_R0402" list(3976.000000 3976.000000) t) | 15@@list("PR9429" "TX_R0402" list(4194.000000 3897.000000) t) | 15@@list("PR9430" "TX_R0402" list(4268.000000 3897.000000) t) | 15@@list("PR9431" "TX_R0402" list(4157.000000 3897.000000) t) | 15@@list("PR9432" "TX_R0402_0OHM" list(4297.000000 3961.000000) t) | 15@@list("PR9433" "TX_R0402" list(4224.500000 3987.000000) t) | 15@@list("PR9434" "TX_R0402_0OHM" list(3818.000000 4119.000000) t) | 15@@list("PR9435" "TX_R0402" list(4036.000000 4141.500000) t) | 15@@list("PR9436" "TX_R0402" list(4370.000000 3980.000000) t) | 15@@list("PR9437" "TX_R0402_0OHM" list(3882.000000 4119.000000) t) | 15@@list("PR9438" "TX_R0402" list(3952.000000 4119.000000) t) | 15@@list("PR9439" "TX_R0402_0OHM" list(3818.000000 4082.000000) t) | 15@@list("PR9440" "TX_R0402" list(3882.000000 4082.000000) t) | 15@@list("PR9441" "TX_R0402" list(3952.000000 4082.000000) t) | 15@@list("PR9442" "TX_R0402" list(4012.550000 4078.000000) t) | 15@@list("PR9443" "TX_R0402" list(3818.000000 4045.000000) t) | 15@@list("PR9444" "TX_R0402" list(3882.000000 4045.000000) t) | 15@@list("PR9445" "TX_R0402" list(3909.000000 4164.500000) t) | 15@@list("PR9446" "TX_R0402" list(3959.500000 4183.000000) t) | 15@@list("PR9447" "TX_R0402" list(4039.000000 4178.500000) t) | 15@@list("PR9448" "TX_R0402" list(3889.000000 4264.000000) t) | 15@@list("PR9449" "TX_R0402_0OHM" list(5522.000000 3522.000000) t) | 15@@list("PR9450" "TX_R0402_0OHM" list(4136.000000 4430.000000) t) | 15@@list("PR9451" "TX_R0402_0OHM" list(5521.900000 3411.370000) t) | 15@@list("PR9452" "TX_R0402_0OHM" list(4305.000000 3897.000000) t) | 15@@list("PR9453" "TX_R0402_0OHM" list(4379.000000 3897.000000) t) | 15@@list("PR9454" "TX_R0402" list(4333.000000 3961.000000) t) | 15@@list("PR9455" "TX_R0402_0OHM" list(4188.000000 3966.000000) t) | 15@@list("PR9456" "TX_R0402_SHORT" list(4342.000000 4533.000000) t) | 15@@list("PR9457" "R0402_H14" list(4034.990000 4295.000000) t) | 15@@list("PR9458" "TX_R0402" list(5457.000000 3522.000000) t) | 15@@list("PR9459" "TX_R0402" list(5522.000000 3448.000000) t) | 15@@list("PR9460" "TX_R0402" list(5522.000000 3374.000000) t) | 15@@list("PR9501" "TX_R0805_H26" list(6340.000000 2995.000000) t) | 15@@list("PR9502" "TX_R0402" list(6391.000000 2895.000000) t) | 15@@list("PR9504" "TX_R0402" list(6391.000000 2858.000000) t) | 15@@list("PR9507" "TX_R0402" list(6305.000000 4710.000000) t) | 15@@list("PR9509" "TX_R0402" list(6379.000000 4710.000000) t) | 15@@list("PR9603" "TX_R0805_0OHM_H26" list(4937.500000 4059.000000) t) | 15@@list("PR9604" "TX_R0402" list(4860.000000 4001.000000) t) | 15@@list("PR9605" "TX_R0805_0OHM_H26" list(5029.000000 4038.000000) t) | 15@@list("PR9607" "TX_R0805_0OHM_H26" list(4472.000000 4388.000000) t) | 15@@list("PR9608" "TX_R0402" list(4492.000000 4480.000000) t) | 15@@list("PR9609" "TX_R0805_0OHM_H26" list(4815.000000 4385.000000) t) | 15@@list("PR9802" "TX_R0402" list(7490.000000 2775.000000) t) | 15@@list("PR9803" "TX_R0402" list(7370.000000 2774.000000) t) | 15@@list("PR9804" "TX_R0402" list(7320.000000 2774.000000) t) | 15@@list("PR9806" "TX_R0402" list(7450.000000 2775.000000) t) | 15@@list("PR9807" "TX_R0402" list(7410.000000 2774.000000) t) | 15@@list("PR9808" "TX_R0402" list(7280.000000 2775.000000) t) | 15@@list("PR9810" "TX_R0402" list(7371.000000 3025.000000) t) | 15@@list("PR9811" "TX_R0402" list(7331.000000 3025.000000) t) | 15@@list("PR9812" "TX_R0402" list(7407.500000 3025.000000) t) | 15@@list("PRT7800" "TX_R0402_H22" list(5435.000000 2502.000000) t) | 15@@list("PRT7801" "TX_R0402_H22" list(5453.000000 2861.000000) t) | 15@@list("PRT7802" "TX_R0402_H22" list(5458.000000 1546.000000) t) | 15@@list("PRT9400" "TX_R0402_H24" list(5305.000000 4090.000000) t) | 15@@list("PRT9401" "TX_R0402_H24" list(5238.500000 4090.000000) t) | 15@@list("PT7700" "NB_TPC26T_50" list(7766.000000 1145.000000) t) | 15@@list("PT7702" "NB_TPC26T_50" list(7618.440000 1328.900000) t) | 15@@list("PT8701" "NB_TPC28T_68" list(6313.000000 2224.000000) t) | 15@@list("PT8702" "NB_TPC28T_68" list(6364.000000 2507.000000) t) | 15@@list("PT8703" "NB_TPC28T_68" list(6263.000000 2463.000000) t) | 15@@list("PT9400" "NB_TPC28T_68" list(4081.000000 4370.500000) t) | 15@@list("PT9401" "NB_TPC28T_68" list(4150.000000 4374.000000) t) | 15@@list("PT9402" "NB_TPC28T_68" list(3959.000000 4401.000000) t) | 15@@list("PT9403" "NB_TPC28T_68" list(4101.000000 4080.000000) t) | 15@@list("PT9506" "NB_TPC28T_68" list(6210.000000 2650.000000) t) | 15@@list("PT9507" "NB_TPC28T_68" list(6689.000000 2882.000000) t) | 15@@list("PT9509" "NB_TPC28T_68" list(6591.000000 4535.000000) t) | 15@@list("PT9510" "NB_TPC28T_68" list(6290.000000 4630.000000) t) | 15@@list("PT9511" "NB_TPC28T_68" list(6488.000000 4439.000000) t) | 15@@list("PT9512" "NB_TPC28T_68" list(6420.000000 4439.000000) t) | 15@@list("PT9515" "NB_TPC28T_68" list(6670.000000 4580.000000) t) | 15@@list("PU7900" "TX_DFN_8P_20_87X87_PAD_1V" list(6096.060000 2030.000000) t) | 15@@list("PU7901" "TX_DFN_8P_20_87X87_PAD_1V" list(6094.060000 2395.000000) t) | 15@@list("PU8000" "TX_DFN_8P_20_87X87_PAD_1V" list(5547.060000 1418.000000) t) | 15@@list("PU8001" "TX_DFN_8P_20_87X87_PAD_1V" list(6124.060000 2800.000000) t) | 15@@list("PU8700" "QFN_16P_20_118X118_MPS" list(6684.000000 1684.000000) t) | 15@@list("PU9500" "TX_DFN_8P_20_S83_PAD_1V" list(6250.000000 2880.000000) t) | 15@@list("Q0400" "TX_SOT23_2D4_H44" list(5175.000000 3278.000000) t) | 15@@list("Q1000" "TX_SOT23_2D4_H44" list(4095.000000 1016.000000) t) | 15@@list("Q1900" "TX_SC70_S6_H47" list(533.000000 2076.000000) t) | 15@@list("Q1901" "TX_SC70_S6_H47" list(2867.000000 923.000000) t) | 15@@list("Q1902" "TX_SC70_S6_H47" list(2869.000000 835.000000) t) | 15@@list("Q2403" "TX_SOT23_2D4_H44" list(3772.640000 896.100000) t) | 15@@list("Q2406" "TX_SOT23_2D4_122X55_H43" list(3810.780000 764.400000) t) | 15@@list("Q3100" "TX_SOT23_2D4_H44" list(6082.000000 740.000000) t) | 15@@list("Q3101" "TX_SC70_S6_H47" list(5908.000000 910.000000) t) | 15@@list("Q3102" "TX_SOT23_2D4_H44" list(5957.000000 740.000000) t) | 15@@list("Q3600" "TX_SOT23_2D4_H44" list(5606.780000 933.000000) t) | 15@@list("Q3601" "TX_SOT23_2D4_H44" list(4117.000000 3351.000000) t) | 15@@list("Q3602" "TX_SOT23_2D4_H44" list(7892.470000 3764.910000) t) | 15@@list("Q3700" "TX_SOT23_2D4_H43" list(7825.000000 4509.000000) t) | 15@@list("Q3701" "TX_SC70_S6_H47" list(4571.000000 964.000000) t) | 15@@list("Q5000" "TX_SC70_S6_H47" list(567.000000 3617.000000) t) | 15@@list("Q5002" "TX_SC70_S6_H47" list(448.000000 3632.500000) t) | 15@@list("Q5100" "TX_SOT23_2D4_H44" list(6211.400000 902.460000) t) | 15@@list("Q5101" "TX_SOT23_2D4_122X55_H43" list(1546.000000 704.000000) t) | 15@@list("Q5102" "TX_SC70_S6_H47" list(1570.000000 455.000000) t) | 15@@list("Q5103" "TX_SC70_S6_H47" list(1532.000000 580.000000) t) | 15@@list("Q5104" "TX_SC70_S6_H47" list(1480.000000 455.000000) t) | 15@@list("Q5800" "TX_SOT23_2D4_H44" list(386.000000 3098.000000) t) | 15@@list("Q5801" "TX_SOT23_2D4_H44" list(4380.000000 954.000000) t) | 15@@list("Q6900" "TX_SC70_S6_H47" list(5510.000000 3585.000000) t) | 15@@list("Q6901" "TX_SOT23_2D4_H44" list(5553.000000 3221.000000) t) | 15@@list("Q7200" "TX_SOT23_2D4_H44" list(7941.000000 4705.000000) t) | 15@@list("Q7201" "TX_SOT23_2D4_H44" list(7785.000000 4705.000000) t) | 15@@list("Q7202" "TX_SOT23_2D4_H44" list(7969.400000 4518.320000) t) | 15@@list("Q7203" "TX_SOT23_2D4_H44" list(6023.260000 4471.400000) t) | 15@@list("Q7204" "TX_SOT23_2D4_H44" list(7970.000000 4363.000000) t) | 15@@list("R0400" "TX_R0402" list(5184.000000 2847.000000) t) | 15@@list("R0403" "TX_R0402" list(5038.060000 2689.000000) t) | 15@@list("R0410" "TX_R0402" list(5102.560000 2907.000000) t) | 15@@list("R0416" "TX_R0402" list(5069.000000 3278.060000) t) | 15@@list("R0417" "TX_R0402" list(5021.620000 2762.200000) t) | 15@@list("R0418" "TX_R0402_H16" list(5056.000000 3190.000000) t) | 15@@list("R0420" "TX_R0402" list(5021.620000 2726.000000) t) | 15@@list("R0503" "TX_R0402" list(3608.940000 4582.550000) t) | 15@@list("R0504" "TX_R0402" list(3539.000000 4734.000000) t) | 15@@list("R0601" "TX_R0402" list(5101.560000 2833.500000) t) | 15@@list("R0602" "TX_R0402" list(5101.560000 2870.000000) t) | 15@@list("R0603" "TX_R0402" list(5021.620000 2834.800000) t) | 15@@list("R0604" "TX_R0402_0OHM" list(5021.620000 2798.500000) t) | 15@@list("R0605" "TX_R0402_0OHM" list(5021.620000 2871.800000) t) | 15@@list("R0608" "TX_R0402" list(6514.000000 1947.000000) t) | 15@@list("R0609" "TX_R0402" list(6553.000000 1999.000000) t) | 15@@list("R0901" "TX_R0402" list(4769.060000 3301.000000) t) | 15@@list("R0902" "TX_R0402" list(5102.060000 2797.000000) t) | 15@@list("R0903" "TX_R0402" list(4852.000000 1325.000000) t) | 15@@list("R0904" "TX_R0402_0OHM" list(4813.000000 1362.000000) t) | 15@@list("R0905" "TX_R0402_0OHM" list(4877.000000 1368.000000) t) | 15@@list("R1000" "TX_R0402" list(5007.000000 2337.000000) t) | 15@@list("R1001" "TX_R0402_0OHM" list(4970.000000 2364.000000) t) | 15@@list("R1009" "TX_R0402" list(4145.000000 1171.000000) t) | 15@@list("R1011" "TX_R0402" list(4182.000000 1171.000000) t) | 15@@list("R1012" "TX_R0402" list(3687.000000 2058.000000) t) | 15@@list("R1013" "TX_R0402" list(3660.000000 2016.000000) t) | 15@@list("R1014" "TX_R0402" list(3660.000000 1979.000000) t) | 15@@list("R1015" "TX_R0402" list(3620.000000 2053.000000) t) | 15@@list("R1016" "TX_R0402" list(3384.000000 1119.000000) t) | 15@@list("R1019" "TX_R0402" list(4012.000000 1186.000000) t) | 15@@list("R1020" "TX_R0402_0OHM" list(4970.000000 2300.000000) t) | 15@@list("R1021" "TX_R0402" list(3604.000000 1452.000000) t) | 15@@list("R1102" "TX_R0402" list(4558.000000 1151.500000) t) | 15@@list("R1103" "TX_R0402" list(4632.000000 1151.500000) t) | 15@@list("R1104" "TX_R0402" list(4625.000000 1216.000000) t) | 15@@list("R1105" "TX_R0402" list(4662.000000 1216.000000) t) | 15@@list("R1107" "TX_R0402" list(3714.850000 1534.540000) t) | 15@@list("R1108" "TX_R0402" list(3754.000000 1534.000000) t) | 15@@list("R1109" "TX_R0402" list(4595.000000 1151.500000) t) | 15@@list("R1115" "TX_R0402" list(3641.000000 1452.000000) t) | 15@@list("R1201" "TX_R0402_0OHM" list(3756.000000 1365.000000) t) | 15@@list("R1202" "TX_R0402" list(4895.120000 3300.000000) t) | 15@@list("R1203" "TX_R0402" list(3640.500000 1534.000000) t) | 15@@list("R1206" "TX_R0402" list(4108.000000 1171.000000) t) | 15@@list("R1207" "TX_R0402" list(3678.000000 1536.000000) t) | 15@@list("R1213" "TX_R0402" list(3629.200000 1932.000000) t) | 15@@list("R1214" "TX_R0402" list(3603.500000 1532.500000) t) | 15@@list("R1216" "TX_R0402_SHORT" list(3618.000000 1857.000000) t) | 15@@list("R1222" "TX_R0402" list(3825.000000 1250.000000) t) | 15@@list("R1223" "TX_R0402_SHORT" list(3838.000000 1356.000000) t) | 15@@list("R1224" "TX_R0402" list(3650.000000 925.000000) t) | 15@@list("R1225" "TX_R0402" list(3792.000000 1365.000000) t) | 15@@list("R1227" "TX_R0402_0OHM" list(3641.000000 1222.000000) t) | 15@@list("R1228" "TX_R0402_SHORT" list(3605.000000 1222.000000) t) | 15@@list("R1300" "TX_R0402" list(4943.960000 1864.490000) t) | 15@@list("R1301" "TX_R0402" list(4018.000000 1372.000000) t) | 15@@list("R1400" "TX_R0402" list(4307.000000 1314.200000) t) | 15@@list("R1401" "TX_R0402" list(4946.000000 1538.000000) t) | 15@@list("R1402" "TX_R0402" list(5024.000000 1879.000000) t) | 15@@list("R1403" "TX_R0402" list(5024.000000 1916.000000) t) | 15@@list("R1404" "TX_R0402" list(5116.000000 1916.000000) t) | 15@@list("R1405" "TX_R0402" list(5079.000000 1916.000000) t) | 15@@list("R1406" "TX_R0402_SHORT" list(4886.000000 1126.000000) t) | 15@@list("R1407" "TX_R0402_SHORT" list(4667.500000 1374.430000) t) | 15@@list("R1408" "TX_R0402_SHORT" list(4703.500000 1374.430000) t) | 15@@list("R1409" "TX_R0402" list(4743.620000 1376.000000) t) | 15@@list("R1410" "TX_R0402" list(4198.000000 1377.000000) t) | 15@@list("R1411" "TX_R0402" list(4235.000000 1381.000000) t) | 15@@list("R1500" "TX_R0402" list(3789.000000 1452.000000) t) | 15@@list("R1504" "TX_R0402" list(4699.000000 1216.000000) t) | 15@@list("R1505" "TX_R0402" list(4736.000000 1229.000000) t) | 15@@list("R1506" "TX_R0402" list(4344.000000 1377.000000) t) | 15@@list("R1509" "TX_R0402" list(4429.000000 1180.000000) t) | 15@@list("R1510" "TX_R0402" list(4521.000000 1151.500000) t) | 15@@list("R1511" "TX_R0402" list(4440.100000 1255.000000) t) | 15@@list("R1512" "TX_R0402" list(4484.000000 1151.500000) t) | 15@@list("R1513" "TX_R0402" list(4272.000000 1377.000000) t) | 15@@list("R1514" "TX_R0402" list(4308.000000 1377.000000) t) | 15@@list("R1515" "TX_R0402" list(4249.000000 1097.000000) t) | 15@@list("R1516" "TX_R0402" list(4212.000000 1097.000000) t) | 15@@list("R1518" "TX_R0402" list(3568.000000 752.000000) t) | 15@@list("R1520" "TX_R0402" list(5654.000000 1089.000000) t) | 15@@list("R1601" "TX_R0402_SHORT" list(5096.000000 1476.000000) t) | 15@@list("R1602" "TX_R0402_SHORT" list(5090.000000 1551.000000) t) | 15@@list("R1614" "TX_R0402_SHORT" list(4217.000000 978.000000) t) | 15@@list("R1900" "TX_R0402" list(3906.000000 1178.000000) t) | 15@@list("R1901" "TX_R0402_SHORT" list(3944.010000 1026.990000) t) | 15@@list("R1902" "TX_R0402" list(3485.000000 980.000000) t) | 15@@list("R1903" "TX_R0402" list(3485.000000 1120.000000) t) | 15@@list("R1904" "TX_R0402" list(3908.000000 1027.000000) t) | 15@@list("R1905" "TX_R0402" list(3485.000000 1055.000000) t) | 15@@list("R1906" "TX_R0402" list(3907.510000 1092.000000) t) | 15@@list("R1907" "TX_R0402_SHORT" list(2962.630000 903.900000) t) | 15@@list("R1908" "TX_R0402_SHORT" list(3396.900000 792.370000) t) | 15@@list("R1909" "TX_R0402_SHORT" list(564.000000 2191.000000) t) | 15@@list("R1910" "TX_R0402_SHORT" list(494.000000 1962.500000) t) | 15@@list("R1911" "TX_R0402" list(461.990000 2187.000000) t) | 15@@list("R1912" "TX_R0402" list(605.000000 2040.000000) t) | 15@@list("R1913" "TX_R0402" list(531.000000 1962.500000) t) | 15@@list("R2415" "TX_R0402" list(3874.000000 862.000000) t) | 15@@list("R2416" "TX_R0402" list(3732.000000 817.000000) t) | 15@@list("R2425" "TX_R0402_0OHM" list(3911.000000 862.000000) t) | 15@@list("R2428" "TX_R0402_0OHM" list(3702.000000 750.000000) t) | 15@@list("R2607" "TX_R0402" list(531.000000 2799.000000) t) | 15@@list("R2608" "TX_R0402" list(560.000000 2714.990000) t) | 15@@list("R2609" "TX_R0402" list(560.000000 2614.990000) t) | 15@@list("R2610" "TX_R0402" list(560.000000 2894.000000) t) | 15@@list("R3000" "TX_R0402_SHORT" list(2302.000000 4118.500000) t) | 15@@list("R3001" "TX_R0402_SHORT" list(2266.000000 4122.500000) t) | 15@@list("R3002" "TX_R0402_0OHM" list(2205.000000 4071.000000) t) | 15@@list("R3003" "TX_R0402" list(1776.000000 4177.000000) t) | 15@@list("R3005" "TX_R0402" list(2936.000000 4154.000000) t) | 15@@list("R3108" "TX_R0805_0OHM_H26" list(3990.000000 842.000000) t) | 15@@list("R3109" "TX_R0402" list(5944.750000 972.050000) t) | 15@@list("R3110" "TX_R0402" list(5879.750000 972.050000) t) | 15@@list("R3111" "TX_R0402_0OHM" list(8204.000000 674.000000) t) | 15@@list("R3112" "TX_R0402_0OHM" list(8203.000000 637.800000) t) | 15@@list("R3115" "TX_R0402_0OHM" list(5814.000000 922.000000) t) | 15@@list("R3601" "TX_R0402" list(7790.000000 3838.000000) t) | 15@@list("R3602" "TX_R0402" list(7915.000000 3675.000000) t) | 15@@list("R3606" "TX_R0402" list(5446.780000 995.000000) t) | 15@@list("R3607" "TX_R0402" list(5238.780000 987.500000) t) | 15@@list("R3608" "TX_R0402" list(5382.000000 958.000000) t) | 15@@list("R3610" "TX_R0402_0OHM" list(7846.000000 3855.000000) t) | 15@@list("R3611" "TX_R0402" list(8012.000000 3700.000000) t) | 15@@list("R3708" "TX_R0402" list(4858.000000 3951.000000) t) | 15@@list("R3710" "TX_R0402" list(4677.000000 969.000000) t) | 15@@list("R3711" "TX_R0402" list(4684.500000 1136.000000) t) | 15@@list("R3712" "TX_R0402" list(4676.000000 911.000000) t) | 15@@list("R3713" "TX_R0402" list(4733.000000 1136.500000) t) | 15@@list("R3714" "TX_R0402" list(4478.000000 908.000000) t) | 15@@list("R3715" "TX_R0402" list(4954.000000 3702.000000) t) | 15@@list("R3800" "TX_R0402" list(143.000000 2356.000000) t) | 15@@list("R3802" "TX_R0603_H22" list(346.000000 2050.000000) t) | 15@@list("R3803" "TX_R0603_H22" list(92.000000 1834.000000) t) | 15@@list("R3805" "TX_R0402" list(622.000000 1231.000000) t) | 15@@list("R3808" "TX_R0402" list(653.020000 1366.560000) t) | 15@@list("R3809" "TX_R0402" list(647.710000 1638.520000) t) | 15@@list("R3810" "TX_R0402" list(406.690000 1768.470000) t) | 15@@list("R3811" "TX_R0402" list(648.070000 1526.650000) t) | 15@@list("R3818" "TX_R0402_0OHM" list(411.000000 1868.000000) t) | 15@@list("R3820" "TX_R0402" list(648.000000 1402.760000) t) | 15@@list("R3822" "TX_R0402" list(300.000000 1103.000000) t) | 15@@list("R3823" "TX_R0402" list(351.000000 1120.000000) t) | 15@@list("R3824" "TX_R0402" list(591.660000 1627.710000) t) | 15@@list("R3825" "TX_R0402_0OHM" list(210.000000 1142.000000) t) | 15@@list("R3828" "TX_R0402" list(148.800000 1807.000000) t) | 15@@list("R3829" "TX_R0402" list(352.000000 1958.000000) t) | 15@@list("R5100" "TX_R0402" list(3324.000000 807.000000) t) | 15@@list("R5101" "TX_R0402" list(6529.480000 1033.380000) t) | 15@@list("R5110" "TX_R0402" list(6477.630000 1019.000000) t) | 15@@list("R5700" "TX_R0402_0OHM" list(606.000000 3325.000000) t) | 15@@list("R5701" "TX_R0402_0OHM" list(606.000000 3365.000000) t) | 15@@list("R5702" "TX_R0402" list(670.000000 3325.000000) t) | 15@@list("R5703" "TX_R0402" list(670.000000 3365.000000) t) | 15@@list("R5709" "TX_R0402" list(680.000000 3580.000000) t) | 15@@list("R5712" "TX_R0402_SHORT" list(421.000000 3292.000000) t) | 15@@list("R5721" "TX_R0402_SHORT" list(671.000000 3455.000000) t) | 15@@list("R5722" "TX_R0402_SHORT" list(670.500000 3528.000000) t) | 15@@list("R5723" "TX_R0402_0OHM" list(670.500000 3492.000000) t) | 15@@list("R5724" "TX_R0402_0OHM" list(671.000000 3419.000000) t) | 15@@list("R5813" "TX_R0402" list(381.000000 3216.000000) t) | 15@@list("R5814" "TX_R0402_SHORT" list(432.000000 2978.000000) t) | 15@@list("R5815" "TX_R0402" list(466.000000 3049.000000) t) | 15@@list("R5819" "TX_R0402" list(683.000000 3067.000000) t) | 15@@list("R5820" "TX_R0402" list(683.000000 3131.000000) t) | 15@@list("R5824" "TX_R0402" list(4275.000000 919.000000) t) | 15@@list("R5825" "TX_R0402_0OHM" list(4479.000000 974.400000) t) | 15@@list("R5900" "TX_R0402" list(602.000000 3687.000000) t) | 15@@list("R5902" "TX_R0402_0OHM" list(657.000000 3802.000000) t) | 15@@list("R5903" "TX_R0402" list(673.000000 3736.000000) t) | 15@@list("R5905" "TX_R0402_0OHM" list(602.000000 3724.000000) t) | 15@@list("R6006" "TX_R0402" list(6148.000000 3173.000000) t) | 15@@list("R6007" "TX_R0402" list(6163.000000 4339.000000) t) | 15@@list("R6008" "TX_R0402" list(6200.000000 4339.000000) t) | 15@@list("R6201" "TX_R0402" list(5626.500000 3862.000000) t) | 15@@list("R6303" "TX_R0402" list(6344.000000 4346.000000) t) | 15@@list("R6304" "TX_R0402" list(6453.000000 4398.000000) t) | 15@@list("R6305" "TX_R0402" list(6453.000000 4324.000000) t) | 15@@list("R6306" "TX_R0402" list(6381.000000 4346.000000) t) | 15@@list("R6307" "TX_R0402" list(6268.000000 4325.000000) t) | 15@@list("R6800" "TX_R0402" list(7066.000000 4002.000000) t) | 15@@list("R6801" "TX_R0402" list(7680.000000 4275.000000) t) | 15@@list("R6802" "TX_R0402" list(7680.000000 4238.000000) t) | 15@@list("R6804" "TX_R0402" list(5612.000000 3316.000000) t) | 15@@list("R6806" "TX_R0402" list(7048.000000 4045.000000) t) | 15@@list("R6807" "TX_R0402" list(7048.010000 4087.000000) t) | 15@@list("R6810" "TX_R0402" list(7689.000000 3286.000000) t) | 15@@list("R6811" "TX_R0402" list(7689.990000 3328.000000) t) | 15@@list("R6812" "TX_R0402" list(7043.000000 4226.000000) t) | 15@@list("R6813" "TX_R0402" list(7042.990000 4267.000000) t) | 15@@list("R6814" "TX_R0402" list(7692.000000 3442.000000) t) | 15@@list("R6815" "TX_R0402" list(7692.010000 3483.000000) t) | 15@@list("R6816" "TX_R0402" list(7691.000000 3403.000000) t) | 15@@list("R6817" "TX_R0402" list(7678.000000 3249.000000) t) | 15@@list("R6819" "TX_R0402" list(7677.000000 3212.000000) t) | 15@@list("R6900" "TX_R0402_0OHM" list(5589.000000 3728.000000) t) | 15@@list("R6907" "TX_R0402" list(6083.000000 3150.000000) t) | 15@@list("R6910" "TX_R0402" list(6209.500000 3160.510000) t) | 15@@list("R6911" "TX_R0402" list(6246.500000 3160.510000) t) | 15@@list("R6912" "TX_R0402" list(6300.370000 3152.180000) t) | 15@@list("R6913" "TX_R0402" list(6337.370000 3152.180000) t) | 15@@list("R6914" "TX_R0402" list(5528.000000 3301.000000) t) | 15@@list("R6942" "TX_R0402" list(5625.500000 3682.000000) t) | 15@@list("R6943" "TX_R0402" list(6366.000000 3081.000000) t) | 15@@list("R7003" "TX_R0402" list(7323.000000 4584.000000) t) | 15@@list("R7004" "TX_R0402_0OHM" list(7362.000000 4584.000000) t) | 15@@list("R7005" "TX_R0603_T02_H30" list(7065.000000 4515.000000) t) | 15@@list("R7200" "TX_R0402" list(7552.000000 4523.000000) t) | 15@@list("R7201" "TX_R0402" list(7530.000000 4574.000000) t) | 15@@list("R7202" "TX_R0402" list(7964.180000 4614.790000) t) | 15@@list("R7203" "TX_R0402" list(5924.790000 4479.820000) t) | 15@@list("R7204" "TX_R0402" list(7888.000000 4372.000000) t) | 15@@list("R7205" "TX_R0402_0OHM" list(7967.210000 4241.180000) t) | 15@@list("RN2603" "TX_2R4P0402_47X55_COLAY" list(451.000000 2799.000000) t) | 15@@list("RN2604" "TX_2R4P0402_47X55_COLAY" list(450.000000 2715.000000) t) | 15@@list("RN2605" "TX_2R4P0402_47X55_COLAY" list(450.000000 2625.000000) t) | 15@@list("RN2606" "TX_2R4P0402_47X55_COLAY" list(451.000000 2889.000000) t) | 15@@list("RN3000" "TX_2R4P0402_47X55_COLAY" list(1889.000000 4133.000000) t) | 15@@list("RN5100" "TX_4R8P0402_H22_T01" list(2414.350000 955.010000) t) | 15@@list("RN5101" "TX_4R8P0402_H22_T01" list(2550.350000 955.010000) t) | 15@@list("RN5700" "TX_2R4P0402_47X55_COLAY" list(365.000000 3523.000000) t) | 15@@list("T0404" "NB_TPC26T_50" list(4965.000000 2729.000000) t) | 15@@list("T0407" "NB_TPC26T_50" list(5138.000000 1581.000000) t) | 15@@list("T0408" "NB_TPC26T_50" list(4984.030000 2665.360000) t) | 15@@list("T0410" "NB_TPC26T_50" list(4920.060000 2839.500000) t) | 15@@list("T0900" "NB_TPC26T_50" list(4925.560000 3044.000000) t) | 15@@list("T0901" "NB_TPC26T_50" list(5115.000000 1862.000000) t) | 15@@list("T0904" "NB_TPC26T_50" list(4809.000000 3282.000000) t) | 15@@list("T0906" "NB_TPC26T_50" list(4925.380000 3095.840000) t) | 15@@list("T0907" "NB_TPC26T_50" list(4925.380000 2992.840000) t) | 15@@list("T1000" "NB_TPC26T_50" list(4163.500000 1227.500000) t) | 15@@list("T1004" "NB_TPC26T_50" list(3498.000000 1692.000000) t) | 15@@list("T1100" "NB_TPC26T_50" list(4614.660000 1422.140000) t) | 15@@list("T1101" "NB_TPC26T_50" list(4016.000000 1317.000000) t) | 15@@list("T1103" "NB_TPC26T_50" list(4529.000000 1203.000000) t) | 15@@list("T1104" "NB_TPC26T_50" list(4447.730000 1380.610000) t) | 15@@list("T1200" "NB_TPC26T_50" list(3749.000000 1912.000000) t) | 15@@list("T1201" "NB_TPC26T_50" list(3535.000000 1579.000000) t) | 15@@list("T1202" "NB_TPC26T_50" list(4857.000000 3262.000000) t) | 15@@list("T1206" "NB_TPC26T_50" list(4048.000000 1271.000000) t) | 15@@list("T1401" "NB_TPC26T_50" list(4953.060000 2797.000000) t) | 15@@list("T1402" "NB_TPC26T_50" list(4631.000000 1371.000000) t) | 15@@list("T1501" "NB_TPC26T_50" list(4133.000000 1305.000000) t) | 15@@list("T1502" "NB_TPC26T_50" list(4205.000000 1265.000000) t) | 15@@list("T1503" "NB_TPC26T_50" list(4309.160000 1461.010000) t) | 15@@list("T1506" "NB_TPC26T_50" list(4397.240000 1364.780000) t) | 15@@list("T1507" "NB_TPC26T_50" list(3791.000000 1509.000000) t) | 15@@list("T1508" "NB_TPC26T_50" list(3861.000000 1419.000000) t) | 15@@list("T2304" "TPC40T_68" list(1097.530000 1563.620000) t) | 15@@list("T2309" "TPC40T_68" list(3404.000000 1933.000000) t) | 15@@list("T2310" "TPC40T_68" list(1442.000000 1774.000000) t) | 15@@list("T5802" "TPC40T_68" list(1555.000000 3537.000000) t) | 15@@list("T5803" "TPC40T_68" list(1507.000000 3151.000000) t) | 15@@list("T5804" "TPC40T_68" list(1565.000000 3195.000000) t) | 15@@list("T5805" "MX_TPC26T_S4_68" list(1375.930000 3458.280000) t) | 15@@list("T6901" "NB_TPC26T_50" list(6609.000000 2993.000000) t) | 15@@list("T6902" "NB_TPC26T_50" list(6473.000000 3142.000000) t) | 15@@list("T6903" "NB_TPC26T_50" list(6554.000000 3002.000000) t) | 15@@list("T6904" "NB_TPC26T_50" list(6466.000000 3203.000000) t) | 15@@list("T6914" "NB_TPC26T_50" list(5913.000000 3202.000000) t) | 15@@list("T6918" "NB_TPC26T_50" list(6205.000000 3215.000000) t) | 15@@list("T6919" "NB_TPC26T_50" list(6150.000000 3220.000000) t) | 15@@list("T6920" "NB_TPC26T_50" list(6453.000000 2955.000000) t) | 15@@list("T6921" "NB_TPC26T_50" list(6401.000000 3005.000000) t) | 15@@list("T6922" "NB_TPC26T_50" list(6302.000000 3076.000000) t) | 15@@list("T6923" "NB_TPC26T_50" list(6265.000000 3215.000000) t) | 15@@list("T6924" "NB_TPC26T_50" list(5661.000000 3639.000000) t) | 15@@list("T6930" "NB_TPC26T_50" list(6518.000000 2950.000000) t) | 15@@list("T6931" "NB_TPC26T_50" list(6574.000000 2945.000000) t) | 15@@list("T6932" "NB_TPC26T_50" list(6458.000000 3053.000000) t) | 15@@list("T6933" "NB_TPC26T_50" list(6511.000000 3038.000000) t) | 15@@list("T6934" "NB_TPC26T_50" list(6489.000000 3094.000000) t) | 15@@list("T6936" "NB_TPC26T_50" list(6469.000000 3004.000000) t) | 15@@list("T6939" "NB_TPC26T_50" list(6398.000000 2948.000000) t) | 15@@list("T6947" "NB_TPC26T_50" list(5689.000000 3586.000000) t) | 15@@list("T6948" "NB_TPC26T_50" list(6099.000000 3239.000000) t) | 15@@list("U0400" "BGA_1356P_1654X945_INTEL" list(4355.190000 2341.300000) t) | 15@@list("U0500" "TX_SC70_S5_TI" list(3509.940000 4611.000000) t) | 15@@list("U1200" "TX_SC70_S5_TI" list(3662.000000 1347.500000) t) | 15@@list("U1201" "TX_SC70_S5_TI" list(2711.000000 958.000000) t) | 15@@list("U1202" "TX_SC70_S5_TI" list(2712.000000 857.000000) t) | 15@@list("U1203" "TX_SC70_S5_TI" list(3735.000000 1240.000000) t) | 15@@list("U1204" "TX_SC70_S5_TI" list(3607.000000 823.000000) t) | 15@@list("U1800" "TX_SC70_S5_TI" list(2869.000000 1014.000000) t) | 15@@list("U1900" "TX_SOIC_8P_50_213X213" list(3699.000000 1072.000000) t) | 15@@list("U3000" "TX_SOT23_S5_H57" list(1658.000000 4174.000000) t) | 15@@list("U3100" "TX_SOT23_S5_2D4_H57" list(3966.870000 746.470000) t) | 15@@list("U3700" "TX_SOIC_8P_26_122X122" list(4929.000000 3805.500000) t) | 15@@list("U5100" "TX_SOT363_PHILIPS" list(3113.000000 945.000000) t) | 15@@list("U5101" "TX_SOT23_S5_2D4_122X67_H57" list(7778.000000 2059.000000) t) | 15@@list("U5801" "TX_SOT23_S5_2D4_T02X01_H57" list(1397.310000 1032.000000) t) | 15@@list("U5802" "TX_SOT23_S5_2D4_T02X01_H57" list(574.000000 3083.000000) t) | 15@@list("U6001" "TX_SC70_S5_TI" list(5209.000000 3702.000000) t) | 15@@list("U6800" "TX_BGA_170P_31_555X476" list(7370.000000 4135.000000) t) | 15@@list("U6802" "TX_BGA_170P_31_555X476" list(7370.410000 3387.730000) t) | 15@@list("U6903" "TX_SC70_S5_TI" list(5369.890000 3719.350000) t) | 15@@list("X0900" "TX_XTAL_4P_126X98_HELE" list(4878.530000 1222.510000) t) | 15@@list("X1000" "TX_XTAL_4P_126X98_HELE" list(5088.020000 2363.300000) t) | 15@@list("X6900" "TX_XTAL_4P_126X98_HELE_H35" list(5491.000000 3708.000000) t) | 16@@list("PD9400" "TX_SOD323F_H49" list(4400.000000 4428.000000) t) | 16@@list("PD9800" "TX_SOD323F_H49" list(7370.000000 2697.500000) t) | 16@@list("PU7700" "TX_QFN_32P_16_S161_PAD_5V" list(7505.000000 1265.500000) t) | 16@@list("PU8800" "TX_DFN_10P_20_S122_P_4V" list(1556.000000 870.000000) t) | 16@@list("PU8801" "TX_DFN_10P_20_S122_P_4V" list(4066.000000 4656.000000) t) | 16@@list("PU8900" "A_QFN_20P_16_S122_P_4V" list(7675.000000 2585.000000) t) | 16@@list("PU9100" "TX_DFN_10P_16_122X83_P_COLA" list(7644.000000 2284.500000) t) | 16@@list("PU9101" "TX_DFN_10P_16_122X83_P_COLA" list(6864.000000 819.000000) t) | 16@@list("PU9200" "TX_DFN_10P_16_122X83_P_COLA" list(5244.000000 1190.000000) t) | 16@@list("PU9400" "TX_QFN_40P_16_S201_P_4V_H31" list(4225.000000 4215.000000) t) | 16@@list("PU9501" "TX_DFN_10P_20_S122_P_4V" list(6500.000000 4655.000000) t) | 16@@list("U5702" "A_QFN_20P_16_122X122_P_5V" list(485.000000 3419.000000) t) | 16@@list("U7000" "TX_DFN_10P_16_122X83_PAD" list(7200.000000 4583.000000) t) | 17@@list("U3800" "TX_QFN_48P_16_S240_P_9V_REA" list(460.000000 1405.000000) t) | 1@@list("" "INDEXB_CROSS" list(7832.000000 4239.000000) nil) | 1@@list("" "INDEXB_CROSS" list(7850.500000 1109.000000) nil) | 1@@list("" "INDEXB_CROSS" list(816.000000 631.000000) nil) | 1@@list("D2400" "TX_SOD323_H39" list(418.000000 2308.080000) nil) | 1@@list("D2401" "TX_SOT323_PAN" list(211.000000 1001.000000) nil) | 1@@list("D2500" "TX_SOD523_1D7_H28" list(3106.000000 1055.000000) nil) | 1@@list("D3604" "TX_SOD523_1D7_H28" list(3710.000000 3559.000000) nil) | 1@@list("D3605" "TX_SOD523_1D7_H28" list(2150.000000 1198.000000) nil) | 1@@list("PCE8601" "TX_SOD523_1D7_H28" list(3931.970000 3832.750000) nil) | 1@@list("PD8800" "TX_SOD323_H39" list(1663.000000 745.000000) nil) | 1@@list("PQ7605" "TX_SOT363_PHILIPS" list(2582.000000 4428.000000) nil) | 1@@list("PQ7606" "TX_SOT363_PHILIPS" list(2581.970000 4531.900000) nil) | 1@@list("PQ7609" "TX_SOT363_PHILIPS" list(2347.030000 4480.960000) nil) | 1@@list("PQ7610" "TX_SOT363_PHILIPS" list(1137.470000 4566.800000) nil) | 1@@list("PQ7611" "TX_SOT363_PHILIPS" list(973.000000 4497.300000) nil) | 1@@list("T2300" "TPC40T_68" list(1439.000000 1325.000000) nil) | 1@@list("T2301" "TPC40T_68" list(757.000000 1947.000000) nil) | 1@@list("T2302" "TPC40T_68" list(672.000000 1833.000000) nil) | 1@@list("T2303" "TPC40T_68" list(1573.000000 1380.000000) nil) | 1@@list("T2305" "TPC40T_68" list(1465.000000 1389.000000) nil) | 1@@list("T2306" "TPC40T_68" list(1514.000000 1334.000000) nil) | 1@@list("T2307" "TPC40T_68" list(1254.000000 1294.000000) nil) | 1@@list("T2308" "TPC40T_68" list(790.470000 1378.620000) nil) | 1@@list("T3600" "TPC40T_68" list(3786.000000 757.000000) nil) | 1@@list("U6801" "TX_BGA_170P_31_555X476" list(7370.000000 4135.000000) nil) | 1@@list("U6803" "TX_BGA_170P_31_555X476" list(7370.410000 3387.730000) nil) | 24@@list("" "BOARD PASTEMASK ADDED BY LAYOUT" list(7899.580000 3988.570000) nil) | 24@@list("" "BOARD PASTEMASK ADDED BY LAYOUT" list(7909.580000 4063.490000) nil) | 24@@list("" "BOARD PASTEMASK ADDED BY LAYOUT" list(7929.540000 3925.300000) nil) | 24@@list("" "BOARD PASTEMASK ADDED BY LAYOUT" list(7944.540000 4096.760000) nil) | 24@@list("" "BOARD PASTEMASK ADDED BY LAYOUT" list(7979.580000 2418.570000) nil) | 24@@list("" "BOARD PASTEMASK ADDED BY LAYOUT" list(7979.580000 2468.490000) nil) | 24@@list("" "BOARD PASTEMASK ADDED BY LAYOUT" list(7992.810000 3890.340000) nil) | 24@@list("" "BOARD PASTEMASK ADDED BY LAYOUT" list(8004.540000 2375.300000) nil) | 24@@list("" "BOARD PASTEMASK ADDED BY LAYOUT" list(8004.540000 2511.760000) nil) | 24@@list("" "BOARD PASTEMASK ADDED BY LAYOUT" list(8007.810000 4116.760000) nil) | 24@@list("" "BOARD PASTEMASK ADDED BY LAYOUT" list(8047.810000 2536.760000) nil) | 24@@list("" "BOARD PASTEMASK ADDED BY LAYOUT" list(8057.810000 2340.340000) nil) | 24@@list("" "BOARD PASTEMASK ADDED BY LAYOUT" list(8062.730000 3885.340000) nil) | 24@@list("" "BOARD PASTEMASK ADDED BY LAYOUT" list(8127.730000 2335.340000) nil) | 24@@list("CE2200" "TX_C7343D_299X177" list(1565.000000 3730.000000) nil) | 24@@list("CE2201" "TX_C7343D_299X177" list(1712.510000 2735.320000) nil) | 24@@list("D2300" "VX_SOD523_1D7" list(1410.000000 1135.000000) nil) | 24@@list("D3003" "VX_SOD523_1D7" list(2137.000000 4058.000000) nil) | 24@@list("D3004" "VX_SOD523_1D7" list(2137.000000 4144.000000) nil) | 24@@list("H5201" "NB_H_CT236CB173D157_P2_S" list(3723.320000 3051.140000) nil) | 24@@list("H5202" "NB_H_CT236CB173D157_P2_S" list(3723.320000 1712.560000) nil) | 24@@list("H5204" "NB_H_S232D87_P2_S" list(91.430000 3279.490000) nil) | 24@@list("H5205" "NB_H_CT236CB173D157_P2_S" list(5061.910000 1712.560000) nil) | 24@@list("H5207" "NB_H_C315D169_P2_S" list(8002.850000 777.520000) t) | 24@@list("H5208" "NB_H_C315D169_P2_S" list(6420.170000 1576.730000) nil) | 24@@list("H5209" "NB_H_ST252CB315D205_P2_S" list(57.960000 1517.680000) nil) | 24@@list("H5210" "NB_H_CT236CB173D157_P2_S" list(6857.180000 4533.420000) nil) | 24@@list("H5211" "NB_H_C315D169_P2_S" list(3681.980000 529.490000) t) | 24@@list("H5212" "NB_H_CT236CB173D157_P2_S" list(6538.280000 2824.760000) nil) | 24@@list("H5213" "NB_H_CT236CB173D157_P2_S" list(5191.820000 3927.120000) nil) | 24@@list("H5214" "NB_H_ST295CB315D169_P2_S" list(4628.830000 4001.930000) nil) | 24@@list("H5215" "NB_H_S209D98_P2_S" list(12.690000 4080.670000) t) | 24@@list("H5216" "NB_H_CT236CB173D157_P2_S" list(5061.900000 3051.140000) nil) | 24@@list("PD7700" "TX_SOD523_1D7_T01_H26" list(7513.000000 1521.500000) nil) | 24@@list("PD7701" "TX_SOD523_1D7_T01_H26" list(7513.000000 1571.000000) nil) | 24@@list("PR8008" "TX_R1206_H30" list(5636.000000 2972.000000) nil) | 24@@list("PR8801" "TX_R0603_SHORT" list(1394.000000 1072.000000) nil) | 24@@list("PR9002" "TX_R0603_SHORT" list(1051.000000 2948.000000) nil) | 24@@list("PR9003" "TX_R0603_SHORT" list(1080.000000 3115.000000) nil) | 24@@list("PR9606" "TX_R1206_H30" list(5108.000000 4245.000000) nil) | 24@@list("PR9610" "TX_R1206_H30" list(4813.000000 4520.000000) nil) | 24@@list("PU7600" "TX_DFN_6P_16_51X51" list(1223.000000 3687.000000) nil) | 24@@list("R0700" "TX_R0805_0OHM_T02_H20" list(4505.000000 2550.000000) nil) | 24@@list("R0701" "TX_R0805_0OHM_T02_H20" list(4505.000000 2658.500000) nil) | 24@@list("R1625" "TX_R0603_SHORT" list(5034.000000 1496.000000) nil) | 24@@list("R3006" "TX_R0603_SHORT" list(2274.000000 4210.000000) nil) | 24@@list("R3007" "TX_R0603_SHORT" list(2274.000000 4155.000000) nil) | 24@@list("R3008" "TX_R0603_SHORT" list(2132.000000 4250.000000) nil) | 24@@list("SR3100" "TX_R0805_SHORT" list(8377.000000 1089.000000) nil) | 24@@list("U3702" "TX_DFN_4P_26_51X67_P_1V" list(-146.760000 2401.500000) nil) | 24@@list("U5700" "TX_DFN_10P_20_102X43_COLAY" list(278.500000 3573.000000) nil) | 24@@list("U5701" "TX_DFN_10P_20_102X43_COLAY" list(284.500000 3434.000000) nil) | 25@@list("" "BOARD PASTEMASK ADDED BY LAYOUT" list(7899.580000 3988.570000) t) | 25@@list("" "BOARD PASTEMASK ADDED BY LAYOUT" list(7909.580000 4063.490000) t) | 25@@list("" "BOARD PASTEMASK ADDED BY LAYOUT" list(7929.540000 3925.300000) t) | 25@@list("" "BOARD PASTEMASK ADDED BY LAYOUT" list(7944.540000 4096.760000) t) | 25@@list("" "BOARD PASTEMASK ADDED BY LAYOUT" list(7979.580000 2418.570000) t) | 25@@list("" "BOARD PASTEMASK ADDED BY LAYOUT" list(7979.580000 2468.490000) t) | 25@@list("" "BOARD PASTEMASK ADDED BY LAYOUT" list(7992.810000 3890.340000) t) | 25@@list("" "BOARD PASTEMASK ADDED BY LAYOUT" list(8004.540000 2375.300000) t) | 25@@list("" "BOARD PASTEMASK ADDED BY LAYOUT" list(8004.540000 2511.760000) t) | 25@@list("" "BOARD PASTEMASK ADDED BY LAYOUT" list(8007.810000 4116.760000) t) | 25@@list("" "BOARD PASTEMASK ADDED BY LAYOUT" list(8047.810000 2536.760000) t) | 25@@list("" "BOARD PASTEMASK ADDED BY LAYOUT" list(8057.810000 2340.340000) t) | 25@@list("" "BOARD PASTEMASK ADDED BY LAYOUT" list(8062.730000 3885.340000) t) | 25@@list("" "BOARD PASTEMASK ADDED BY LAYOUT" list(8127.730000 2335.340000) t) | 25@@list("CON2000" "A_DDR4_260P_20_4H_REV_FOX" list(2394.580000 2574.760000) t) | 25@@list("CON2600" "A_HDMI_19P_4H_RA_SMT_ACON" list(-66.050000 2868.070000) t) | 25@@list("CON3000" "TX_FPC_30P_20_2H_RA_ACES_B" list(2282.370000 4344.450000) t) | 25@@list("CON3600" "TX_WTOB_4P_39_2HD_RA_COLAY" list(7931.980000 3403.500000) t) | 25@@list("CON5100" "TX_FPC_8P_39_2HOLD_ACES_B" list(1924.110000 529.480000) t) | 25@@list("CON5101" "TX_FPC_4P_39_2HOLD_RA_AC_B" list(6516.700000 820.820000) t) | 25@@list("CON5102" "TX_FPC_30P_31_2HOLD_RA_ACE" list(2861.110000 608.230000) t) | 25@@list("CON5103" "A_WTOB_50P_20_4HD_IEX" list(8009.530000 1651.870000) t) | 25@@list("CON5700" "A_USB_24P_12HOLD_RA_FOX" list(93.010000 3679.090000) t) | 25@@list("F3000" "TX_POLYSWITCH_2P_1812_H71" list(2807.000000 4357.000000) t) | 25@@list("H5201" "NB_H_CT236CB173D157_P2_S" list(3723.320000 3051.140000) nil) | 25@@list("H5202" "NB_H_CT236CB173D157_P2_S" list(3723.320000 1712.560000) nil) | 25@@list("H5204" "NB_H_S232D87_P2_S" list(91.430000 3279.490000) nil) | 25@@list("H5205" "NB_H_CT236CB173D157_P2_S" list(5061.910000 1712.560000) nil) | 25@@list("H5207" "NB_H_C315D169_P2_S" list(8002.850000 777.520000) t) | 25@@list("H5208" "NB_H_C315D169_P2_S" list(6420.170000 1576.730000) nil) | 25@@list("H5209" "NB_H_ST252CB315D205_P2_S" list(57.960000 1517.680000) nil) | 25@@list("H5210" "NB_H_CT236CB173D157_P2_S" list(6857.180000 4533.420000) nil) | 25@@list("H5211" "NB_H_C315D169_P2_S" list(3681.980000 529.490000) t) | 25@@list("H5212" "NB_H_CT236CB173D157_P2_S" list(6538.280000 2824.760000) nil) | 25@@list("H5213" "NB_H_CT236CB173D157_P2_S" list(5191.820000 3927.120000) nil) | 25@@list("H5214" "NB_H_ST295CB315D169_P2_S" list(4628.830000 4001.930000) nil) | 25@@list("H5215" "NB_H_S209D98_P2_S" list(12.690000 4080.670000) t) | 25@@list("H5216" "NB_H_CT236CB173D157_P2_S" list(5061.900000 3051.140000) nil) | 25@@list("LED5000" "TX_LED_3P_126X59_CO" list(-161.730000 4151.740000) t) | 25@@list("PCE8600" "TX_C7343D_299X177" list(3642.000000 4431.000000) t) | 25@@list("PJP8601" "3MM_OPEN_5MIL_M1M2" list(3528.510000 4126.000000) t) | 25@@list("PJP8701" "2MM_OPEN_5MIL_M1M2" list(6288.000000 2333.000000) t) | 25@@list("PJP8802" "1MM_OPEN_5MIL_M1M2" list(1777.000000 893.000000) t) | 25@@list("PJP8902" "3MM_OPEN_5MIL_M1M2" list(7612.000000 2072.490000) t) | 25@@list("PJP8903" "3MM_OPEN_5MIL_M1M2" list(6841.510000 2705.000000) t) | 25@@list("PJP9500" "1MM_OPEN_5MIL_M1M2" list(6355.000000 2729.000000) t) | 25@@list("PJP9501" "1MM_OPEN_5MIL_M1M2" list(6070.000000 2986.000000) t) | 25@@list("PJP9503" "1MM_OPEN_5MIL_M1M2" list(6980.000000 4705.000000) t) | 25@@list("PJP9504" "2MM_OPEN_5MIL_M1M2" list(6222.000000 4489.000000) t) | 25@@list("PJP9800" "3MM_OPEN_5MIL_M1M2" list(6817.910000 2987.850000) t) | 25@@list("PL8900" "TX_INDUCTOR_2P_S406" list(7454.000000 1788.000000) t) | 25@@list("PQ7900" "TX_POWER_8P_50_2PAD_8V" list(5786.060000 2140.000000) t) | 25@@list("PQ7901" "TX_POWER_8P_50_2PAD_8V" list(5755.060000 2696.000000) t) | 25@@list("PQ8001" "TX_POWER_8P_50_2PAD_8V" list(5769.060000 3071.000000) t) | 25@@list("PQ9600" "TX_POWER_8P_50_2PAD_8V" list(4953.830000 4203.000000) t) | 25@@list("PQ9601" "TX_POWER_8P_50_2PAD_8V" list(4648.840000 4525.000000) t) | 25@@list("PR7801" "TX_R0603_SHORT" list(6403.000000 2078.000000) t) | 25@@list("PR7802" "TX_R0603_SHORT" list(6470.000000 2040.000000) t) | 25@@list("PR7903" "TX_R1206_H30" list(5616.000000 1937.000000) t) | 25@@list("PR7909" "TX_R1206_H30" list(5626.000000 2506.000000) t) | 25@@list("PR8607" "TX_R1206_H30" list(3194.000000 4639.500000) t) | 25@@list("PR8613" "TX_R0603_SHORT" list(2931.000000 4298.000000) t) | 25@@list("PR8700" "TX_R0603_SHORT" list(6994.000000 1672.500000) t) | 25@@list("PR8806" "TX_R0603_SHORT" list(3628.000000 4657.000000) t) | 25@@list("PR8808" "TX_R0603_SHORT" list(4191.000000 4562.000000) t) | 25@@list("PR8907" "TX_R1206_H30" list(7118.500000 2004.000000) t) | 25@@list("PR8920" "TX_R1206_H30" list(7340.000000 2555.000000) t) | 25@@list("PR9108" "TX_R0603_SHORT" list(7839.000000 2356.000000) t) | 25@@list("PR9202" "TX_R0603_SHORT" list(5128.000000 1107.000000) t) | 25@@list("PR9208" "TX_R0603_SHORT" list(5171.000000 1315.000000) t) | 25@@list("PR9414" "TX_R0603_SHORT" list(4392.000000 4333.000000) t) | 25@@list("PR9800" "TX_R0603_SHORT" list(7605.000000 2890.000000) t) | 25@@list("PU7800" "A_QFN_40P_16_201X201_PAD_8V" list(6675.000000 2185.000000) t) | 25@@list("PU9800" "TX_QFN_13P_122X83" list(7355.130000 2895.000000) t) | 25@@list("R1600" "TX_R0603_SHORT" list(5090.000000 1348.800000) t) | 25@@list("R1609" "TX_R0603_SHORT" list(5018.000000 1477.800000) t) | 25@@list("R1613" "TX_R0603_SHORT" list(5228.000000 1412.000000) t) | 25@@list("R1620" "TX_R0603_SHORT" list(5042.000000 1348.800000) t) | 25@@list("R3600" "TX_R0603_SHORT" list(7925.000000 3633.000000) t) | 25@@list("U2600" "TX_DFN_10P_20_102X43_COLAY" list(350.000000 2855.000000) t) | 25@@list("U2601" "TX_DFN_10P_20_102X43_COLAY" list(347.000000 2665.000000) t) | 25@@list("U5900" "A_QFN_17P_20_S161_P_8V" list(485.000000 3844.060000) t) | 25@@list("U6000" "TX_BGA_631P_909X909_AMD" list(6199.650000 3750.650000) t) | 3@@list("C0400" "TX_C0402" list(5056.000000 3227.000000) t) | 3@@list("C0500" "TX_C0402" list(3515.450000 4545.940000) t) | 3@@list("C0607" "TX_C0402" list(5064.000000 1200.800000) t) | 3@@list("C0608" "TX_C0402" list(5027.000000 1200.800000) t) | 3@@list("C0707" "TX_C0402" list(5008.000000 2205.000000) t) | 3@@list("C0708" "TX_C0402" list(5211.710000 2683.280000) t) | 3@@list("C0709" "TX_C0402" list(5212.000000 2574.000000) t) | 3@@list("C0710" "TX_C0402" list(4943.280000 2205.290000) t) | 3@@list("C0713" "TX_C0402" list(5196.000000 2485.000000) t) | 3@@list("C0714" "TX_C0402" list(5202.000000 2139.000000) t) | 3@@list("C0715" "TX_C0402" list(5211.710000 2646.780000) t) | 3@@list("C0716" "TX_C0402" list(5202.000000 2102.000000) t) | 3@@list("C0734" "TX_C0402" list(5212.000000 2538.000000) t) | 3@@list("C0735" "TX_C0402" list(5212.000000 2610.000000) t) | 3@@list("C0736" "TX_C0402" list(5202.000000 2176.000000) t) | 3@@list("C0737" "TX_C0402" list(5151.000000 2202.000000) t) | 3@@list("C0738" "TX_C0402" list(5113.050000 2201.600000) t) | 3@@list("C0739" "TX_C0402" list(5045.000000 2205.000000) t) | 3@@list("C0900" "TX_C0402" list(4788.000000 1325.000000) t) | 3@@list("C0901" "TX_C0402" list(4915.000000 1331.000000) t) | 3@@list("C1000" "TX_C0402" list(5007.000000 2273.000000) t) | 3@@list("C1001" "TX_C0402" list(5007.060000 2401.000000) t) | 3@@list("C1004" "TX_C0402" list(3609.020000 1996.000000) t) | 3@@list("C1005" "TX_C0402" list(4148.000000 1115.000000) t) | 3@@list("C1006" "TX_C0402" list(4066.000000 1131.000000) t) | 3@@list("C1104" "TX_C0402" list(3752.000000 1452.000000) t) | 3@@list("C1105" "TX_C0402" list(3678.000000 1452.000000) t) | 3@@list("C1200" "TX_C0402" list(3769.000000 1314.000000) t) | 3@@list("C1203" "TX_C0402" list(3706.000000 1879.000000) t) | 3@@list("C1206" "TX_C0402" list(3650.000000 888.000000) t) | 3@@list("C1207" "TX_C0402" list(3628.000000 1273.000000) t) | 3@@list("C1604" "TX_C0402" list(4389.510000 1249.010000) t) | 3@@list("C1607" "TX_C0603_T02_H39" list(4974.000000 1331.000000) t) | 3@@list("C1609" "TX_C0603_T02_H39" list(5087.000000 1419.800000) t) | 3@@list("C1610" "TX_C0402" list(4946.000000 1439.500000) t) | 3@@list("C1616" "TX_C0603_T02_H39" list(5012.620000 1528.000000) t) | 3@@list("C1617" "TX_C0402" list(3715.000000 1452.000000) t) | 3@@list("C1627" "TX_C0603_T02_H39" list(5234.000000 1490.000000) t) | 3@@list("C1628" "TX_C0603_T02_H39" list(4238.000000 1036.000000) t) | 3@@list("C1631" "TX_C0402" list(4344.000000 1195.000000) t) | 3@@list("C1633" "TX_C0603_T02_H39" list(4281.000000 1264.000000) t) | 3@@list("C1634" "TX_C0603_T02_H39" list(4562.000000 1369.000000) t) | 3@@list("C1900" "TX_C0402" list(3909.000000 962.000000) t) | 3@@list("C1901" "TX_C0402" list(509.000000 2190.000000) t) | 3@@list("C1902" "TX_C0402" list(568.000000 1962.000000) t) | 3@@list("C2900" "TX_C0402" list(653.000000 2729.200000) t) | 3@@list("C2901" "TX_C0402" list(656.000000 2912.000000) t) | 3@@list("C2902" "TX_C0402" list(654.000000 2632.200000) t) | 3@@list("C2903" "TX_C0402" list(654.000000 2596.000000) t) | 3@@list("C2904" "TX_C0402" list(622.000000 2822.000000) t) | 3@@list("C2905" "TX_C0402" list(656.000000 2875.800000) t) | 3@@list("C2906" "TX_C0402" list(653.000000 2693.000000) t) | 3@@list("C2907" "TX_C0402" list(622.000000 2785.800000) t) | 3@@list("C3000" "TX_C0402_T02_H26" list(1784.000000 4126.000000) t) | 3@@list("C3001" "TX_C0402" list(2184.500000 4125.500000) t) | 3@@list("C3002" "TX_C0402" list(2146.000000 4106.000000) t) | 3@@list("C3004" "TX_C0402" list(2540.000000 4152.600000) t) | 3@@list("C3005" "TX_C0402" list(2502.000000 4152.600000) t) | 3@@list("C3006" "TX_C0402" list(2465.000000 4101.100000) t) | 3@@list("C3007" "TX_C0402" list(2428.800000 4101.100000) t) | 3@@list("C3008" "TX_C0402" list(2352.000000 4138.600000) t) | 3@@list("C3009" "TX_C0402" list(2388.200000 4138.600000) t) | 3@@list("C3010" "TX_C0402" list(1525.000000 4151.000000) t) | 3@@list("C3011" "TX_C0402" list(2230.000000 4121.000000) t) | 3@@list("C3104" "TX_C0402" list(8142.000000 995.000000) t) | 3@@list("C3105" "TX_C0402" list(8136.000000 958.900000) t) | 3@@list("C3106" "TX_C0402" list(8199.000000 943.000000) t) | 3@@list("C3107" "TX_C0402" list(8197.000000 907.000000) t) | 3@@list("C3120" "TX_C0402" list(4579.000000 811.000000) t) | 3@@list("C3121" "TX_C0402" list(4578.790000 775.000000) t) | 3@@list("C3122" "TX_C0402" list(4579.000000 738.210000) t) | 3@@list("C3123" "TX_C0402" list(4579.000000 702.000000) t) | 3@@list("C3124" "TX_C0603_T02_H39" list(4127.000000 894.000000) t) | 3@@list("C3125" "TX_C0402" list(4189.000000 926.000000) t) | 3@@list("C3127" "TX_C0603_T02_H39" list(4075.000000 894.000000) t) | 3@@list("C3600" "TX_C0402" list(8012.000000 3624.000000) t) | 3@@list("C3601" "TX_C0402" list(8012.000000 3662.000000) t) | 3@@list("C3602" "TX_C0402" list(7880.000000 2730.000000) t) | 3@@list("C3603" "TX_C0402" list(8012.000000 3741.000000) t) | 3@@list("C3604" "TX_C0402" list(5381.780000 995.000000) t) | 3@@list("C3700" "TX_C0402" list(4763.000000 3775.000000) t) | 3@@list("C3706" "TX_C0402" list(7836.000000 4425.000000) t) | 3@@list("C3800" "TX_C0402_T02_H28" list(649.180000 1481.150000) t) | 3@@list("C3802" "TX_C0402_T02_H28" list(497.000000 1191.000000) t) | 3@@list("C3803" "TX_C0402" list(509.000000 1229.000000) t) | 3@@list("C3808" "TX_C0805_T02_H55" list(335.000000 1843.000000) t) | 3@@list("C3809" "TX_C0805_T02_H55" list(261.000000 1843.000000) t) | 3@@list("C3810" "TX_C0402" list(12.500000 1816.000000) t) | 3@@list("C3811" "TX_C0402" list(-10.000000 2380.000000) t) | 3@@list("C3812" "TX_C0402" list(359.500000 2207.500000) t) | 3@@list("C3813" "TX_C0402" list(254.000000 2384.000000) t) | 3@@list("C3814" "TX_C0402" list(632.000000 1290.000000) t) | 3@@list("C3815" "TX_C0402_T02_H28" list(244.780000 1422.210000) t) | 3@@list("C3816" "TX_C0402" list(683.060000 1316.020000) t) | 3@@list("C3819" "TX_C0402_T02_H28" list(341.500000 1606.500000) t) | 3@@list("C3820" "TX_C0402" list(364.000000 1660.000000) t) | 3@@list("C3822" "TX_C0402" list(341.460000 1567.660000) t) | 3@@list("C3825" "TX_C0402_T02_H28" list(335.460000 1214.950000) t) | 3@@list("C3826" "TX_C0402" list(374.280000 1214.950000) t) | 3@@list("C3827" "TX_C0402_T02_H28" list(462.080000 1666.830000) t) | 3@@list("C3828" "TX_C0402" list(424.080000 1666.830000) t) | 3@@list("C3829" "TX_C0402_T02_H28" list(298.320000 1660.000000) t) | 3@@list("C3830" "TX_C0402" list(232.000000 1302.000000) t) | 3@@list("C3831" "TX_C0402" list(290.000000 1279.000000) t) | 3@@list("C3833" "TX_C0402" list(648.070000 1563.620000) t) | 3@@list("C3834" "TX_C0402" list(262.000000 1169.000000) t) | 3@@list("C3839" "TX_C0402" list(649.180000 1443.130000) t) | 3@@list("C3840" "TX_C0402" list(647.710000 1602.370000) t) | 3@@list("C3841" "TX_C0402" list(356.000000 2430.000000) t) | 3@@list("C3842" "TX_C0402" list(89.000000 2426.000000) t) | 3@@list("C3843" "TX_C0402" list(262.000000 1103.000000) t) | 3@@list("C5100" "TX_C0402" list(3036.170000 809.090000) t) | 3@@list("C5101" "TX_C0402" list(3108.350000 809.010000) t) | 3@@list("C5102" "TX_C0402" list(3072.170000 809.090000) t) | 3@@list("C5103" "TX_C0402" list(2962.350000 805.010000) t) | 3@@list("C5104" "TX_C0402" list(3180.350000 809.010000) t) | 3@@list("C5105" "TX_C0402" list(2345.360000 838.690000) t) | 3@@list("C5106" "TX_C0402" list(3217.170000 809.090000) t) | 3@@list("C5107" "TX_C0402" list(2382.360000 838.690000) t) | 3@@list("C5108" "TX_C0402" list(2495.360000 837.690000) t) | 3@@list("C5109" "TX_C0402" list(3144.350000 809.010000) t) | 3@@list("C5110" "TX_C0402" list(2418.360000 837.690000) t) | 3@@list("C5117" "TX_C0402" list(2569.360000 837.690000) t) | 3@@list("C5121" "TX_C0402" list(2454.360000 837.690000) t) | 3@@list("C5122" "TX_C0402" list(2533.360000 837.690000) t) | 3@@list("C5123" "TX_C0402" list(2606.360000 837.690000) t) | 3@@list("C5124" "TX_C0402" list(7767.380000 2154.520000) t) | 3@@list("C5125" "TX_C0402" list(6581.380000 1022.520000) t) | 3@@list("C5132" "TX_C0402" list(2999.170000 805.090000) t) | 3@@list("C5133" "TX_C0402" list(7802.000000 1495.000000) t) | 3@@list("C5134" "TX_C0402" list(7802.000000 1531.000000) t) | 3@@list("C5135" "TX_C0402" list(7317.000000 1144.000000) t) | 3@@list("C5136" "TX_C0402" list(7280.000000 1144.000000) t) | 3@@list("C5300" "TX_C0402" list(3650.000000 4582.550000) t) | 3@@list("C5723" "TX_C0603_T02_H39" list(290.000000 3684.000000) t) | 3@@list("C5724" "TX_C0402" list(462.000000 3292.000000) t) | 3@@list("C5808" "TX_C0402" list(472.000000 2978.000000) t) | 3@@list("C5809" "TX_C0402" list(340.000000 3216.000000) t) | 3@@list("C5810" "TX_C0402" list(683.000000 3002.000000) t) | 3@@list("C5900" "TX_C0603_T02_H39" list(343.000000 3688.000000) t) | 3@@list("C5903" "TX_C0603_T02_H39" list(275.000000 3907.000000) t) | 3@@list("C5905" "TX_C0402" list(615.000000 3762.000000) t) | 3@@list("C5907" "TX_C0603_T02_H39" list(514.000000 3975.000000) t) | 3@@list("C5908" "TX_C0603_T02_H39" list(621.000000 3975.000000) t) | 3@@list("C5909" "TX_C0603_T02_H39" list(674.000000 3870.000000) t) | 3@@list("C5910" "TX_C0603_T02_H39" list(567.000000 3975.000000) t) | 3@@list("C5911" "TX_C0603_T02_H39" list(620.000000 3870.000000) t) | 3@@list("C5913" "TX_C0603_T02_H39" list(674.000000 3975.000000) t) | 3@@list("C6008" "TX_C0402" list(5865.000000 4340.000000) t) | 3@@list("C6009" "TX_C0402" list(5902.000000 4340.000000) t) | 3@@list("C6010" "TX_C0402" list(5940.000000 4340.000000) t) | 3@@list("C6011" "TX_C0402" list(5978.000000 4340.000000) t) | 3@@list("C6012" "TX_C0402" list(6014.990000 4340.010000) t) | 3@@list("C6013" "TX_C0402" list(6052.010000 4340.020000) t) | 3@@list("C6014" "TX_C0402" list(6089.000000 4340.000000) t) | 3@@list("C6015" "TX_C0402" list(6126.000000 4340.000000) t) | 3@@list("C6016" "TX_C0402" list(5303.000000 3694.000000) t) | 3@@list("C6200" "TX_C0402" list(5588.500000 3861.490000) t) | 3@@list("C6301" "TX_C0402" list(6453.000000 4361.000000) t) | 3@@list("C6302" "TX_C0402" list(6268.000000 4364.000000) t) | 3@@list("C6600" "TX_C0402" list(7052.000000 4348.000000) t) | 3@@list("C6601" "TX_C0402" list(7057.000000 3962.000000) t) | 3@@list("C6602" "TX_C0402" list(7680.000000 4316.000000) t) | 3@@list("C6603" "TX_C0402" list(7680.000000 3907.000000) t) | 3@@list("C6604" "TX_C0402" list(7511.680000 4452.000000) t) | 3@@list("C6605" "TX_C0402" list(7052.000000 3612.000000) t) | 3@@list("C6606" "TX_C0402" list(7058.000000 3260.000000) t) | 3@@list("C6607" "TX_C0402" list(7678.000000 3533.000000) t) | 3@@list("C6608" "TX_C0402" list(7680.000000 3171.000000) t) | 3@@list("C6609" "TX_C0402" list(7385.000000 3075.000000) t) | 3@@list("C6610" "TX_C0402" list(7053.000000 4385.000000) t) | 3@@list("C6611" "TX_C0402" list(7680.000000 4355.000000) t) | 3@@list("C6612" "TX_C0402" list(7057.000000 3925.000000) t) | 3@@list("C6613" "TX_C0402" list(7680.000000 3866.000000) t) | 3@@list("C6614" "TX_C0402_T02_H28" list(7678.000000 3609.000000) t) | 3@@list("C6630" "TX_C0402" list(7678.000000 3570.000000) t) | 3@@list("C6631" "TX_C0402" list(7680.000000 3134.000000) t) | 3@@list("C6634" "TX_C0402" list(7062.000000 3172.000000) t) | 3@@list("C6635" "TX_C0402" list(7052.000000 3650.000000) t) | 3@@list("C6801" "TX_C0402" list(7048.000000 4128.000000) t) | 3@@list("C6803" "TX_C0402" list(7683.000000 3367.000000) t) | 3@@list("C6900" "TX_C0402" list(5625.500000 3747.000000) t) | 3@@list("C6901" "TX_C0402" list(5589.000000 3663.000000) t) | 3@@list("C7001" "TX_C0402" list(7321.000000 4634.000000) t) | 3@@list("C7005" "TX_C0402" list(7304.000000 4520.000000) t) | 3@@list("C7006" "TX_C0402" list(7343.000000 4520.000000) t) | 3@@list("C7007" "TX_C0402" list(7078.000000 4597.000000) t) | 3@@list("C7008" "TX_C0402" list(7078.000000 4560.000000) t) | 3@@list("CON3100" "TX_NGFF_67P_20_4HOLD_ARG" list(8498.910000 710.590000) t) | 3@@list("CON3101" "TX_FPC_12P_20_2H_RA_ACES_B" list(4294.180000 694.840000) t) | 3@@list("D3000" "TX_SOT23_2D4_H43" list(3034.000000 4191.000000) t) | 3@@list("D3001" "TX_ESD_2P_33_39X24_H24" list(2000.000000 4134.000000) t) | 3@@list("D3002" "TX_ESD_2P_33_39X24_H24" list(2069.000000 4134.000000) t) | 3@@list("D3601" "TX_ESD_2P_33_39X24_COLAY" list(5084.000000 973.000000) t) | 3@@list("D3602" "TX_ESD_2P_33_39X24_COLAY" list(5173.780000 973.000000) t) | 3@@list("D3603" "TX_ESD_2P_33_39X24_COLAY" list(5304.000000 983.000000) t) | 3@@list("D3800" "TX_ESD_2P_33_39X24_H24" list(-41.000000 1719.000000) t) | 3@@list("D3801" "TX_ESD_2P_33_39X24_H24" list(-51.000000 2380.000000) t) | 3@@list("D3802" "TX_ESD_2P_33_39X24_H24" list(376.820000 2310.630000) t) | 3@@list("D3803" "TX_ESD_2P_33_39X24_H24" list(218.000000 2423.000000) t) | 3@@list("D3804" "TX_ESD_2P_33_39X24_COLAY" list(541.000000 1691.000000) t) | 3@@list("D3805" "TX_SOT23_2D4_H43" list(1734.000000 772.000000) t) | 3@@list("D3806" "TX_ESD_2P_33_39X24_H24" list(407.220000 1807.000000) t) | 3@@list("D3807" "TX_SOT323" list(616.030000 1788.290000) t) | 3@@list("D5700" "TX_ESD_2P_33_39X24_H24" list(271.000000 3494.000000) t) | 3@@list("D5701" "TX_ESD_2P_33_39X24_H24" list(271.000000 3563.000000) t) | 3@@list("D5705" "TX_ESD_2P_33_39X24_H24" list(303.000000 3435.000000) t) | 3@@list("D5706" "TX_ESD_2P_33_39X24_H24" list(303.000000 3381.000000) t) | 3@@list("D5708" "TX_DFN1006_2P_43X28_WIL" list(274.200000 3830.500000) t) | 3@@list("D5709" "TX_DFN1006_2P_43X28_WIL" list(274.200000 3766.500000) t) | 3@@list("D5800" "TX_SOT23_2D4_H43" list(575.000000 3216.000000) t) | 3@@list("L2600" "TX_CHOKE_4P_49X39_MURA" list(451.000000 2799.000000) t) | 3@@list("L2601" "TX_CHOKE_4P_49X39_MURA" list(450.000000 2716.000000) t) | 3@@list("L2602" "TX_CHOKE_4P_49X39_MURA" list(450.000000 2625.000000) t) | 3@@list("L2603" "TX_CHOKE_4P_49X39_MURA" list(450.000000 2889.000000) t) | 3@@list("L3601" "TX_L0603_T015" list(4872.100000 996.000000) t) | 3@@list("L3602" "TX_L0603_T015" list(4936.100000 997.000000) t) | 3@@list("L3603" "TX_L0603_T015" list(5004.100000 997.000000) t) | 3@@list("L3801" "TX_L0603_T02_H37" list(345.310000 2141.200000) t) | 3@@list("L3802" "TX_L0603_T02_H37" list(57.800000 2367.810000) t) | 3@@list("L3803" "TX_L0603_T02_H37" list(321.800000 2368.310000) t) | 3@@list("L3804" "TX_L0603_T02_H37" list(22.440000 1861.000000) t) | 3@@list("L3806" "TX_L0603_T015" list(402.470000 1724.240000) t) | 3@@list("L5700" "TX_CHOKE_4P_49X39_MURA" list(365.000000 3523.000000) t) | 3@@list("PC7601" "TX_C0603" list(1501.000000 4196.000000) t) | 3@@list("PC7605" "TX_C0805_T02_H57" list(994.000000 4102.000000) t) | 3@@list("PC7608" "TX_C0402" list(582.000000 2525.000000) t) | 3@@list("PC7700" "TX_C0805_T02_H57" list(7180.000000 1194.900000) t) | 3@@list("PC7701" "TX_C0805_T02_H57" list(7180.000000 1335.300000) t) | 3@@list("PC7702" "TX_C0805_T02_H57" list(7180.000000 1265.100000) t) | 3@@list("PC7703" "TX_C0805_T02_H57" list(7180.000000 1124.200000) t) | 3@@list("PC7704" "TX_C0805_T02_H57" list(6123.000000 1362.000000) t) | 3@@list("PC7705" "TX_C0805_T02_H57" list(6195.000000 1545.000000) t) | 3@@list("PC7706" "TX_C0805_T02_H57" list(6051.000000 1367.000000) t) | 3@@list("PC7707" "TX_C0805_T02_H57" list(5956.000000 1307.000000) t) | 3@@list("PC7708" "TX_C0402_T02_H26" list(7359.000000 1313.000000) t) | 3@@list("PC7709" "TX_C0603_T015_H37" list(7289.000000 1341.300000) t) | 3@@list("PC7710" "TX_C0603_T015_H37" list(7284.800000 1252.000000) t) | 3@@list("PC7711" "TX_C0603" list(7364.000000 1236.000000) t) | 3@@list("PC7712" "TX_C0603_T015_H37" list(7376.000000 1409.000000) t) | 3@@list("PC7713" "TX_C0402_T02_H26" list(7441.000000 1415.000000) t) | 3@@list("PC7714" "TX_C0402_T02_H26" list(7372.500000 1127.000000) t) | 3@@list("PC7715" "TX_C0603" list(7450.500000 1130.140000) t) | 3@@list("PC7716" "TX_C0402" list(7479.800000 1415.000000) t) | 3@@list("PC7717" "TX_C0603_T015_H37" list(7695.000000 1097.000000) t) | 3@@list("PC7718" "TX_C0402" list(7612.500000 1134.000000) t) | 3@@list("PC7719" "TX_C0603" list(7695.000000 1148.000000) t) | 3@@list("PC7720" "TX_C0805_T02_H57" list(5852.000000 1205.000000) t) | 3@@list("PC7721" "TX_C0402" list(7691.000000 1410.000000) t) | 3@@list("PC7722" "TX_C0402" list(5701.720000 1172.000000) t) | 3@@list("PC7723" "TX_C0402" list(7756.000000 1292.000000) t) | 3@@list("PC7800" "TX_C0402" list(6739.500000 2373.000000) t) | 3@@list("PC7801" "TX_C0402" list(6495.000000 2166.000000) t) | 3@@list("PC7802" "TX_C0603" list(6405.000000 2168.290000) t) | 3@@list("PC7803" "TX_C0402" list(6739.000000 2409.500000) t) | 3@@list("PC7804" "TX_C0603" list(6495.000000 2109.000000) t) | 3@@list("PC7805" "TX_C0402" list(6746.500000 2332.000000) t) | 3@@list("PC7806" "TX_C0402" list(6820.000000 2406.000000) t) | 3@@list("PC7812" "TX_C0402" list(6610.000000 2353.000000) t) | 3@@list("PC7814" "TX_C0402" list(6850.000000 2198.000000) t) | 3@@list("PC7815" "TX_C0402" list(6618.500000 2503.000000) t) | 3@@list("PC7816" "TX_C0402" list(6919.000000 2234.000000) t) | 3@@list("PC7817" "TX_C0402" list(6724.000000 2585.000000) t) | 3@@list("PC7818" "TX_C0402" list(6827.000000 2118.000000) t) | 3@@list("PC7820" "TX_C0402" list(6669.000000 2442.000000) t) | 3@@list("PC7822" "TX_C0402" list(6932.000000 2178.500000) t) | 3@@list("PC7823" "TX_C0402" list(6689.000000 2353.500000) t) | 3@@list("PC7831" "TX_C0402" list(6716.000000 2010.000000) t) | 3@@list("PC7833" "TX_C0402" list(6516.000000 1999.000000) t) | 3@@list("PC7834" "TX_C0402" list(6679.900000 2010.000000) t) | 3@@list("PC7835" "TX_C0402" list(6770.000000 2010.000000) t) | 3@@list("PC7837" "TX_C0402" list(6590.000000 1985.000000) t) | 3@@list("PC7838" "TX_C0402" list(6625.000000 1935.000000) t) | 3@@list("PC7839" "TX_C0402" list(6829.000000 2480.000000) t) | 3@@list("PC7840" "TX_C0402" list(6792.160000 2479.880000) t) | 3@@list("PC7841" "TX_C0402" list(6673.000000 2524.500000) t) | 3@@list("PC7900" "TX_C0402_T02_H26" list(6050.000000 1904.000000) t) | 3@@list("PC7901" "TX_C0805_T02_H57" list(5825.060000 1994.000000) t) | 3@@list("PC7902" "TX_C0805_T02_H57" list(5825.060000 1924.000000) t) | 3@@list("PC7903" "TX_C0402" list(5944.000000 2195.000000) t) | 3@@list("PC7904" "TX_C0603" list(6001.060000 2033.000000) t) | 3@@list("PC7905" "TX_C0402" list(5675.060000 2002.000000) t) | 3@@list("PC7906" "TX_C0805_T02_H57" list(5943.000000 2342.000000) t) | 3@@list("PC7907" "TX_C0805_T02_H57" list(5786.000000 2552.000000) t) | 3@@list("PC7908" "TX_C0805_T02_H57" list(5786.000000 2481.000000) t) | 3@@list("PC7909" "TX_C0402_T02_H26" list(6138.060000 2307.000000) t) | 3@@list("PC7910" "TX_C0402" list(5949.060000 2737.000000) t) | 3@@list("PC7911" "TX_C0603" list(6003.000000 2409.000000) t) | 3@@list("PC7912" "TX_C0402" list(5693.000000 2566.000000) t) | 3@@list("PC7913" "TX_C0805_T02_H57" list(5949.000000 1953.000000) t) | 3@@list("PC8000" "TX_C0603" list(5606.000000 1504.000000) t) | 3@@list("PC8001" "TX_C0805_T02_H57" list(5945.060000 1661.000000) t) | 3@@list("PC8002" "TX_C0402_T02_H26" list(5418.000000 1385.000000) t) | 3@@list("PC8003" "TX_C0805_T02_H57" list(5945.000000 1732.000000) t) | 3@@list("PC8005" "TX_C0402" list(5777.000000 1617.000000) t) | 3@@list("PC8006" "TX_C0402_T02_H26" list(6160.000000 2708.000000) t) | 3@@list("PC8007" "TX_C0805_T02_H57" list(5948.060000 2871.000000) t) | 3@@list("PC8008" "TX_C0805_T02_H57" list(5805.060000 2926.000000) t) | 3@@list("PC8009" "TX_C0805_T02_H57" list(5805.060000 2856.000000) t) | 3@@list("PC8010" "TX_C0402" list(5927.060000 3142.000000) t) | 3@@list("PC8011" "TX_C0603" list(6029.560000 2817.000000) t) | 3@@list("PC8105" "TX_C0603_T02_H39" list(5247.000000 2449.000000) t) | 3@@list("PC8106" "TX_C0603_T02_H39" list(5247.000000 1982.000000) t) | 3@@list("PC8123" "TX_C0603_T02_H39" list(5253.000000 2826.000000) t) | 3@@list("PC8140" "TX_C0603_T02_H39" list(4339.000000 3549.000000) t) | 3@@list("PC8147" "TX_C0603_T02_H39" list(4812.000000 3412.000000) t) | 3@@list("PC8148" "TX_C0603_T02_H39" list(4564.000000 3358.000000) t) | 3@@list("PC8149" "TX_C0603_T02_H39" list(4674.000000 3305.000000) t) | 3@@list("PC8151" "TX_C0603_T02_H39" list(4866.000000 3412.000000) t) | 3@@list("PC8152" "TX_C0603_T02_H39" list(4577.000000 3595.000000) t) | 3@@list("PC8156" "TX_C0603_T02_H39" list(4673.000000 3414.000000) t) | 3@@list("PC8162" "TX_C0603_T02_H39" list(5316.060000 1623.000000) t) | 3@@list("PC8164" "TX_C0603_T02_H39" list(4338.060000 3604.000000) t) | 3@@list("PC8166" "TX_C0603_T02_H39" list(4564.000000 3412.000000) t) | 3@@list("PC8167" "TX_C0603_T02_H39" list(4756.000000 3412.000000) t) | 3@@list("PC8176" "TX_C0603_T02_H39" list(4564.000000 3305.000000) t) | 3@@list("PC8177" "TX_C0603_T02_H39" list(4674.000000 3360.000000) t) | 3@@list("PC8184" "TX_C0603_T02_H39" list(4339.000000 3494.000000) t) | 3@@list("PC8187" "TX_C0603_T02_H39" list(4479.000000 3595.000000) t) | 3@@list("PC8602" "TX_C0805_T02_H57" list(3034.000000 4359.000000) t) | 3@@list("PC8603" "TX_C0805_T02_H57" list(3034.000000 4289.000000) t) | 3@@list("PC8606" "TX_C0402" list(3084.000000 4628.000000) t) | 3@@list("PC8607" "TX_C0402" list(3084.000000 4591.000000) t) | 3@@list("PC8608" "TX_C0402_T02_H28" list(3458.000000 4531.000000) t) | 3@@list("PC8617" "TX_C0603_T02_H39" list(3659.000000 4092.000000) t) | 3@@list("PC8618" "TX_C0603_T02_H39" list(3683.000000 4309.500000) t) | 3@@list("PC8619" "TX_C0603_T02_H39" list(3658.500000 4201.000000) t) | 3@@list("PC8620" "TX_C0603_T02_H39" list(3683.000000 4255.500000) t) | 3@@list("PC8622" "TX_C0402" list(2944.000000 4344.000000) t) | 3@@list("PC8700" "TX_C0805_T02_H57" list(6806.000000 1643.000000) t) | 3@@list("PC8701" "TX_C0603_T02_H39" list(6650.000000 1492.000000) t) | 3@@list("PC8702" "TX_C0603_T02_H39" list(6240.000000 2060.000000) t) | 3@@list("PC8703" "TX_C0603_T02_H39" list(6240.000000 2113.000000) t) | 3@@list("PC8704" "TX_C0402" list(6645.000000 1414.000000) t) | 3@@list("PC8705" "TX_C0402" list(6732.000000 1558.000000) t) | 3@@list("PC8706" "TX_C0402" list(6575.000000 1776.500000) t) | 3@@list("PC8707" "TX_C0603_T02_H39" list(6169.000000 2241.000000) t) | 3@@list("PC8708" "TX_C0603_T02_H39" list(6331.000000 2073.000000) t) | 3@@list("PC8709" "TX_C0603" list(6503.000000 1861.000000) t) | 3@@list("PC8710" "TX_C0603_T02_H39" list(6669.000000 1563.500000) t) | 3@@list("PC8711" "TX_C0603_T02_H39" list(6335.000000 2177.000000) t) | 3@@list("PC8712" "TX_C0603_T02_H39" list(6240.000000 2166.000000) t) | 3@@list("PC8713" "TX_C0402" list(6724.000000 1789.500000) t) | 3@@list("PC8714" "TX_C0805_T02_H57" list(6877.000000 1643.000000) t) | 3@@list("PC8715" "TX_C0402" list(6931.000000 1657.000000) t) | 3@@list("PC8800" "TX_C0805_T02_H57" list(1523.000000 1007.000000) t) | 3@@list("PC8804" "TX_C0603_T02_H39" list(1807.000000 1066.000000) t) | 3@@list("PC8805" "TX_C0603_T02_H39" list(1754.000000 1066.000000) t) | 3@@list("PC8806" "TX_C0603_T02_H39" list(1688.000000 901.000000) t) | 3@@list("PC8807" "TX_C0603_T02_H39" list(3699.500000 4624.000000) t) | 3@@list("PC8808" "TX_C0402" list(4003.000000 4754.000000) t) | 3@@list("PC8809" "TX_C0603_T02_H39" list(3673.000000 4728.000000) t) | 3@@list("PC8812" "TX_C0402" list(4168.000000 4695.000000) t) | 3@@list("PC8813" "TX_C0805_T02_H57" list(4204.000000 4627.000000) t) | 3@@list("PC8900" "TX_C0402" list(7510.000000 2548.000000) t) | 3@@list("PC8901" "TX_C0402" list(7627.000000 2720.000000) t) | 3@@list("PC8902" "TX_C0402" list(7682.000000 2720.000000) t) | 3@@list("PC8903" "TX_C0402" list(7674.000000 2451.500000) t) | 3@@list("PC8904" "TX_C0402" list(7856.630000 2613.140000) t) | 3@@list("PC8905" "TX_C0805_T02_H57" list(6837.480000 1898.000000) t) | 3@@list("PC8906" "TX_C0805_T02_H57" list(6767.380000 1898.500000) t) | 3@@list("PC8907" "TX_C0402" list(7136.000000 1872.000000) t) | 3@@list("PC8908" "TX_C0402" list(7104.000000 2113.000000) t) | 3@@list("PC8909" "TX_C0402_T02_H28" list(7740.000000 1760.000000) t) | 3@@list("PC8910" "TX_C0402" list(7018.600000 2012.400000) t) | 3@@list("PC8911" "TX_C0402" list(7742.870000 2739.530000) t) | 3@@list("PC8912" "TX_C0402" list(7710.500000 2451.500000) t) | 3@@list("PC8913" "TX_C0402" list(7852.000000 2446.500000) t) | 3@@list("PC8914" "TX_C0805_T02_H57" list(7296.000000 2246.000000) t) | 3@@list("PC8915" "TX_C0805_T02_H57" list(7221.000000 2246.000000) t) | 3@@list("PC8916" "TX_C0402" list(7423.000000 2330.000000) t) | 3@@list("PC8917" "TX_C0402" list(7801.000000 2522.000000) t) | 3@@list("PC8918" "TX_C0402" list(7330.000000 2650.000000) t) | 3@@list("PC8919" "TX_C0402_T02_H28" list(6801.000000 2570.000000) t) | 3@@list("PC8920" "TX_C0402" list(7414.000000 2451.000000) t) | 3@@list("PC8922" "TX_C0402" list(7637.500000 2452.000000) t) | 3@@list("PC8923" "TX_C0402" list(7545.000000 2443.000000) t) | 3@@list("PC8924" "TX_C0805_T02_H57" list(6697.380000 1898.500000) t) | 3@@list("PC8925" "TX_C0805_T02_H57" list(6907.480000 1898.000000) t) | 3@@list("PC9100" "TX_C0402" list(6962.000000 779.000000) t) | 3@@list("PC9101" "TX_C0402" list(6876.500000 711.000000) t) | 3@@list("PC9102" "TX_C0402" list(6864.000000 923.000000) t) | 3@@list("PC9103" "TX_C0402" list(6962.000000 842.000000) t) | 3@@list("PC9104" "TX_C0402" list(6763.000000 757.300000) t) | 3@@list("PC9105" "TX_C0402" list(6827.000000 923.000000) t) | 3@@list("PC9107" "TX_C0402" list(7615.000000 2382.000000) t) | 3@@list("PC9108" "TX_C0402" list(7761.000000 2338.000000) t) | 3@@list("PC9109" "TX_C0402" list(7680.000000 2382.000000) t) | 3@@list("PC9110" "TX_C0402" list(7520.000000 2218.000000) t) | 3@@list("PC9111" "TX_C0402" list(7520.000000 2326.000000) t) | 3@@list("PC9112" "TX_C0402" list(7761.000000 2301.000000) t) | 3@@list("PC9113" "TX_C0402" list(7761.000000 2264.000000) t) | 3@@list("PC9114" "TX_C0402" list(6760.000000 840.000000) t) | 3@@list("PC9200" "TX_C0402" list(5337.000000 1125.000000) t) | 3@@list("PC9201" "TX_C0402" list(5131.000000 1211.800000) t) | 3@@list("PC9202" "TX_C0402" list(5213.000000 1092.000000) t) | 3@@list("PC9203" "TX_C0402" list(5230.000000 1288.000000) t) | 3@@list("PC9204" "TX_C0402" list(5131.000000 1175.300000) t) | 3@@list("PC9206" "TX_C0402" list(5294.000000 1288.000000) t) | 3@@list("PC9402" "TX_C0402" list(3890.000000 4008.000000) t) | 3@@list("PC9403" "TX_C0402" list(4276.500000 4429.000000) t) | 3@@list("PC9404" "TX_C0402" list(4174.000000 4430.000000) t) | 3@@list("PC9405" "TX_C0402" list(4030.000000 4255.000000) t) | 3@@list("PC9406" "TX_C0402" list(4421.000000 4290.000000) t) | 3@@list("PC9407" "TX_C0402" list(4397.000000 4240.000000) t) | 3@@list("PC9409" "TX_C0402" list(4430.000000 4157.000000) t) | 3@@list("PC9410" "TX_C0402" list(4051.000000 3980.500000) t) | 3@@list("PC9411" "TX_C0402" list(4083.000000 3897.000000) t) | 3@@list("PC9412" "TX_C0402" list(4175.000000 4057.000000) t) | 3@@list("PC9413" "TX_C0402" list(4307.000000 4358.000000) t) | 3@@list("PC9414" "TX_C0402" list(3972.000000 3897.000000) t) | 3@@list("PC9415" "TX_C0402" list(4238.380000 4036.870000) t) | 3@@list("PC9416" "TX_C0402" list(4260.500000 3987.000000) t) | 3@@list("PC9417" "TX_C0402" list(4342.000000 3897.000000) t) | 3@@list("PC9418" "TX_C0402" list(4231.000000 3897.000000) t) | 3@@list("PC9419" "TX_C0402" list(4416.000000 3897.000000) t) | 3@@list("PC9420" "TX_C0402" list(3889.000000 4301.000000) t) | 3@@list("PC9421" "TX_C0402" list(5522.000000 3485.000000) t) | 3@@list("PC9422" "TX_C0402" list(5586.000000 3448.000000) t) | 3@@list("PC9423" "TX_C0402" list(5522.500000 3337.500000) t) | 3@@list("PC9424" "TX_C0402" list(4088.000000 3978.500000) t) | 3@@list("PC9425" "TX_C0402" list(4175.000000 4020.000000) t) | 3@@list("PC9500" "TX_C0603_T02_H39" list(6240.000000 2698.000000) t) | 3@@list("PC9501" "TX_C0603_T02_H39" list(6240.000000 2750.000000) t) | 3@@list("PC9502" "TX_C0402" list(6228.000000 2795.000000) t) | 3@@list("PC9503" "TX_C0603_T02_H39" list(6142.000000 3093.000000) t) | 3@@list("PC9504" "TX_C0603_T02_H39" list(6215.000000 3063.000000) t) | 3@@list("PC9505" "TX_C0402" list(6082.000000 3067.000000) t) | 3@@list("PC9506" "TX_C0603" list(6334.000000 2863.000000) t) | 3@@list("PC9508" "TX_C0402" list(6391.000000 2821.000000) t) | 3@@list("PC9509" "TX_C0603_T02_H39" list(6643.500000 4656.000000) t) | 3@@list("PC9510" "TX_C0603_T02_H39" list(6696.000000 4656.000000) t) | 3@@list("PC9511" "TX_C0402" list(6598.000000 4662.000000) t) | 3@@list("PC9512" "TX_C0603_T02_H39" list(6393.000000 4617.000000) t) | 3@@list("PC9513" "TX_C0603_T02_H39" list(6362.000000 4462.000000) t) | 3@@list("PC9514" "TX_C0402" list(6229.000000 4646.000000) t) | 3@@list("PC9517" "TX_C0402" list(6342.000000 4710.000000) t) | 3@@list("PC9518" "TX_C0603_T02_H39" list(6341.000000 4617.000000) t) | 3@@list("PC9600" "TX_C0805_T02_H57" list(4711.000000 4296.000000) t) | 3@@list("PC9601" "TX_C0805_T02_H57" list(4781.000000 4296.000000) t) | 3@@list("PC9602" "TX_C0402" list(4846.000000 4052.000000) t) | 3@@list("PC9603" "TX_C0402_T02_H28" list(5073.000000 4736.000000) t) | 3@@list("PC9605" "TX_C0402" list(5094.000000 4078.200000) t) | 3@@list("PC9606" "TX_C0603_T02_H39" list(5524.000000 3992.000000) t) | 3@@list("PC9607" "TX_C0603_T02_H39" list(5599.000000 4387.000000) t) | 3@@list("PC9608" "TX_C0603_T02_H39" list(5599.000000 4334.000000) t) | 3@@list("PC9609" "TX_C0603_T02_H39" list(5793.000000 4387.000000) t) | 3@@list("PC9610" "TX_C0603_T02_H39" list(5793.000000 4334.000000) t) | 3@@list("PC9611" "TX_C0603_T02_H39" list(5419.000000 3992.000000) t) | 3@@list("PC9612" "TX_C0603_T02_H39" list(5599.000000 4172.000000) t) | 3@@list("PC9613" "TX_C0603_T02_H39" list(5599.000000 4279.000000) t) | 3@@list("PC9614" "TX_C0603_T02_H39" list(5365.000000 3992.000000) t) | 3@@list("PC9615" "TX_C0805_T02_H57" list(4407.000000 4640.000000) t) | 3@@list("PC9616" "TX_C0805_T02_H57" list(4477.500000 4640.000000) t) | 3@@list("PC9617" "TX_C0603_T02_H39" list(5599.000000 4066.000000) t) | 3@@list("PC9618" "TX_C0603_T02_H39" list(5689.000000 4387.000000) t) | 3@@list("PC9619" "TX_C0603_T02_H39" list(5577.000000 3992.000000) t) | 3@@list("PC9620" "TX_C0603_T02_H39" list(5689.000000 4334.000000) t) | 3@@list("PC9621" "TX_C0603_T02_H39" list(5598.500000 4119.000000) t) | 3@@list("PC9622" "TX_C0603_T02_H39" list(5599.000000 4226.000000) t) | 3@@list("PC9623" "TX_C0603_T02_H39" list(5471.000000 3992.000000) t) | 3@@list("PC9624" "TX_C0402" list(4453.000000 4480.000000) t) | 3@@list("PC9626" "TX_C0402_T02_H28" list(5114.000000 4736.000000) t) | 3@@list("PC9627" "TX_C0402" list(4725.000000 4385.000000) t) | 3@@list("PC9800" "TX_C0402" list(7597.000000 2810.000000) t) | 3@@list("PC9801" "TX_C0805_T02_H57" list(7540.000000 2895.000000) t) | 3@@list("PC9802" "TX_C0805_T02_H57" list(7470.000000 2895.000000) t) | 3@@list("PC9803" "TX_C0402" list(7605.000000 2975.000000) t) | 3@@list("PC9805" "TX_C0603_T02_H39" list(6755.000000 2874.000000) t) | 3@@list("PC9806" "TX_C0603_T02_H39" list(6820.000000 2874.000000) t) | 3@@list("PC9807" "TX_C0603_T02_H39" list(6885.000000 2874.000000) t) | 3@@list("PCE7900" "TX_C3528_T02_H79" list(5900.000000 1510.000000) t) | 3@@list("PCE8000" "TX_C3528_T02_H79" list(6027.990000 2591.840000) t) | 3@@list("PCE8100" "TX_C7343D_T02_H83" list(5466.000000 2363.000000) t) | 3@@list("PCE8900" "TX_C3528_T02_H79" list(7028.000000 1575.000000) t) | 3@@list("PCE8901" "TX_C7343D_T02_H83" list(7335.000000 2087.000000) t) | 3@@list("PCE8902" "TX_C7343D_T02_H83" list(7101.400000 2647.600000) t) | 3@@list("PCE9600" "TX_C7343D_T02_H83" list(5616.000000 4597.000000) t) | 3@@list("PCE9601" "TX_C7343D_T02_H83" list(5809.000000 4597.000000) t) | 3@@list("PCE9602" "TX_C7343D_T02_H83" list(5344.000000 4676.000000) t) | 3@@list("PD7601" "TX_SOT323_T01X02" list(488.250000 2288.750000) t) | 3@@list("PD9400" "TX_SOD323F_H49" list(4400.000000 4428.000000) t) | 3@@list("PD9800" "TX_SOD323F_H49" list(7370.000000 2697.500000) t) | 3@@list("PJP8602" "TX_R0402_SHORT" list(3638.000000 3870.000000) t) | 3@@list("PL7900" "TX_INDUCTOR_2P_278X260_H118" list(5466.060000 2133.000000) t) | 3@@list("PL7901" "TX_INDUCTOR_2P_278X260_H118" list(5441.000000 2700.000000) t) | 3@@list("PL8000" "TX_INDUCTOR_2P_274X260_CYN" list(5529.060000 1720.000000) t) | 3@@list("PL8001" "TX_INDUCTOR_2P_278X260_H118" list(5458.060000 3020.000000) t) | 3@@list("PL8901" "TX_INDUCTO_2P_287X268_COLAY" list(7034.000000 2414.000000) t) | 3@@list("PL9501" "TX_INDUCTOR_2P_106X87" list(6454.000000 4521.000000) t) | 3@@list("PL9600" "TX_INDUCTOR_2P_278X260_H118" list(5274.000000 4314.000000) t) | 3@@list("PL9601" "TX_INDUCTOR_2P_278X260_H118" list(4965.000000 4553.000000) t) | 3@@list("PQ7601" "TX_SC70_S6_H47" list(598.000000 2433.000000) t) | 3@@list("PQ7602" "TX_SOT23_2D4_H43" list(476.000000 2435.000000) t) | 3@@list("PQ7701" "TX_SI7501DN_H44" list(5588.080000 1272.020000) t) | 3@@list("PQ7702" "TX_SI7501DN_H44" list(6895.000000 1386.000000) t) | 3@@list("PQ7703" "TX_SI7501DN_H44" list(6230.500000 1339.000000) t) | 3@@list("PQ7704" "TX_SI7501DN_H44" list(6368.000000 1296.000000) t) | 3@@list("PR7600" "TX_R0603_H24" list(1671.000000 4294.000000) t) | 3@@list("PR7602" "TX_R0603_H24" list(1601.000000 4283.000000) t) | 3@@list("PR7603" "TX_R0603_H24" list(1597.000000 4599.000000) t) | 3@@list("PR7604" "TX_R0603_H24" list(1589.000000 4524.000000) t) | 3@@list("PR7607" "TX_R0402" list(600.000000 2305.000000) t) | 3@@list("PR7608" "TX_R0402" list(427.000000 2545.000000) t) | 3@@list("PR7609" "TX_R0402" list(600.000000 2342.000000) t) | 3@@list("PR7610" "TX_R0402" list(491.000000 2545.000000) t) | 3@@list("PR7619" "TX_R0402" list(600.000000 2268.000000) t) | 3@@list("PR7700" "TX_R1508_H35" list(7119.000000 1442.000000) t) | 3@@list("PR7701" "TX_R0603_0OHM_H24" list(7549.000000 1102.000000) t) | 3@@list("PR7702" "TX_R0402" list(7690.000000 1519.500000) t) | 3@@list("PR7703" "TX_R0402" list(7240.000000 1452.000000) t) | 3@@list("PR7704" "TX_R0402" list(7241.000000 1402.000000) t) | 3@@list("PR7707" "TX_R0402" list(7456.000000 1483.000000) t) | 3@@list("PR7708" "TX_R0603_H24" list(7367.000000 1489.000000) t) | 3@@list("PR7709" "TX_R0402" list(7690.000000 1483.000000) t) | 3@@list("PR7710" "TX_R0402" list(7520.000000 1483.000000) t) | 3@@list("PR7712" "TX_R1508_H35" list(5832.000000 1307.000000) t) | 3@@list("PR7713" "TX_R0402" list(5816.000000 1405.000000) t) | 3@@list("PR7714" "TX_R0402" list(5723.000000 1348.000000) t) | 3@@list("PR7715" "TX_R0402" list(7677.000000 1226.700000) t) | 3@@list("PR7716" "TX_R0402" list(7691.000000 1373.500000) t) | 3@@list("PR7717" "R0402" list(7691.000000 1335.500000) t) | 3@@list("PR7718" "TX_R0603_0OHM_H24" list(6995.000000 1350.000000) t) | 3@@list("PR7719" "TX_R0402_0OHM" list(7669.000000 1190.500000) t) | 3@@list("PR7720" "TX_R0402_0OHM" list(7521.800000 1414.000000) t) | 3@@list("PR7721" "TX_R0402_0OHM" list(7630.100000 1428.000000) t) | 3@@list("PR7722" "TX_R0402_0OHM" list(7557.900000 1414.000000) t) | 3@@list("PR7723" "TX_R0402_0OHM" list(7594.000000 1414.000000) t) | 3@@list("PR7724" "TX_R0402_0OHM" list(7692.000000 1298.900000) t) | 3@@list("PR7725" "TX_R0402_0OHM" list(7677.000000 1262.800000) t) | 3@@list("PR7726" "TX_R0402" list(7691.000000 1446.000000) t) | 3@@list("PR7800" "TX_R0402" list(6755.000000 2498.000000) t) | 3@@list("PR7803" "TX_R0402" list(6739.000000 2446.500000) t) | 3@@list("PR7804" "TX_R0402" list(6820.000000 2332.440000) t) | 3@@list("PR7806" "TX_R0402" list(6820.000000 2368.940000) t) | 3@@list("PR7812" "TX_R0402" list(6618.500000 2466.000000) t) | 3@@list("PR7813" "TX_R0402" list(6850.000000 2234.000000) t) | 3@@list("PR7814" "TX_R0402" list(6724.000000 2548.000000) t) | 3@@list("PR7815" "TX_R0402" list(6647.000000 2363.000000) t) | 3@@list("PR7816" "TX_R0402" list(6888.000000 2125.000000) t) | 3@@list("PR7817" "TX_R0402_0OHM" list(6969.000000 2142.000000) t) | 3@@list("PR7820" "TX_R0402" list(6670.000000 2591.000000) t) | 3@@list("PR7821" "TX_R0402" list(6876.800000 2088.000000) t) | 3@@list("PR7822" "TX_R0402" list(6880.060000 2161.500000) t) | 3@@list("PR7829" "TX_R0402_H24" list(5944.000000 2088.000000) t) | 3@@list("PR7830" "TX_R0402_H24" list(6083.060000 2676.000000) t) | 3@@list("PR7834" "TX_R0402" list(6490.500000 2205.000000) t) | 3@@list("PR7836" "TX_R0402_SHORT" list(6502.000000 2242.000000) t) | 3@@list("PR7837" "TX_R0402_0OHM" list(6502.000000 2280.000000) t) | 3@@list("PR7849" "TX_R0402" list(6806.100000 2010.000000) t) | 3@@list("PR7851" "TX_R0402" list(6643.800000 1985.000000) t) | 3@@list("PR7854" "TX_R0402" list(6618.500000 2429.000000) t) | 3@@list("PR7855" "TX_R0402" list(6633.000000 2591.000000) t) | 3@@list("PR7900" "TX_R0805_0OHM_H26" list(6055.000000 2215.000000) t) | 3@@list("PR7902" "TX_R0805_0OHM_H26" list(6039.060000 2127.000000) t) | 3@@list("PR7904" "TX_R0402" list(5483.000000 1960.000000) t) | 3@@list("PR7905" "TX_R0402" list(5447.000000 1960.000000) t) | 3@@list("PR7906" "TX_R0402" list(5519.000000 1960.000000) t) | 3@@list("PR7907" "TX_R0805_0OHM_H26" list(6017.000000 2714.440000) t) | 3@@list("PR7908" "TX_R0805_0OHM_H26" list(6068.060000 2492.000000) t) | 3@@list("PR7910" "TX_R0402" list(5493.000000 2516.000000) t) | 3@@list("PR7911" "TX_R0402" list(5530.000000 2516.000000) t) | 3@@list("PR7912" "TX_R0402" list(5435.000000 2540.000000) t) | 3@@list("PR7913" "TX_R0402" list(5981.060000 2195.000000) t) | 3@@list("PR7915" "TX_R0402" list(5912.060000 2737.000000) t) | 3@@list("PR7917" "TX_R0402_0OHM" list(6050.000000 1942.000000) t) | 3@@list("PR7918" "TX_R0402_0OHM" list(6120.000000 2149.000000) t) | 3@@list("PR7919" "TX_R0402_0OHM" list(6065.000000 2310.000000) t) | 3@@list("PR7920" "TX_R0402_0OHM" list(6144.060000 2500.000000) t) | 3@@list("PR7921" "TX_R0402" list(5410.000000 1960.000000) t) | 3@@list("PR7922" "TX_R0402" list(5384.000000 2526.000000) t) | 3@@list("PR8000" "TX_R0805_0OHM_H26" list(5684.000000 1508.000000) t) | 3@@list("PR8003" "TX_R0805_0OHM_H26" list(5751.000000 1516.000000) t) | 3@@list("PR8004" "TX_R0402" list(5530.000000 1546.000000) t) | 3@@list("PR8005" "TX_R0402" list(5494.000000 1546.000000) t) | 3@@list("PR8006" "TX_R0805_0OHM_H26" list(6016.500000 3108.940000) t) | 3@@list("PR8007" "TX_R0805_0OHM_H26" list(6069.060000 2896.800000) t) | 3@@list("PR8011" "TX_R0402" list(5964.060000 3142.000000) t) | 3@@list("PR8013" "TX_R0402_0OHM" list(5418.000000 1424.000000) t) | 3@@list("PR8014" "TX_R0402_0OHM" list(5652.890000 1419.530000) t) | 3@@list("PR8015" "TX_R0402_0OHM" list(6082.060000 2718.000000) t) | 3@@list("PR8016" "TX_R0402_0OHM" list(6149.060000 2899.500000) t) | 3@@list("PR8701" "TX_R0402_0OHM" list(6645.200000 1883.000000) t) | 3@@list("PR8702" "TX_R0402_SHORT" list(6609.200000 1883.000000) t) | 3@@list("PR8703" "TX_R0603_H24" list(6551.000000 1861.000000) t) | 3@@list("PR8704" "TX_R0805_H26" list(6498.000000 1781.500000) t) | 3@@list("PR8705" "TX_R0402" list(6643.000000 1794.000000) t) | 3@@list("PR8706" "TX_R0402_0OHM" list(6625.000000 1832.000000) t) | 3@@list("PR8707" "TX_R0402" list(6782.000000 1464.000000) t) | 3@@list("PR8708" "TX_R0402" list(6732.000000 1478.000000) t) | 3@@list("PR8709" "TX_R0402" list(6695.000000 1447.000000) t) | 3@@list("PR8710" "TX_R0402" list(6580.120000 1414.000000) t) | 3@@list("PR8711" "TX_R0402" list(6782.000000 1534.000000) t) | 3@@list("PR8712" "TX_R0402_0OHM" list(6747.500000 1825.500000) t) | 3@@list("PR8800" "TX_R0402" list(1710.000000 1057.000000) t) | 3@@list("PR8809" "TX_R0402" list(3718.000000 4737.000000) t) | 3@@list("PR8811" "TX_R0402_SHORT" list(4072.000000 4754.000000) t) | 3@@list("PR8902" "TX_R0805_H26" list(7848.160000 2664.440000) t) | 3@@list("PR8903" "TX_R0805_0OHM_H26" list(7091.000000 1801.000000) t) | 3@@list("PR8904" "TX_R0402" list(7099.000000 1872.000000) t) | 3@@list("PR8905" "TX_R0805_0OHM_H26" list(7020.000000 2127.000000) t) | 3@@list("PR8906" "TX_R0402" list(7018.600000 2048.400000) t) | 3@@list("PR8908" "TX_R0603_H24" list(7796.970000 2747.210000) t) | 3@@list("PR8909" "TX_R0402" list(7801.000000 2485.000000) t) | 3@@list("PR8910" "TX_R0402" list(7747.000000 2449.000000) t) | 3@@list("PR8911" "TX_R0402" list(7797.000000 2433.000000) t) | 3@@list("PR8914" "TX_R0805_H26" list(7520.000000 2600.000000) t) | 3@@list("PR8915" "TX_R0805_0OHM_H26" list(7369.000000 2246.000000) t) | 3@@list("PR8917" "TX_R0402" list(7460.000000 2330.000000) t) | 3@@list("PR8918" "TX_R0805_0OHM_H26" list(7420.000000 2549.000000) t) | 3@@list("PR8919" "TX_R0402" list(7454.000000 2451.000000) t) | 3@@list("PR8921" "TX_R0402" list(7600.000000 2452.000000) t) | 3@@list("PR8922" "TX_R0402" list(7545.000000 2480.000000) t) | 3@@list("PR8923" "TX_R0402" list(7800.000000 2576.000000) t) | 3@@list("PR9100" "TX_R0402_SHORT" list(6962.000000 711.000000) t) | 3@@list("PR9101" "TX_R0402" list(6925.000000 711.000000) t) | 3@@list("PR9103" "TX_R0402_0OHM" list(6800.000000 711.000000) t) | 3@@list("PR9104" "TX_R0402" list(6838.000000 711.000000) t) | 3@@list("PR9105" "TX_R0402_0OHM" list(6761.000000 941.000000) t) | 3@@list("PR9106" "TX_R0402_SHORT" list(7524.500000 2399.500000) t) | 3@@list("PR9107" "TX_R0402" list(7530.000000 2362.500000) t) | 3@@list("PR9109" "TX_R0402_SHORT" list(7519.500000 2254.000000) t) | 3@@list("PR9110" "TX_R0402" list(7520.000000 2290.000000) t) | 3@@list("PR9401" "TX_R0402" list(4042.000000 4497.000000) t) | 3@@list("PR9402" "TX_R0402" list(4022.000000 4371.000000) t) | 3@@list("PR9403" "TX_R0402" list(4025.000000 4434.000000) t) | 3@@list("PR9408" "TX_R0603_H24" list(4225.000000 4505.000000) t) | 3@@list("PR9409" "TX_R0402" list(4143.000000 4499.000000) t) | 3@@list("PR9410" "TX_R0805_H26" list(4483.000000 4211.000000) t) | 3@@list("PR9412" "TX_R0402" list(3958.000000 4323.000000) t) | 3@@list("PR9413" "TX_R0603_H24" list(3955.000000 4260.000000) t) | 3@@list("PR9415" "TX_R0402" list(4412.000000 4016.000000) t) | 3@@list("PR9416" "TX_R0402" list(4063.000000 4063.500000) t) | 3@@list("PR9417" "TX_R0805_H26" list(4377.990000 4079.000000) t) | 3@@list("PR9419" "TX_R0402" list(4124.000000 3978.500000) t) | 3@@list("PR9420" "TX_R0402" list(4009.000000 3897.000000) t) | 3@@list("PR9421" "TX_R0402_0OHM" list(4350.500000 4483.000000) t) | 3@@list("PR9422" "TX_R0402" list(4046.000000 3897.000000) t) | 3@@list("PR9423" "TX_R0402" list(4227.000000 4430.000000) t) | 3@@list("PR9424" "TX_R0402" list(4120.000000 3897.000000) t) | 3@@list("PR9425" "TX_R0402" list(4013.000000 3976.000000) t) | 3@@list("PR9426" "TX_R0402_0OHM" list(4350.500000 4418.000000) t) | 3@@list("PR9427" "TX_R0402" list(4313.500000 4418.000000) t) | 3@@list("PR9428" "TX_R0402" list(3976.000000 3976.000000) t) | 3@@list("PR9429" "TX_R0402" list(4194.000000 3897.000000) t) | 3@@list("PR9430" "TX_R0402" list(4268.000000 3897.000000) t) | 3@@list("PR9431" "TX_R0402" list(4157.000000 3897.000000) t) | 3@@list("PR9432" "TX_R0402_0OHM" list(4297.000000 3961.000000) t) | 3@@list("PR9433" "TX_R0402" list(4224.500000 3987.000000) t) | 3@@list("PR9434" "TX_R0402_0OHM" list(3818.000000 4119.000000) t) | 3@@list("PR9435" "TX_R0402" list(4036.000000 4141.500000) t) | 3@@list("PR9436" "TX_R0402" list(4370.000000 3980.000000) t) | 3@@list("PR9437" "TX_R0402_0OHM" list(3882.000000 4119.000000) t) | 3@@list("PR9438" "TX_R0402" list(3952.000000 4119.000000) t) | 3@@list("PR9439" "TX_R0402_0OHM" list(3818.000000 4082.000000) t) | 3@@list("PR9440" "TX_R0402" list(3882.000000 4082.000000) t) | 3@@list("PR9441" "TX_R0402" list(3952.000000 4082.000000) t) | 3@@list("PR9442" "TX_R0402" list(4012.550000 4078.000000) t) | 3@@list("PR9443" "TX_R0402" list(3818.000000 4045.000000) t) | 3@@list("PR9444" "TX_R0402" list(3882.000000 4045.000000) t) | 3@@list("PR9445" "TX_R0402" list(3909.000000 4164.500000) t) | 3@@list("PR9446" "TX_R0402" list(3959.500000 4183.000000) t) | 3@@list("PR9447" "TX_R0402" list(4039.000000 4178.500000) t) | 3@@list("PR9448" "TX_R0402" list(3889.000000 4264.000000) t) | 3@@list("PR9449" "TX_R0402_0OHM" list(5522.000000 3522.000000) t) | 3@@list("PR9450" "TX_R0402_0OHM" list(4136.000000 4430.000000) t) | 3@@list("PR9451" "TX_R0402_0OHM" list(5521.900000 3411.370000) t) | 3@@list("PR9452" "TX_R0402_0OHM" list(4305.000000 3897.000000) t) | 3@@list("PR9453" "TX_R0402_0OHM" list(4379.000000 3897.000000) t) | 3@@list("PR9454" "TX_R0402" list(4333.000000 3961.000000) t) | 3@@list("PR9455" "TX_R0402_0OHM" list(4188.000000 3966.000000) t) | 3@@list("PR9456" "TX_R0402_SHORT" list(4342.000000 4533.000000) t) | 3@@list("PR9457" "R0402_H14" list(4034.990000 4295.000000) t) | 3@@list("PR9458" "TX_R0402" list(5457.000000 3522.000000) t) | 3@@list("PR9459" "TX_R0402" list(5522.000000 3448.000000) t) | 3@@list("PR9460" "TX_R0402" list(5522.000000 3374.000000) t) | 3@@list("PR9501" "TX_R0805_H26" list(6340.000000 2995.000000) t) | 3@@list("PR9502" "TX_R0402" list(6391.000000 2895.000000) t) | 3@@list("PR9504" "TX_R0402" list(6391.000000 2858.000000) t) | 3@@list("PR9507" "TX_R0402" list(6305.000000 4710.000000) t) | 3@@list("PR9509" "TX_R0402" list(6379.000000 4710.000000) t) | 3@@list("PR9603" "TX_R0805_0OHM_H26" list(4937.500000 4059.000000) t) | 3@@list("PR9604" "TX_R0402" list(4860.000000 4001.000000) t) | 3@@list("PR9605" "TX_R0805_0OHM_H26" list(5029.000000 4038.000000) t) | 3@@list("PR9607" "TX_R0805_0OHM_H26" list(4472.000000 4388.000000) t) | 3@@list("PR9608" "TX_R0402" list(4492.000000 4480.000000) t) | 3@@list("PR9609" "TX_R0805_0OHM_H26" list(4815.000000 4385.000000) t) | 3@@list("PR9802" "TX_R0402" list(7490.000000 2775.000000) t) | 3@@list("PR9803" "TX_R0402" list(7370.000000 2774.000000) t) | 3@@list("PR9804" "TX_R0402" list(7320.000000 2774.000000) t) | 3@@list("PR9806" "TX_R0402" list(7450.000000 2775.000000) t) | 3@@list("PR9807" "TX_R0402" list(7410.000000 2774.000000) t) | 3@@list("PR9808" "TX_R0402" list(7280.000000 2775.000000) t) | 3@@list("PR9810" "TX_R0402" list(7371.000000 3025.000000) t) | 3@@list("PR9811" "TX_R0402" list(7331.000000 3025.000000) t) | 3@@list("PR9812" "TX_R0402" list(7407.500000 3025.000000) t) | 3@@list("PRT7800" "TX_R0402_H22" list(5435.000000 2502.000000) t) | 3@@list("PRT7801" "TX_R0402_H22" list(5453.000000 2861.000000) t) | 3@@list("PRT7802" "TX_R0402_H22" list(5458.000000 1546.000000) t) | 3@@list("PRT9400" "TX_R0402_H24" list(5305.000000 4090.000000) t) | 3@@list("PRT9401" "TX_R0402_H24" list(5238.500000 4090.000000) t) | 3@@list("PT7700" "NB_TPC26T_50" list(7766.000000 1145.000000) t) | 3@@list("PT7702" "NB_TPC26T_50" list(7618.440000 1328.900000) t) | 3@@list("PT8701" "NB_TPC28T_68" list(6313.000000 2224.000000) t) | 3@@list("PT8702" "NB_TPC28T_68" list(6364.000000 2507.000000) t) | 3@@list("PT8703" "NB_TPC28T_68" list(6263.000000 2463.000000) t) | 3@@list("PT9400" "NB_TPC28T_68" list(4081.000000 4370.500000) t) | 3@@list("PT9401" "NB_TPC28T_68" list(4150.000000 4374.000000) t) | 3@@list("PT9402" "NB_TPC28T_68" list(3959.000000 4401.000000) t) | 3@@list("PT9403" "NB_TPC28T_68" list(4101.000000 4080.000000) t) | 3@@list("PT9506" "NB_TPC28T_68" list(6210.000000 2650.000000) t) | 3@@list("PT9507" "NB_TPC28T_68" list(6689.000000 2882.000000) t) | 3@@list("PT9509" "NB_TPC28T_68" list(6591.000000 4535.000000) t) | 3@@list("PT9510" "NB_TPC28T_68" list(6290.000000 4630.000000) t) | 3@@list("PT9511" "NB_TPC28T_68" list(6488.000000 4439.000000) t) | 3@@list("PT9512" "NB_TPC28T_68" list(6420.000000 4439.000000) t) | 3@@list("PT9515" "NB_TPC28T_68" list(6670.000000 4580.000000) t) | 3@@list("PU7700" "TX_QFN_32P_16_S161_PAD_5V" list(7505.000000 1265.500000) t) | 3@@list("PU7900" "TX_DFN_8P_20_87X87_PAD_1V" list(6096.060000 2030.000000) t) | 3@@list("PU7901" "TX_DFN_8P_20_87X87_PAD_1V" list(6094.060000 2395.000000) t) | 3@@list("PU8000" "TX_DFN_8P_20_87X87_PAD_1V" list(5547.060000 1418.000000) t) | 3@@list("PU8001" "TX_DFN_8P_20_87X87_PAD_1V" list(6124.060000 2800.000000) t) | 3@@list("PU8700" "QFN_16P_20_118X118_MPS" list(6684.000000 1684.000000) t) | 3@@list("PU8800" "TX_DFN_10P_20_S122_P_4V" list(1556.000000 870.000000) t) | 3@@list("PU8801" "TX_DFN_10P_20_S122_P_4V" list(4066.000000 4656.000000) t) | 3@@list("PU8900" "A_QFN_20P_16_S122_P_4V" list(7675.000000 2585.000000) t) | 3@@list("PU9100" "TX_DFN_10P_16_122X83_P_COLA" list(7644.000000 2284.500000) t) | 3@@list("PU9101" "TX_DFN_10P_16_122X83_P_COLA" list(6864.000000 819.000000) t) | 3@@list("PU9200" "TX_DFN_10P_16_122X83_P_COLA" list(5244.000000 1190.000000) t) | 3@@list("PU9400" "TX_QFN_40P_16_S201_P_4V_H31" list(4225.000000 4215.000000) t) | 3@@list("PU9500" "TX_DFN_8P_20_S83_PAD_1V" list(6250.000000 2880.000000) t) | 3@@list("PU9501" "TX_DFN_10P_20_S122_P_4V" list(6500.000000 4655.000000) t) | 3@@list("Q0400" "TX_SOT23_2D4_H44" list(5175.000000 3278.000000) t) | 3@@list("Q1000" "TX_SOT23_2D4_H44" list(4095.000000 1016.000000) t) | 3@@list("Q1900" "TX_SC70_S6_H47" list(533.000000 2076.000000) t) | 3@@list("Q1901" "TX_SC70_S6_H47" list(2867.000000 923.000000) t) | 3@@list("Q1902" "TX_SC70_S6_H47" list(2869.000000 835.000000) t) | 3@@list("Q2403" "TX_SOT23_2D4_H44" list(3772.640000 896.100000) t) | 3@@list("Q2406" "TX_SOT23_2D4_122X55_H43" list(3810.780000 764.400000) t) | 3@@list("Q3100" "TX_SOT23_2D4_H44" list(6082.000000 740.000000) t) | 3@@list("Q3101" "TX_SC70_S6_H47" list(5908.000000 910.000000) t) | 3@@list("Q3102" "TX_SOT23_2D4_H44" list(5957.000000 740.000000) t) | 3@@list("Q3600" "TX_SOT23_2D4_H44" list(5606.780000 933.000000) t) | 3@@list("Q3601" "TX_SOT23_2D4_H44" list(4117.000000 3351.000000) t) | 3@@list("Q3602" "TX_SOT23_2D4_H44" list(7892.470000 3764.910000) t) | 3@@list("Q3700" "TX_SOT23_2D4_H43" list(7825.000000 4509.000000) t) | 3@@list("Q3701" "TX_SC70_S6_H47" list(4571.000000 964.000000) t) | 3@@list("Q5000" "TX_SC70_S6_H47" list(567.000000 3617.000000) t) | 3@@list("Q5002" "TX_SC70_S6_H47" list(448.000000 3632.500000) t) | 3@@list("Q5100" "TX_SOT23_2D4_H44" list(6211.400000 902.460000) t) | 3@@list("Q5101" "TX_SOT23_2D4_122X55_H43" list(1546.000000 704.000000) t) | 3@@list("Q5102" "TX_SC70_S6_H47" list(1570.000000 455.000000) t) | 3@@list("Q5103" "TX_SC70_S6_H47" list(1532.000000 580.000000) t) | 3@@list("Q5104" "TX_SC70_S6_H47" list(1480.000000 455.000000) t) | 3@@list("Q5800" "TX_SOT23_2D4_H44" list(386.000000 3098.000000) t) | 3@@list("Q5801" "TX_SOT23_2D4_H44" list(4380.000000 954.000000) t) | 3@@list("Q6900" "TX_SC70_S6_H47" list(5510.000000 3585.000000) t) | 3@@list("Q6901" "TX_SOT23_2D4_H44" list(5553.000000 3221.000000) t) | 3@@list("Q7200" "TX_SOT23_2D4_H44" list(7941.000000 4705.000000) t) | 3@@list("Q7201" "TX_SOT23_2D4_H44" list(7785.000000 4705.000000) t) | 3@@list("Q7202" "TX_SOT23_2D4_H44" list(7969.400000 4518.320000) t) | 3@@list("Q7203" "TX_SOT23_2D4_H44" list(6023.260000 4471.400000) t) | 3@@list("Q7204" "TX_SOT23_2D4_H44" list(7970.000000 4363.000000) t) | 3@@list("R0400" "TX_R0402" list(5184.000000 2847.000000) t) | 3@@list("R0403" "TX_R0402" list(5038.060000 2689.000000) t) | 3@@list("R0410" "TX_R0402" list(5102.560000 2907.000000) t) | 3@@list("R0416" "TX_R0402" list(5069.000000 3278.060000) t) | 3@@list("R0417" "TX_R0402" list(5021.620000 2762.200000) t) | 3@@list("R0418" "TX_R0402_H16" list(5056.000000 3190.000000) t) | 3@@list("R0420" "TX_R0402" list(5021.620000 2726.000000) t) | 3@@list("R0503" "TX_R0402" list(3608.940000 4582.550000) t) | 3@@list("R0504" "TX_R0402" list(3539.000000 4734.000000) t) | 3@@list("R0601" "TX_R0402" list(5101.560000 2833.500000) t) | 3@@list("R0602" "TX_R0402" list(5101.560000 2870.000000) t) | 3@@list("R0603" "TX_R0402" list(5021.620000 2834.800000) t) | 3@@list("R0604" "TX_R0402_0OHM" list(5021.620000 2798.500000) t) | 3@@list("R0605" "TX_R0402_0OHM" list(5021.620000 2871.800000) t) | 3@@list("R0608" "TX_R0402" list(6514.000000 1947.000000) t) | 3@@list("R0609" "TX_R0402" list(6553.000000 1999.000000) t) | 3@@list("R0901" "TX_R0402" list(4769.060000 3301.000000) t) | 3@@list("R0902" "TX_R0402" list(5102.060000 2797.000000) t) | 3@@list("R0903" "TX_R0402" list(4852.000000 1325.000000) t) | 3@@list("R0904" "TX_R0402_0OHM" list(4813.000000 1362.000000) t) | 3@@list("R0905" "TX_R0402_0OHM" list(4877.000000 1368.000000) t) | 3@@list("R1000" "TX_R0402" list(5007.000000 2337.000000) t) | 3@@list("R1001" "TX_R0402_0OHM" list(4970.000000 2364.000000) t) | 3@@list("R1009" "TX_R0402" list(4145.000000 1171.000000) t) | 3@@list("R1011" "TX_R0402" list(4182.000000 1171.000000) t) | 3@@list("R1012" "TX_R0402" list(3687.000000 2058.000000) t) | 3@@list("R1013" "TX_R0402" list(3660.000000 2016.000000) t) | 3@@list("R1014" "TX_R0402" list(3660.000000 1979.000000) t) | 3@@list("R1015" "TX_R0402" list(3620.000000 2053.000000) t) | 3@@list("R1016" "TX_R0402" list(3384.000000 1119.000000) t) | 3@@list("R1019" "TX_R0402" list(4012.000000 1186.000000) t) | 3@@list("R1020" "TX_R0402_0OHM" list(4970.000000 2300.000000) t) | 3@@list("R1021" "TX_R0402" list(3604.000000 1452.000000) t) | 3@@list("R1102" "TX_R0402" list(4558.000000 1151.500000) t) | 3@@list("R1103" "TX_R0402" list(4632.000000 1151.500000) t) | 3@@list("R1104" "TX_R0402" list(4625.000000 1216.000000) t) | 3@@list("R1105" "TX_R0402" list(4662.000000 1216.000000) t) | 3@@list("R1107" "TX_R0402" list(3714.850000 1534.540000) t) | 3@@list("R1108" "TX_R0402" list(3754.000000 1534.000000) t) | 3@@list("R1109" "TX_R0402" list(4595.000000 1151.500000) t) | 3@@list("R1115" "TX_R0402" list(3641.000000 1452.000000) t) | 3@@list("R1201" "TX_R0402_0OHM" list(3756.000000 1365.000000) t) | 3@@list("R1202" "TX_R0402" list(4895.120000 3300.000000) t) | 3@@list("R1203" "TX_R0402" list(3640.500000 1534.000000) t) | 3@@list("R1206" "TX_R0402" list(4108.000000 1171.000000) t) | 3@@list("R1207" "TX_R0402" list(3678.000000 1536.000000) t) | 3@@list("R1213" "TX_R0402" list(3629.200000 1932.000000) t) | 3@@list("R1214" "TX_R0402" list(3603.500000 1532.500000) t) | 3@@list("R1216" "TX_R0402_SHORT" list(3618.000000 1857.000000) t) | 3@@list("R1222" "TX_R0402" list(3825.000000 1250.000000) t) | 3@@list("R1223" "TX_R0402_SHORT" list(3838.000000 1356.000000) t) | 3@@list("R1224" "TX_R0402" list(3650.000000 925.000000) t) | 3@@list("R1225" "TX_R0402" list(3792.000000 1365.000000) t) | 3@@list("R1227" "TX_R0402_0OHM" list(3641.000000 1222.000000) t) | 3@@list("R1228" "TX_R0402_SHORT" list(3605.000000 1222.000000) t) | 3@@list("R1300" "TX_R0402" list(4943.960000 1864.490000) t) | 3@@list("R1301" "TX_R0402" list(4018.000000 1372.000000) t) | 3@@list("R1400" "TX_R0402" list(4307.000000 1314.200000) t) | 3@@list("R1401" "TX_R0402" list(4946.000000 1538.000000) t) | 3@@list("R1402" "TX_R0402" list(5024.000000 1879.000000) t) | 3@@list("R1403" "TX_R0402" list(5024.000000 1916.000000) t) | 3@@list("R1404" "TX_R0402" list(5116.000000 1916.000000) t) | 3@@list("R1405" "TX_R0402" list(5079.000000 1916.000000) t) | 3@@list("R1406" "TX_R0402_SHORT" list(4886.000000 1126.000000) t) | 3@@list("R1407" "TX_R0402_SHORT" list(4667.500000 1374.430000) t) | 3@@list("R1408" "TX_R0402_SHORT" list(4703.500000 1374.430000) t) | 3@@list("R1409" "TX_R0402" list(4743.620000 1376.000000) t) | 3@@list("R1410" "TX_R0402" list(4198.000000 1377.000000) t) | 3@@list("R1411" "TX_R0402" list(4235.000000 1381.000000) t) | 3@@list("R1500" "TX_R0402" list(3789.000000 1452.000000) t) | 3@@list("R1504" "TX_R0402" list(4699.000000 1216.000000) t) | 3@@list("R1505" "TX_R0402" list(4736.000000 1229.000000) t) | 3@@list("R1506" "TX_R0402" list(4344.000000 1377.000000) t) | 3@@list("R1509" "TX_R0402" list(4429.000000 1180.000000) t) | 3@@list("R1510" "TX_R0402" list(4521.000000 1151.500000) t) | 3@@list("R1511" "TX_R0402" list(4440.100000 1255.000000) t) | 3@@list("R1512" "TX_R0402" list(4484.000000 1151.500000) t) | 3@@list("R1513" "TX_R0402" list(4272.000000 1377.000000) t) | 3@@list("R1514" "TX_R0402" list(4308.000000 1377.000000) t) | 3@@list("R1515" "TX_R0402" list(4249.000000 1097.000000) t) | 3@@list("R1516" "TX_R0402" list(4212.000000 1097.000000) t) | 3@@list("R1518" "TX_R0402" list(3568.000000 752.000000) t) | 3@@list("R1520" "TX_R0402" list(5654.000000 1089.000000) t) | 3@@list("R1601" "TX_R0402_SHORT" list(5096.000000 1476.000000) t) | 3@@list("R1602" "TX_R0402_SHORT" list(5090.000000 1551.000000) t) | 3@@list("R1614" "TX_R0402_SHORT" list(4217.000000 978.000000) t) | 3@@list("R1900" "TX_R0402" list(3906.000000 1178.000000) t) | 3@@list("R1901" "TX_R0402_SHORT" list(3944.010000 1026.990000) t) | 3@@list("R1902" "TX_R0402" list(3485.000000 980.000000) t) | 3@@list("R1903" "TX_R0402" list(3485.000000 1120.000000) t) | 3@@list("R1904" "TX_R0402" list(3908.000000 1027.000000) t) | 3@@list("R1905" "TX_R0402" list(3485.000000 1055.000000) t) | 3@@list("R1906" "TX_R0402" list(3907.510000 1092.000000) t) | 3@@list("R1907" "TX_R0402_SHORT" list(2962.630000 903.900000) t) | 3@@list("R1908" "TX_R0402_SHORT" list(3396.900000 792.370000) t) | 3@@list("R1909" "TX_R0402_SHORT" list(564.000000 2191.000000) t) | 3@@list("R1910" "TX_R0402_SHORT" list(494.000000 1962.500000) t) | 3@@list("R1911" "TX_R0402" list(461.990000 2187.000000) t) | 3@@list("R1912" "TX_R0402" list(605.000000 2040.000000) t) | 3@@list("R1913" "TX_R0402" list(531.000000 1962.500000) t) | 3@@list("R2415" "TX_R0402" list(3874.000000 862.000000) t) | 3@@list("R2416" "TX_R0402" list(3732.000000 817.000000) t) | 3@@list("R2425" "TX_R0402_0OHM" list(3911.000000 862.000000) t) | 3@@list("R2428" "TX_R0402_0OHM" list(3702.000000 750.000000) t) | 3@@list("R2607" "TX_R0402" list(531.000000 2799.000000) t) | 3@@list("R2608" "TX_R0402" list(560.000000 2714.990000) t) | 3@@list("R2609" "TX_R0402" list(560.000000 2614.990000) t) | 3@@list("R2610" "TX_R0402" list(560.000000 2894.000000) t) | 3@@list("R3000" "TX_R0402_SHORT" list(2302.000000 4118.500000) t) | 3@@list("R3001" "TX_R0402_SHORT" list(2266.000000 4122.500000) t) | 3@@list("R3002" "TX_R0402_0OHM" list(2205.000000 4071.000000) t) | 3@@list("R3003" "TX_R0402" list(1776.000000 4177.000000) t) | 3@@list("R3005" "TX_R0402" list(2936.000000 4154.000000) t) | 3@@list("R3108" "TX_R0805_0OHM_H26" list(3990.000000 842.000000) t) | 3@@list("R3109" "TX_R0402" list(5944.750000 972.050000) t) | 3@@list("R3110" "TX_R0402" list(5879.750000 972.050000) t) | 3@@list("R3111" "TX_R0402_0OHM" list(8204.000000 674.000000) t) | 3@@list("R3112" "TX_R0402_0OHM" list(8203.000000 637.800000) t) | 3@@list("R3115" "TX_R0402_0OHM" list(5814.000000 922.000000) t) | 3@@list("R3601" "TX_R0402" list(7790.000000 3838.000000) t) | 3@@list("R3602" "TX_R0402" list(7915.000000 3675.000000) t) | 3@@list("R3606" "TX_R0402" list(5446.780000 995.000000) t) | 3@@list("R3607" "TX_R0402" list(5238.780000 987.500000) t) | 3@@list("R3608" "TX_R0402" list(5382.000000 958.000000) t) | 3@@list("R3610" "TX_R0402_0OHM" list(7846.000000 3855.000000) t) | 3@@list("R3611" "TX_R0402" list(8012.000000 3700.000000) t) | 3@@list("R3708" "TX_R0402" list(4858.000000 3951.000000) t) | 3@@list("R3710" "TX_R0402" list(4677.000000 969.000000) t) | 3@@list("R3711" "TX_R0402" list(4684.500000 1136.000000) t) | 3@@list("R3712" "TX_R0402" list(4676.000000 911.000000) t) | 3@@list("R3713" "TX_R0402" list(4733.000000 1136.500000) t) | 3@@list("R3714" "TX_R0402" list(4478.000000 908.000000) t) | 3@@list("R3715" "TX_R0402" list(4954.000000 3702.000000) t) | 3@@list("R3800" "TX_R0402" list(143.000000 2356.000000) t) | 3@@list("R3802" "TX_R0603_H22" list(346.000000 2050.000000) t) | 3@@list("R3803" "TX_R0603_H22" list(92.000000 1834.000000) t) | 3@@list("R3805" "TX_R0402" list(622.000000 1231.000000) t) | 3@@list("R3808" "TX_R0402" list(653.020000 1366.560000) t) | 3@@list("R3809" "TX_R0402" list(647.710000 1638.520000) t) | 3@@list("R3810" "TX_R0402" list(406.690000 1768.470000) t) | 3@@list("R3811" "TX_R0402" list(648.070000 1526.650000) t) | 3@@list("R3818" "TX_R0402_0OHM" list(411.000000 1868.000000) t) | 3@@list("R3820" "TX_R0402" list(648.000000 1402.760000) t) | 3@@list("R3822" "TX_R0402" list(300.000000 1103.000000) t) | 3@@list("R3823" "TX_R0402" list(351.000000 1120.000000) t) | 3@@list("R3824" "TX_R0402" list(591.660000 1627.710000) t) | 3@@list("R3825" "TX_R0402_0OHM" list(210.000000 1142.000000) t) | 3@@list("R3828" "TX_R0402" list(148.800000 1807.000000) t) | 3@@list("R3829" "TX_R0402" list(352.000000 1958.000000) t) | 3@@list("R5100" "TX_R0402" list(3324.000000 807.000000) t) | 3@@list("R5101" "TX_R0402" list(6529.480000 1033.380000) t) | 3@@list("R5110" "TX_R0402" list(6477.630000 1019.000000) t) | 3@@list("R5700" "TX_R0402_0OHM" list(606.000000 3325.000000) t) | 3@@list("R5701" "TX_R0402_0OHM" list(606.000000 3365.000000) t) | 3@@list("R5702" "TX_R0402" list(670.000000 3325.000000) t) | 3@@list("R5703" "TX_R0402" list(670.000000 3365.000000) t) | 3@@list("R5709" "TX_R0402" list(680.000000 3580.000000) t) | 3@@list("R5712" "TX_R0402_SHORT" list(421.000000 3292.000000) t) | 3@@list("R5721" "TX_R0402_SHORT" list(671.000000 3455.000000) t) | 3@@list("R5722" "TX_R0402_SHORT" list(670.500000 3528.000000) t) | 3@@list("R5723" "TX_R0402_0OHM" list(670.500000 3492.000000) t) | 3@@list("R5724" "TX_R0402_0OHM" list(671.000000 3419.000000) t) | 3@@list("R5813" "TX_R0402" list(381.000000 3216.000000) t) | 3@@list("R5814" "TX_R0402_SHORT" list(432.000000 2978.000000) t) | 3@@list("R5815" "TX_R0402" list(466.000000 3049.000000) t) | 3@@list("R5819" "TX_R0402" list(683.000000 3067.000000) t) | 3@@list("R5820" "TX_R0402" list(683.000000 3131.000000) t) | 3@@list("R5824" "TX_R0402" list(4275.000000 919.000000) t) | 3@@list("R5825" "TX_R0402_0OHM" list(4479.000000 974.400000) t) | 3@@list("R5900" "TX_R0402" list(602.000000 3687.000000) t) | 3@@list("R5902" "TX_R0402_0OHM" list(657.000000 3802.000000) t) | 3@@list("R5903" "TX_R0402" list(673.000000 3736.000000) t) | 3@@list("R5905" "TX_R0402_0OHM" list(602.000000 3724.000000) t) | 3@@list("R6006" "TX_R0402" list(6148.000000 3173.000000) t) | 3@@list("R6007" "TX_R0402" list(6163.000000 4339.000000) t) | 3@@list("R6008" "TX_R0402" list(6200.000000 4339.000000) t) | 3@@list("R6201" "TX_R0402" list(5626.500000 3862.000000) t) | 3@@list("R6303" "TX_R0402" list(6344.000000 4346.000000) t) | 3@@list("R6304" "TX_R0402" list(6453.000000 4398.000000) t) | 3@@list("R6305" "TX_R0402" list(6453.000000 4324.000000) t) | 3@@list("R6306" "TX_R0402" list(6381.000000 4346.000000) t) | 3@@list("R6307" "TX_R0402" list(6268.000000 4325.000000) t) | 3@@list("R6800" "TX_R0402" list(7066.000000 4002.000000) t) | 3@@list("R6801" "TX_R0402" list(7680.000000 4275.000000) t) | 3@@list("R6802" "TX_R0402" list(7680.000000 4238.000000) t) | 3@@list("R6804" "TX_R0402" list(5612.000000 3316.000000) t) | 3@@list("R6806" "TX_R0402" list(7048.000000 4045.000000) t) | 3@@list("R6807" "TX_R0402" list(7048.010000 4087.000000) t) | 3@@list("R6810" "TX_R0402" list(7689.000000 3286.000000) t) | 3@@list("R6811" "TX_R0402" list(7689.990000 3328.000000) t) | 3@@list("R6812" "TX_R0402" list(7043.000000 4226.000000) t) | 3@@list("R6813" "TX_R0402" list(7042.990000 4267.000000) t) | 3@@list("R6814" "TX_R0402" list(7692.000000 3442.000000) t) | 3@@list("R6815" "TX_R0402" list(7692.010000 3483.000000) t) | 3@@list("R6816" "TX_R0402" list(7691.000000 3403.000000) t) | 3@@list("R6817" "TX_R0402" list(7678.000000 3249.000000) t) | 3@@list("R6819" "TX_R0402" list(7677.000000 3212.000000) t) | 3@@list("R6900" "TX_R0402_0OHM" list(5589.000000 3728.000000) t) | 3@@list("R6907" "TX_R0402" list(6083.000000 3150.000000) t) | 3@@list("R6910" "TX_R0402" list(6209.500000 3160.510000) t) | 3@@list("R6911" "TX_R0402" list(6246.500000 3160.510000) t) | 3@@list("R6912" "TX_R0402" list(6300.370000 3152.180000) t) | 3@@list("R6913" "TX_R0402" list(6337.370000 3152.180000) t) | 3@@list("R6914" "TX_R0402" list(5528.000000 3301.000000) t) | 3@@list("R6942" "TX_R0402" list(5625.500000 3682.000000) t) | 3@@list("R6943" "TX_R0402" list(6366.000000 3081.000000) t) | 3@@list("R7003" "TX_R0402" list(7323.000000 4584.000000) t) | 3@@list("R7004" "TX_R0402_0OHM" list(7362.000000 4584.000000) t) | 3@@list("R7005" "TX_R0603_T02_H30" list(7065.000000 4515.000000) t) | 3@@list("R7200" "TX_R0402" list(7552.000000 4523.000000) t) | 3@@list("R7201" "TX_R0402" list(7530.000000 4574.000000) t) | 3@@list("R7202" "TX_R0402" list(7964.180000 4614.790000) t) | 3@@list("R7203" "TX_R0402" list(5924.790000 4479.820000) t) | 3@@list("R7204" "TX_R0402" list(7888.000000 4372.000000) t) | 3@@list("R7205" "TX_R0402_0OHM" list(7967.210000 4241.180000) t) | 3@@list("RN2603" "TX_2R4P0402_47X55_COLAY" list(451.000000 2799.000000) t) | 3@@list("RN2604" "TX_2R4P0402_47X55_COLAY" list(450.000000 2715.000000) t) | 3@@list("RN2605" "TX_2R4P0402_47X55_COLAY" list(450.000000 2625.000000) t) | 3@@list("RN2606" "TX_2R4P0402_47X55_COLAY" list(451.000000 2889.000000) t) | 3@@list("RN3000" "TX_2R4P0402_47X55_COLAY" list(1889.000000 4133.000000) t) | 3@@list("RN5100" "TX_4R8P0402_H22_T01" list(2414.350000 955.010000) t) | 3@@list("RN5101" "TX_4R8P0402_H22_T01" list(2550.350000 955.010000) t) | 3@@list("RN5700" "TX_2R4P0402_47X55_COLAY" list(365.000000 3523.000000) t) | 3@@list("T0404" "NB_TPC26T_50" list(4965.000000 2729.000000) t) | 3@@list("T0407" "NB_TPC26T_50" list(5138.000000 1581.000000) t) | 3@@list("T0408" "NB_TPC26T_50" list(4984.030000 2665.360000) t) | 3@@list("T0410" "NB_TPC26T_50" list(4920.060000 2839.500000) t) | 3@@list("T0900" "NB_TPC26T_50" list(4925.560000 3044.000000) t) | 3@@list("T0901" "NB_TPC26T_50" list(5115.000000 1862.000000) t) | 3@@list("T0904" "NB_TPC26T_50" list(4809.000000 3282.000000) t) | 3@@list("T0906" "NB_TPC26T_50" list(4925.380000 3095.840000) t) | 3@@list("T0907" "NB_TPC26T_50" list(4925.380000 2992.840000) t) | 3@@list("T1000" "NB_TPC26T_50" list(4163.500000 1227.500000) t) | 3@@list("T1004" "NB_TPC26T_50" list(3498.000000 1692.000000) t) | 3@@list("T1100" "NB_TPC26T_50" list(4614.660000 1422.140000) t) | 3@@list("T1101" "NB_TPC26T_50" list(4016.000000 1317.000000) t) | 3@@list("T1103" "NB_TPC26T_50" list(4529.000000 1203.000000) t) | 3@@list("T1104" "NB_TPC26T_50" list(4447.730000 1380.610000) t) | 3@@list("T1200" "NB_TPC26T_50" list(3749.000000 1912.000000) t) | 3@@list("T1201" "NB_TPC26T_50" list(3535.000000 1579.000000) t) | 3@@list("T1202" "NB_TPC26T_50" list(4857.000000 3262.000000) t) | 3@@list("T1206" "NB_TPC26T_50" list(4048.000000 1271.000000) t) | 3@@list("T1401" "NB_TPC26T_50" list(4953.060000 2797.000000) t) | 3@@list("T1402" "NB_TPC26T_50" list(4631.000000 1371.000000) t) | 3@@list("T1501" "NB_TPC26T_50" list(4133.000000 1305.000000) t) | 3@@list("T1502" "NB_TPC26T_50" list(4205.000000 1265.000000) t) | 3@@list("T1503" "NB_TPC26T_50" list(4309.160000 1461.010000) t) | 3@@list("T1506" "NB_TPC26T_50" list(4397.240000 1364.780000) t) | 3@@list("T1507" "NB_TPC26T_50" list(3791.000000 1509.000000) t) | 3@@list("T1508" "NB_TPC26T_50" list(3861.000000 1419.000000) t) | 3@@list("T5805" "MX_TPC26T_S4_68" list(1375.930000 3458.280000) t) | 3@@list("T6901" "NB_TPC26T_50" list(6609.000000 2993.000000) t) | 3@@list("T6902" "NB_TPC26T_50" list(6473.000000 3142.000000) t) | 3@@list("T6903" "NB_TPC26T_50" list(6554.000000 3002.000000) t) | 3@@list("T6904" "NB_TPC26T_50" list(6466.000000 3203.000000) t) | 3@@list("T6914" "NB_TPC26T_50" list(5913.000000 3202.000000) t) | 3@@list("T6918" "NB_TPC26T_50" list(6205.000000 3215.000000) t) | 3@@list("T6919" "NB_TPC26T_50" list(6150.000000 3220.000000) t) | 3@@list("T6920" "NB_TPC26T_50" list(6453.000000 2955.000000) t) | 3@@list("T6921" "NB_TPC26T_50" list(6401.000000 3005.000000) t) | 3@@list("T6922" "NB_TPC26T_50" list(6302.000000 3076.000000) t) | 3@@list("T6923" "NB_TPC26T_50" list(6265.000000 3215.000000) t) | 3@@list("T6924" "NB_TPC26T_50" list(5661.000000 3639.000000) t) | 3@@list("T6930" "NB_TPC26T_50" list(6518.000000 2950.000000) t) | 3@@list("T6931" "NB_TPC26T_50" list(6574.000000 2945.000000) t) | 3@@list("T6932" "NB_TPC26T_50" list(6458.000000 3053.000000) t) | 3@@list("T6933" "NB_TPC26T_50" list(6511.000000 3038.000000) t) | 3@@list("T6934" "NB_TPC26T_50" list(6489.000000 3094.000000) t) | 3@@list("T6936" "NB_TPC26T_50" list(6469.000000 3004.000000) t) | 3@@list("T6939" "NB_TPC26T_50" list(6398.000000 2948.000000) t) | 3@@list("T6947" "NB_TPC26T_50" list(5689.000000 3586.000000) t) | 3@@list("T6948" "NB_TPC26T_50" list(6099.000000 3239.000000) t) | 3@@list("U0500" "TX_SC70_S5_TI" list(3509.940000 4611.000000) t) | 3@@list("U1200" "TX_SC70_S5_TI" list(3662.000000 1347.500000) t) | 3@@list("U1201" "TX_SC70_S5_TI" list(2711.000000 958.000000) t) | 3@@list("U1202" "TX_SC70_S5_TI" list(2712.000000 857.000000) t) | 3@@list("U1203" "TX_SC70_S5_TI" list(3735.000000 1240.000000) t) | 3@@list("U1204" "TX_SC70_S5_TI" list(3607.000000 823.000000) t) | 3@@list("U1800" "TX_SC70_S5_TI" list(2869.000000 1014.000000) t) | 3@@list("U3000" "TX_SOT23_S5_H57" list(1658.000000 4174.000000) t) | 3@@list("U3100" "TX_SOT23_S5_2D4_H57" list(3966.870000 746.470000) t) | 3@@list("U3800" "TX_QFN_48P_16_S240_P_9V_REA" list(460.000000 1405.000000) t) | 3@@list("U5702" "A_QFN_20P_16_122X122_P_5V" list(485.000000 3419.000000) t) | 3@@list("U6001" "TX_SC70_S5_TI" list(5209.000000 3702.000000) t) | 3@@list("U6903" "TX_SC70_S5_TI" list(5369.890000 3719.350000) t) | 3@@list("U7000" "TX_DFN_10P_16_122X83_PAD" list(7200.000000 4583.000000) t) | 3@@list("X0900" "TX_XTAL_4P_126X98_HELE" list(4878.530000 1222.510000) t) | 3@@list("X1000" "TX_XTAL_4P_126X98_HELE" list(5088.020000 2363.300000) t) | 3@@list("X6900" "TX_XTAL_4P_126X98_HELE_H35" list(5491.000000 3708.000000) t) | 4@@list("" "INDEXB_CROSS" list(1125.000000 485.000000) t) | 4@@list("" "INDEXB_CROSS" list(7804.000000 4283.990000) t) | 4@@list("" "INDEXB_CROSS" list(8156.010000 1138.930000) t) | 4@@list("CON3601" "TX_WTOB_10P_79_2HOLD_ACES" list(5144.580000 667.260000) t) | 4@@list("CON3800" "WTOB_6P_39_2H_RA_CVI" list(97.340000 905.470000) t) | 4@@list("CON7600" "TX_WTOB_7P_49_2HD_RA_ACES" list(1278.440000 4399.570000) t) | 4@@list("D1800" "TX_SOD323_H39" list(2247.000000 647.000000) t) | 4@@list("D3600" "TX_SOD523_1D7_H28" list(7845.000000 2905.000000) t) | 4@@list("D3700" "TX_SOD323_H39" list(4968.000000 3950.000000) t) | 4@@list("F5100" "TX_POLYSWITCH_0603_71X39" list(6699.000000 1032.000000) t) | 4@@list("J3800" "TX_AUDIO_JACK_6P_TECHK" list(-172.350000 2120.040000) t) | 4@@list("L3000" "CHOKE_4P_49X39_MURA" list(1889.000000 4133.000000) t) | 4@@list("PD7600" "TX_SMA_181X110" list(1683.000000 4474.500000) t) | 4@@list("PL7700" "TX_INDUCTOR_2P_S260_CYN_T02" list(6622.000000 1231.000000) t) | 4@@list("PL8600" "TX_INDUCTOR_2P_S268_MI_COLA" list(3282.000000 4422.250000) t) | 4@@list("PL8700" "TX_INDUCTOR_2P_S268_MI_COLA" list(6297.900000 1890.400000) t) | 4@@list("PL8800" "TX_INDUCTOR_2P_98X79_TA_H47" list(1625.000000 1003.000000) t) | 4@@list("PL8801" "TX_INDUCTOR_2P_98X79_TA_H47" list(3852.000000 4670.000000) t) | 4@@list("PL9500" "TX_INDUCTOR_2P_98X79_TA_H47" list(6205.000000 2990.000000) t) | 4@@list("PL9800" "TX_INDUCTOR_2P_S268_MI_COLA" list(7100.000000 2883.750000) t) | 4@@list("PQ7700" "TX_SI7850DP" list(6920.000000 1193.940000) t) | 4@@list("PQ8000" "TX_POWERPAIR_8P_2PAD_VISHAY" list(5804.060000 1735.000000) t) | 4@@list("PQ8600" "TX_POWERPAIR_8P_2PAD_VISHAY" list(3030.000000 4485.000000) t) | 4@@list("PQ8900" "TX_POWERPAIR_8P_2PAD_VISHAY" list(7009.500000 1914.000000) t) | 4@@list("PQ8901" "TX_POWERPAIR_8P_2PAD_VISHAY" list(7325.000000 2389.500000) t) | 4@@list("T2304" "TPC40T_68" list(1097.530000 1563.620000) t) | 4@@list("T2309" "TPC40T_68" list(3404.000000 1933.000000) t) | 4@@list("T2310" "TPC40T_68" list(1442.000000 1774.000000) t) | 4@@list("T5802" "TPC40T_68" list(1555.000000 3537.000000) t) | 4@@list("T5803" "TPC40T_68" list(1507.000000 3151.000000) t) | 4@@list("T5804" "TPC40T_68" list(1565.000000 3195.000000) t) | 4@@list("U0400" "BGA_1356P_1654X945_INTEL" list(4355.190000 2341.300000) t) | 4@@list("U1900" "TX_SOIC_8P_50_213X213" list(3699.000000 1072.000000) t) | 4@@list("U3700" "TX_SOIC_8P_26_122X122" list(4929.000000 3805.500000) t) | 4@@list("U5100" "TX_SOT363_PHILIPS" list(3113.000000 945.000000) t) | 4@@list("U5101" "TX_SOT23_S5_2D4_122X67_H57" list(7778.000000 2059.000000) t) | 4@@list("U5801" "TX_SOT23_S5_2D4_T02X01_H57" list(1397.310000 1032.000000) t) | 4@@list("U5802" "TX_SOT23_S5_2D4_T02X01_H57" list(574.000000 3083.000000) t) | 4@@list("U6800" "TX_BGA_170P_31_555X476" list(7370.000000 4135.000000) t) | 4@@list("U6802" "TX_BGA_170P_31_555X476" list(7370.410000 3387.730000) t) | 5@@list("CON2100" "A_DDR4_260P_20_4HOLD_FOX" list(1892.610000 2614.130000) t) | 5@@list("CON3602" "TX_WTOB_2P_49_2H_ACES_H138" list(2144.580000 931.060000) t) | 5@@list("CON5104" "TX_WTOB_20P_20_4HOLD" list(7468.990000 936.180000) t) | 6@@list("" "INDEXB_CROSS" list(7832.000000 4239.000000) nil) | 6@@list("" "INDEXB_CROSS" list(7850.500000 1109.000000) nil) | 6@@list("" "INDEXB_CROSS" list(816.000000 631.000000) nil) | 6@@list("C0600" "TX_C0603_T02_H39" list(3959.000000 2297.000000) nil) | 6@@list("C0601" "TX_C0603_T02_H39" list(3958.000000 2573.000000) nil) | 6@@list("C0602" "TX_C0603_T02_H39" list(4019.000000 2206.000000) nil) | 6@@list("C0603" "TX_C0402_T02_H28" list(4038.100000 2096.030000) nil) | 6@@list("C0604" "TX_C0402_T02_H28" list(3933.000000 2166.000000) nil) | 6@@list("C0605" "TX_C0402_T02_H28" list(3933.000000 2230.000000) nil) | 6@@list("C0606" "TX_C0402_T02_H28" list(3932.000000 2410.000000) nil) | 6@@list("C0609" "TX_C0402" list(4177.000000 2183.000000) nil) | 6@@list("C0610" "TX_C0402" list(4181.000000 2233.000000) nil) | 6@@list("C0611" "TX_C0402" list(4620.090000 2130.360000) nil) | 6@@list("C0612" "TX_C0402_T02_H28" list(4109.830000 2499.790000) nil) | 6@@list("C0613" "TX_C0402" list(4266.060000 2113.000000) nil) | 6@@list("C0614" "TX_C0402" list(4395.780000 2114.790000) nil) | 6@@list("C0615" "TX_C0402" list(4303.060000 2113.000000) nil) | 6@@list("C0616" "TX_C0402" list(4339.780000 2112.790000) nil) | 6@@list("C0617" "TX_C0402" list(4619.710000 2168.280000) nil) | 6@@list("C0618" "TX_C0402" list(4432.820000 2114.710000) nil) | 6@@list("C0619" "TX_C0402" list(4850.000000 1992.000000) nil) | 6@@list("C0620" "TX_C0402" list(4778.060000 2045.000000) nil) | 6@@list("C0621" "TX_C0402" list(4192.000000 2121.060000) nil) | 6@@list("C0622" "TX_C0402" list(4633.060000 2066.000000) nil) | 6@@list("C0623" "TX_C0402" list(4596.060000 2066.000000) nil) | 6@@list("C0700" "TX_C0402" list(4174.790000 2276.290000) nil) | 6@@list("C0701" "TX_C0402" list(4174.860000 2313.410000) nil) | 6@@list("C0702" "TX_C0402" list(4174.790000 2350.250000) nil) | 6@@list("C0703" "TX_C0402" list(4268.000000 2323.000000) nil) | 6@@list("C0704" "TX_C0402" list(4855.000000 2396.000000) nil) | 6@@list("C0705" "TX_C0402" list(4680.380000 2366.720000) nil) | 6@@list("C0706" "TX_C0402" list(4784.000000 2286.000000) nil) | 6@@list("C0711" "TX_C0402" list(4854.000000 2624.000000) nil) | 6@@list("C0712" "TX_C0402" list(4522.880000 2381.000000) nil) | 6@@list("C0717" "TX_C0402" list(4679.880000 2438.000000) nil) | 6@@list("C0718" "TX_C0402" list(4625.620000 2367.000000) nil) | 6@@list("C0719" "TX_C0402" list(4818.120000 2385.500000) nil) | 6@@list("C0720" "TX_C0402" list(4276.000000 2830.000000) nil) | 6@@list("C0721" "TX_C0402" list(4543.000000 2830.000000) nil) | 6@@list("C0722" "TX_C0402" list(4615.880000 2807.220000) nil) | 6@@list("C0723" "TX_C0402" list(4543.000000 2766.000000) nil) | 6@@list("C0724" "TX_C0402" list(4491.000000 2830.000000) nil) | 6@@list("C0725" "TX_C0402" list(4615.880000 2656.220000) nil) | 6@@list("C0726" "TX_C0402" list(4616.000000 2693.000000) nil) | 6@@list("C0727" "TX_C0402" list(4615.880000 2733.220000) nil) | 6@@list("C0728" "TX_C0402" list(4615.880000 2770.220000) nil) | 6@@list("C0729" "TX_C0402" list(4383.000000 2830.000000) nil) | 6@@list("C0730" "TX_C0402" list(4438.000000 2830.000000) nil) | 6@@list("C0731" "TX_C0402" list(4494.000000 3259.000000) nil) | 6@@list("C0732" "TX_C0402" list(4558.000000 3259.000000) nil) | 6@@list("C0733" "TX_C0402" list(4328.000000 2830.000000) nil) | 6@@list("C0740" "TX_C0402" list(4175.300000 2423.500000) nil) | 6@@list("C0741" "TX_C0402" list(4270.000000 2404.000000) nil) | 6@@list("C0742" "TX_C0402" list(4625.000000 2437.500000) nil) | 6@@list("C0743" "TX_C0402" list(4626.000000 2301.000000) nil) | 6@@list("C0744" "TX_C0402" list(4175.300000 2387.000000) nil) | 6@@list("C0745" "TX_C0402" list(4614.620000 2616.690000) nil) | 6@@list("C0746" "TX_C0402" list(4614.620000 2579.690000) nil) | 6@@list("C0747" "TX_C0402" list(4781.380000 2648.310000) nil) | 6@@list("C0748" "TX_C0402" list(4183.880000 2606.810000) nil) | 6@@list("C0749" "TX_C0402" list(4183.880000 2569.810000) nil) | 6@@list("C1002" "TX_C0402" list(3448.000000 1991.500000) nil) | 6@@list("C1003" "TX_C0402" list(3473.880000 1917.000000) nil) | 6@@list("C1100" "TX_C0402" list(3394.000000 1647.000000) nil) | 6@@list("C1101" "TX_C0402" list(3435.000000 1647.000000) nil) | 6@@list("C1102" "TX_C0402" list(3472.000000 1647.000000) nil) | 6@@list("C1103" "TX_C0402" list(3508.000000 1647.000000) nil) | 6@@list("C1201" "TX_C0402" list(2371.000000 684.000000) nil) | 6@@list("C1202" "TX_C0402" list(2410.000000 684.000000) nil) | 6@@list("C1204" "TX_C0402" list(3393.000000 1451.000000) nil) | 6@@list("C1205" "TX_C0402" list(3396.000000 1307.000000) nil) | 6@@list("C1600" "TX_C0402" list(4347.000000 2004.000000) nil) | 6@@list("C1601" "TX_C0402" list(4347.000000 1940.000000) nil) | 6@@list("C1602" "TX_C0402" list(4464.500000 1433.000000) nil) | 6@@list("C1603" "TX_C0402" list(4464.500000 1396.000000) nil) | 6@@list("C1605" "TX_C0402" list(4401.000000 2005.500000) nil) | 6@@list("C1606" "TX_C0402" list(4551.000000 1924.440000) nil) | 6@@list("C1608" "TX_C0402" list(4581.100000 1456.780000) nil) | 6@@list("C1611" "TX_C0402" list(4142.400000 1491.300000) nil) | 6@@list("C1612" "TX_C0402" list(4388.000000 1469.000000) nil) | 6@@list("C1613" "TX_C0402" list(4592.100000 1420.290000) nil) | 6@@list("C1614" "TX_C0402" list(4445.060000 2025.000000) nil) | 6@@list("C1615" "TX_C0402" list(4432.000000 1919.600000) nil) | 6@@list("C1618" "TX_C0402" list(3590.000000 1535.000000) nil) | 6@@list("C1619" "TX_C0402" list(4306.000000 2018.000000) nil) | 6@@list("C1620" "TX_C0402" list(4269.000000 1997.000000) nil) | 6@@list("C1621" "TX_C0603_T02_H39" list(4691.800000 1948.610000) nil) | 6@@list("C1622" "TX_C0402" list(4436.000000 1955.700000) nil) | 6@@list("C1623" "TX_C0603_T02_H39" list(4689.300000 2061.680000) nil) | 6@@list("C1624" "TX_C0603_T02_H39" list(4745.000000 1982.500000) nil) | 6@@list("C1625" "TX_C0402" list(4496.500000 1990.000000) nil) | 6@@list("C1626" "TX_C0402" list(4534.000000 2019.000000) nil) | 6@@list("C1629" "TX_C0402" list(4468.000000 1359.000000) nil) | 6@@list("C1630" "TX_C0402" list(4488.000000 1090.000000) nil) | 6@@list("C1632" "TX_C0402" list(5041.000000 1127.000000) nil) | 6@@list("C1800" "TX_C0402" list(297.000000 935.000000) nil) | 6@@list("C1903" "TX_C0402" list(1361.000000 3577.000000) nil) | 6@@list("C1904" "TX_C0402" list(942.000000 2439.000000) nil) | 6@@list("C1905" "TX_C0402" list(2695.000000 930.000000) nil) | 6@@list("C1906" "TX_C0402" list(2714.000000 1146.000000) nil) | 6@@list("C2000" "TX_C0402" list(2235.000000 1323.000000) nil) | 6@@list("C2001" "TX_C0402" list(2548.000000 1278.000000) nil) | 6@@list("C2002" "TX_C0402" list(2235.000000 2841.000000) nil) | 6@@list("C2003" "TX_C0402" list(4052.000000 1297.000000) nil) | 6@@list("C2004" "TX_C0402" list(4052.000000 1260.350000) nil) | 6@@list("C2005" "TX_C0402" list(2550.000000 1363.000000) nil) | 6@@list("C2006" "TX_C0402" list(2235.000000 1365.000000) nil) | 6@@list("C2007" "TX_C0402" list(2127.310000 2229.620000) nil) | 6@@list("C2008" "TX_C0402" list(2127.310000 2192.620000) nil) | 6@@list("C2009" "TX_C0402" list(2211.810000 2242.620000) nil) | 6@@list("C2010" "TX_C0402" list(2211.810000 2130.620000) nil) | 6@@list("C2011" "TX_C0402" list(2234.000000 2804.000000) nil) | 6@@list("C2012" "TX_C0402" list(2548.000000 1314.000000) nil) | 6@@list("C2100" "TX_C0402" list(1644.130000 1242.340000) nil) | 6@@list("C2101" "TX_C0402" list(2056.000000 1327.000000) nil) | 6@@list("C2102" "TX_C0402" list(1596.000000 2721.000000) nil) | 6@@list("C2103" "TX_C0402" list(2056.000000 1409.000000) nil) | 6@@list("C2104" "TX_C0402" list(1827.000000 1238.000000) nil) | 6@@list("C2105" "TX_C0402" list(2056.000000 1450.000000) nil) | 6@@list("C2106" "TX_C0402" list(2056.000000 1368.000000) nil) | 6@@list("C2107" "TX_C0402" list(1861.000000 1313.000000) nil) | 6@@list("C2108" "TX_C0402" list(1661.560000 2243.510000) nil) | 6@@list("C2109" "TX_C0402" list(1661.560000 2282.510000) nil) | 6@@list("C2110" "TX_C0402" list(1741.780000 2103.620000) nil) | 6@@list("C2111" "TX_C0402" list(1741.780000 2140.400000) nil) | 6@@list("C2200" "TX_C0402_T02_H28" list(2246.000000 3320.000000) nil) | 6@@list("C2201" "TX_C0402_T02_H28" list(2513.770000 2722.910000) nil) | 6@@list("C2202" "TX_C0402_T02_H28" list(2318.000000 2339.000000) nil) | 6@@list("C2203" "TX_C0402_T02_H28" list(2477.000000 1485.000000) nil) | 6@@list("C2204" "TX_C0402_T02_H28" list(2532.270000 2078.620000) nil) | 6@@list("C2205" "TX_C0402_T02_H28" list(2522.000000 2268.000000) nil) | 6@@list("C2206" "TX_C0402_T02_H28" list(2245.690000 3003.230000) nil) | 6@@list("C2207" "TX_C0402_T02_H28" list(2556.000000 2648.000000) nil) | 6@@list("C2208" "TX_C0402_T02_H28" list(1532.630000 1242.340000) nil) | 6@@list("C2209" "TX_C0402_T02_H28" list(2172.950000 1269.030000) nil) | 6@@list("C2210" "TX_C0402_T02_H28" list(1733.000000 3819.000000) nil) | 6@@list("C2211" "TX_C0402_T02_H28" list(1849.660000 2172.650000) nil) | 6@@list("C2212" "TX_C0402_T02_H28" list(2055.000000 2291.000000) nil) | 6@@list("C2213" "TX_C0402_T02_H28" list(1735.960000 2396.640000) nil) | 6@@list("C2214" "TX_C0402_T02_H28" list(1737.000000 2315.000000) nil) | 6@@list("C2215" "TX_C0402_T02_H28" list(2045.000000 2971.000000) nil) | 6@@list("C2216" "TX_C0402_T02_H28" list(2046.000000 2930.000000) nil) | 6@@list("C2217" "TX_C0402_T02_H28" list(2051.000000 2766.000000) nil) | 6@@list("C2218" "TX_C0402_T02_H28" list(2039.570000 3624.950000) nil) | 6@@list("C2219" "TX_C0402_T02_H28" list(1870.280000 2014.260000) nil) | 6@@list("C2220" "TX_C0402" list(2248.950000 1269.030000) nil) | 6@@list("C2221" "TX_C0402" list(2211.950000 1269.030000) nil) | 6@@list("C2222" "TX_C0402" list(1607.630000 1242.340000) nil) | 6@@list("C2223" "TX_C0402" list(1571.130000 1242.340000) nil) | 6@@list("C2224" "TX_C0402" list(2548.000000 3193.000000) nil) | 6@@list("C2225" "TX_C0402" list(2386.000000 2649.000000) nil) | 6@@list("C2226" "TX_C0402" list(2558.000000 2570.000000) nil) | 6@@list("C2227" "TX_C0402" list(2200.000000 3708.000000) nil) | 6@@list("C2228" "TX_C0402" list(2266.000000 1760.000000) nil) | 6@@list("C2229" "TX_C0402" list(2555.810000 3611.550000) nil) | 6@@list("C2230" "TX_C0402" list(2541.520000 1789.400000) nil) | 6@@list("C2231" "TX_C0402" list(2385.930000 2606.780000) nil) | 6@@list("C2232" "TX_C0402_T02_H28" list(2014.810000 1267.620000) nil) | 6@@list("C2233" "TX_C0402_T02_H28" list(2055.810000 1267.620000) nil) | 6@@list("C2234" "TX_C0402" list(2069.000000 2709.000000) nil) | 6@@list("C2235" "TX_C0402" list(2055.000000 2252.000000) nil) | 6@@list("C2236" "TX_C0402" list(2073.000000 2347.000000) nil) | 6@@list("C2237" "TX_C0402" list(2050.810000 3217.790000) nil) | 6@@list("C2238" "TX_C0402" list(1838.000000 1912.000000) nil) | 6@@list("C2239" "TX_C0402" list(1771.810000 3378.810000) nil) | 6@@list("C2240" "TX_C0402" list(2141.000000 1450.000000) nil) | 6@@list("C2241" "TX_C0402" list(2045.310000 1930.900000) nil) | 6@@list("C2242" "TX_C0402" list(2514.000000 1209.000000) nil) | 6@@list("C2243" "TX_C0402" list(2550.000000 1209.000000) nil) | 6@@list("C2300" "TX_C0402" list(1096.000000 2105.000000) nil) | 6@@list("C2301" "TX_C0402" list(1343.000000 2110.000000) nil) | 6@@list("C2302" "TX_C0402" list(1605.000000 1442.000000) nil) | 6@@list("C2303" "TX_C0402" list(1185.000000 1270.000000) nil) | 6@@list("C2304" "TX_C0402" list(1551.000000 1744.000000) nil) | 6@@list("C2305" "TX_C0402" list(737.150000 1788.160000) nil) | 6@@list("C2306" "TX_C0402" list(1058.000000 2105.000000) nil) | 6@@list("C2307" "TX_C0402" list(866.000000 1306.000000) nil) | 6@@list("C2308" "TX_C0402" list(1630.000000 1880.100000) nil) | 6@@list("C2309" "TX_C0402" list(740.000000 1573.000000) nil) | 6@@list("C2310" "TX_C0402" list(1147.000000 2070.000000) nil) | 6@@list("C2311" "TX_C0402" list(1604.000000 2128.000000) nil) | 6@@list("C2312" "TX_C0402" list(1511.000000 1961.000000) nil) | 6@@list("C2313" "TX_C0402" list(1661.000000 1497.000000) nil) | 6@@list("C2314" "TX_C0402" list(1560.000000 1607.000000) nil) | 6@@list("C2315" "TX_C0402" list(1402.000000 1267.000000) nil) | 6@@list("C2316" "TX_C0402_T02_H28" list(810.760000 2026.360000) nil) | 6@@list("C2317" "TX_C0402" list(1544.000000 1557.000000) nil) | 6@@list("C2318" "TX_C0402" list(1476.930000 2031.050000) nil) | 6@@list("C2319" "TX_C0402" list(1643.350000 1978.010000) nil) | 6@@list("C2321" "TX_C0402" list(1565.000000 1694.000000) nil) | 6@@list("C2400" "TX_C0402_T02_H26" list(822.000000 1172.000000) nil) | 6@@list("C2401" "TX_C0402" list(1020.000000 2105.000000) nil) | 6@@list("C2500" "TX_C0402" list(3455.000000 1214.650000) nil) | 6@@list("C2501" "TX_C0402_T02_H26" list(3381.000000 1214.350000) nil) | 6@@list("C2502" "TX_C0402_T02_H28" list(3632.500000 768.000000) nil) | 6@@list("C2503" "TX_C0402" list(3494.000000 1214.350000) nil) | 6@@list("C2504" "TX_C0402" list(3419.000000 1214.350000) nil) | 6@@list("C2505" "TX_C0402" list(3458.000000 1420.000000) nil) | 6@@list("C2506" "TX_C0402_T02_H26" list(3632.500000 809.000000) nil) | 6@@list("C2600" "TX_C0402" list(401.000000 3130.000000) nil) | 6@@list("C2601" "TX_C0402_T02_H28" list(442.000000 3130.000000) nil) | 6@@list("C2908" "TX_C0402" list(775.000000 2909.000000) nil) | 6@@list("C2909" "TX_C0402" list(882.000000 2740.000000) nil) | 6@@list("C3003" "TX_C0402" list(2023.000000 4193.500000) nil) | 6@@list("C3100" "TX_C0402_T02_H28" list(8622.000000 1012.000000) nil) | 6@@list("C3101" "TX_C0402" list(8622.000000 1126.000000) nil) | 6@@list("C3102" "TX_C0402" list(8622.000000 1052.000000) nil) | 6@@list("C3103" "TX_C0402" list(8622.000000 1089.000000) nil) | 6@@list("C3108" "TX_C0402_T02_H28" list(8621.000000 894.000000) nil) | 6@@list("C3109" "TX_C0402" list(8622.000000 972.000000) nil) | 6@@list("C3110" "TX_C0402" list(8621.000000 933.000000) nil) | 6@@list("C3111" "TX_C0402" list(8231.000000 827.800000) nil) | 6@@list("C3112" "TX_C0402" list(8231.000000 864.000000) nil) | 6@@list("C3113" "TX_C0402" list(8307.000000 613.200000) nil) | 6@@list("C3114" "TX_C0402" list(8307.000000 577.000000) nil) | 6@@list("C3115" "TX_C0402" list(8521.000000 519.000000) nil) | 6@@list("C3116" "TX_C0402_T02_H28" list(8608.000000 352.000000) nil) | 6@@list("C3117" "TX_C0402" list(8608.000000 313.000000) nil) | 6@@list("C3118" "TX_C0402" list(8608.000000 391.000000) nil) | 6@@list("C3119" "TX_C0402" list(8612.000000 428.000000) nil) | 6@@list("C3605" "TX_C0402" list(3823.000000 3557.000000) nil) | 6@@list("C3701" "TX_C0402" list(225.000000 2453.000000) nil) | 6@@list("C3702" "TX_C0402" list(5738.000000 996.000000) nil) | 6@@list("C3703" "TX_C0402" list(5723.000000 1157.000000) nil) | 6@@list("C3704" "TX_C0402" list(5872.000000 1195.000000) nil) | 6@@list("C3705" "TX_C0402_T02_H28" list(5872.000000 1234.000000) nil) | 6@@list("C3707" "TX_C0402" list(3953.000000 2115.000000) nil) | 6@@list("C3801" "TX_C0402" list(535.000000 1168.000000) nil) | 6@@list("C3804" "TX_C0402_T02_H28" list(496.000000 1521.000000) nil) | 6@@list("C3805" "TX_C0402" list(547.390000 1637.720000) nil) | 6@@list("C3806" "TX_C0402" list(457.000000 1529.000000) nil) | 6@@list("C3807" "TX_C0402" list(464.550000 1686.320000) nil) | 6@@list("C3817" "TX_C0402_T02_H28" list(510.000000 1227.000000) nil) | 6@@list("C3818" "TX_C0603" list(338.610000 1229.710000) nil) | 6@@list("C3821" "TX_C0603" list(264.000000 1279.000000) nil) | 6@@list("C3823" "TX_C0402_T02_H28" list(402.000000 1288.000000) nil) | 6@@list("C3824" "TX_C0402_T02_H28" list(341.000000 1567.000000) nil) | 6@@list("C3832" "TX_C0402_T02_H28" list(538.760000 1528.390000) nil) | 6@@list("C3835" "TX_C0402" list(-30.000000 1035.000000) nil) | 6@@list("C3836" "TX_C0402" list(25.000000 1037.000000) nil) | 6@@list("C3837" "TX_C0402" list(78.190000 1035.880000) nil) | 6@@list("C3838" "TX_C0402" list(121.190000 1035.880000) nil) | 6@@list("C3901" "TX_C0402" list(1303.000000 2506.000000) nil) | 6@@list("C3902" "TX_C0402_T02_H28" list(1224.000000 2506.000000) nil) | 6@@list("C3903" "TX_C0402" list(1024.000000 2621.000000) nil) | 6@@list("C3904" "TX_C0402" list(1352.000000 2688.000000) nil) | 6@@list("C3905" "TX_C0402_T02_H28" list(1024.000000 2540.000000) nil) | 6@@list("C3906" "TX_C0402_T02_H28" list(1352.000000 2768.000000) nil) | 6@@list("C3907" "TX_C0402" list(1201.000000 2826.000000) nil) | 6@@list("C3908" "TX_C0402_T02_H26" list(1352.000000 2727.000000) nil) | 6@@list("C3909" "TX_C0402" list(1353.000000 2543.000000) nil) | 6@@list("C3910" "TX_C0402_T02_H26" list(1264.000000 2506.000000) nil) | 6@@list("C3911" "TX_C0402" list(1352.000000 2651.000000) nil) | 6@@list("C3913" "TX_C0402_T02_H26" list(1024.000000 2582.000000) nil) | 6@@list("C3914" "TX_C0402" list(1165.000000 2826.000000) nil) | 6@@list("C5111" "TX_C0402" list(2934.790000 615.020000) nil) | 6@@list("C5112" "TX_C0402" list(2862.240000 615.620000) nil) | 6@@list("C5113" "TX_C0402" list(2898.430000 615.620000) nil) | 6@@list("C5114" "TX_C0402" list(2789.660000 615.620000) nil) | 6@@list("C5115" "TX_C0402" list(2825.870000 615.620000) nil) | 6@@list("C5116" "TX_C0402" list(2970.910000 615.280000) nil) | 6@@list("C5118" "TX_C0402" list(3043.970000 614.420000) nil) | 6@@list("C5119" "TX_C0402" list(3007.350000 614.290000) nil) | 6@@list("C5120" "TX_C0402" list(3080.880000 614.420000) nil) | 6@@list("C5126" "TX_C0402" list(2089.600000 565.000000) nil) | 6@@list("C5127" "TX_C0402" list(1789.500000 565.000000) nil) | 6@@list("C5128" "TX_C0402" list(1899.000000 565.000000) nil) | 6@@list("C5129" "TX_C0402" list(2017.000000 565.000000) nil) | 6@@list("C5130" "TX_C0402" list(2115.000000 670.000000) nil) | 6@@list("C5131" "TX_C0402" list(297.000000 897.000000) nil) | 6@@list("C5301" "TX_C0402" list(1465.000000 2559.000000) nil) | 6@@list("C5700" "TX_C0402" list(682.000000 3645.000000) nil) | 6@@list("C5701" "TX_C0402" list(967.000000 3641.000000) nil) | 6@@list("C5702" "TX_C0402" list(701.000000 3340.000000) nil) | 6@@list("C5703" "TX_C0402" list(889.000000 3300.000000) nil) | 6@@list("C5704" "TX_C0402" list(1008.000000 3641.000000) nil) | 6@@list("C5705" "TX_C0402" list(1006.000000 3351.000000) nil) | 6@@list("C5706" "TX_C0402" list(1005.000000 3311.000000) nil) | 6@@list("C5707" "TX_C0402" list(852.000000 3302.000000) nil) | 6@@list("C5708" "TX_C0402" list(814.000000 3302.000000) nil) | 6@@list("C5709" "TX_C0402" list(1000.000000 3392.000000) nil) | 6@@list("C5710" "TX_C0402" list(1000.000000 3429.000000) nil) | 6@@list("C5711" "TX_C0402" list(1080.000000 3448.000000) nil) | 6@@list("C5712" "TX_C0402" list(1080.000000 3485.000000) nil) | 6@@list("C5713" "TX_C0402" list(1006.000000 3503.000000) nil) | 6@@list("C5714" "TX_C0402" list(1006.000000 3541.000000) nil) | 6@@list("C5715" "TX_C0402" list(1100.000000 3571.000000) nil) | 6@@list("C5716" "TX_C0402" list(1100.000000 3609.000000) nil) | 6@@list("C5717" "TX_C0402" list(692.000000 3793.000000) nil) | 6@@list("C5718" "TX_C0402" list(655.000000 3793.000000) nil) | 6@@list("C5719" "TX_C0402" list(366.000000 3580.000000) nil) | 6@@list("C5720" "TX_C0402" list(366.000000 3539.000000) nil) | 6@@list("C5721" "TX_C0402" list(366.000000 3459.000000) nil) | 6@@list("C5722" "TX_C0402" list(366.000000 3498.000000) nil) | 6@@list("C5800" "TX_C0402" list(1405.000000 3096.500000) nil) | 6@@list("C5801" "TX_C0402" list(1355.000000 3080.000000) nil) | 6@@list("C5802" "TX_C0402" list(1286.000000 3113.000000) nil) | 6@@list("C5803" "TX_C0402" list(1304.000000 3063.000000) nil) | 6@@list("C5804" "TX_C0402" list(1430.000000 3453.300000) nil) | 6@@list("C5805" "TX_C0402" list(1576.090000 3248.530000) nil) | 6@@list("C5806" "TX_C0402" list(1576.000000 3357.000000) nil) | 6@@list("C5807" "TX_C0402" list(1578.000000 3403.000000) nil) | 6@@list("C5811" "TX_C0402" list(1561.000000 3306.000000) nil) | 6@@list("C5812" "TX_C0402" list(1598.000000 3306.000000) nil) | 6@@list("C5813" "TX_C0402" list(863.000000 2462.000000) nil) | 6@@list("C5814" "TX_C0402" list(881.000000 2678.000000) nil) | 6@@list("C5906" "TX_C0402" list(532.000000 3749.000000) nil) | 6@@list("C5912" "TX_C0402" list(494.000000 3749.000000) nil) | 6@@list("C6000" "TX_C0402" list(5267.990000 3555.000000) nil) | 6@@list("C6001" "TX_C0402" list(5293.990000 3529.000000) nil) | 6@@list("C6002" "TX_C0402" list(5346.000000 3477.000000) nil) | 6@@list("C6003" "TX_C0402" list(5320.100000 3502.810000) nil) | 6@@list("C6004" "TX_C0402" list(5241.860000 3581.060000) nil) | 6@@list("C6005" "TX_C0402" list(5215.990000 3607.000000) nil) | 6@@list("C6006" "TX_C0402" list(5180.990000 3635.000000) nil) | 6@@list("C6007" "TX_C0402" list(5155.260000 3660.600000) nil) | 6@@list("C6201" "TX_C0402" list(5895.490000 3875.500000) nil) | 6@@list("C6202" "TX_C0402" list(5802.000000 3769.000000) nil) | 6@@list("C6203" "TX_C0402" list(5799.000000 3891.000000) nil) | 6@@list("C6300" "TX_C0402_H20" list(6892.000000 3398.000000) nil) | 6@@list("C6303" "TX_C0402" list(6370.000000 3365.500000) nil) | 6@@list("C6304" "TX_C0402" list(6407.000000 3327.000000) nil) | 6@@list("C6305" "TX_C0402" list(6955.000000 3324.000000) nil) | 6@@list("C6615" "TX_C0402" list(7074.000000 4355.000000) nil) | 6@@list("C6616" "TX_C0402" list(7058.000000 3965.000000) nil) | 6@@list("C6617" "TX_C0402" list(7679.000000 4329.000000) nil) | 6@@list("C6618" "TX_C0402" list(7676.000000 3992.000000) nil) | 6@@list("C6619" "TX_C0402" list(7477.680000 4453.000000) nil) | 6@@list("C6620" "TX_C0402" list(7048.000000 3610.000000) nil) | 6@@list("C6621" "TX_C0402" list(7057.000000 3266.000000) nil) | 6@@list("C6622" "TX_C0402" list(7691.000000 3527.000000) nil) | 6@@list("C6623" "TX_C0402" list(7680.000000 3171.000000) nil) | 6@@list("C6624" "TX_C0402" list(7401.000000 3072.000000) nil) | 6@@list("C6625" "TX_C0402" list(7038.000000 4355.000000) nil) | 6@@list("C6626" "TX_C0402" list(7058.000000 3925.000000) nil) | 6@@list("C6627" "TX_C0402" list(7679.000000 4370.000000) nil) | 6@@list("C6628" "TX_C0402" list(7676.000000 3950.000000) nil) | 6@@list("C6629" "TX_C0402_T02_H28" list(7691.000000 3488.000000) nil) | 6@@list("C6632" "TX_C0402" list(7680.000000 3132.000000) nil) | 6@@list("C6633" "TX_C0402" list(7057.000000 3229.000000) nil) | 6@@list("C6636" "TX_C0402" list(7048.000000 3652.000000) nil) | 6@@list("C6637" "TX_C0402" list(7691.000000 3563.000000) nil) | 6@@list("C6700" "TX_C0402" list(6026.000000 3946.000000) nil) | 6@@list("C6701" "TX_C0402" list(6042.510000 3710.500000) nil) | 6@@list("C6702" "TX_C0402" list(6152.510000 3933.500000) nil) | 6@@list("C6703" "TX_C0402" list(6014.500000 3650.510000) nil) | 6@@list("C6704" "TX_C0402" list(6265.500000 3676.510000) nil) | 6@@list("C6705" "TX_C0402" list(6100.270000 3556.490000) nil) | 6@@list("C6706" "TX_C0402" list(6220.750000 3556.820000) nil) | 6@@list("C6707" "TX_C0402" list(6088.210000 3825.820000) nil) | 6@@list("C6708" "TX_C0402" list(6051.790000 3871.180000) nil) | 6@@list("C6709" "TX_C0402" list(6231.790000 3917.180000) nil) | 6@@list("C6710" "TX_C0402" list(6144.820000 3896.790000) nil) | 6@@list("C6711" "TX_C0402" list(6189.210000 3824.820000) nil) | 6@@list("C6712" "TX_C0402" list(6289.000000 3828.000000) nil) | 6@@list("C6713" "TX_C0402" list(6239.000000 3842.000000) nil) | 6@@list("C6714" "TX_C0402" list(6158.570000 3609.030000) nil) | 6@@list("C6715" "TX_C0402" list(5974.050000 3572.320000) nil) | 6@@list("C6716" "TX_C0402" list(6126.720000 3749.900000) nil) | 6@@list("C6717" "TX_C0402" list(6154.990000 3560.570000) nil) | 6@@list("C6718" "TX_C0402_T02_H28" list(6374.500000 3531.500000) nil) | 6@@list("C6719" "TX_C0402_T02_H28" list(5862.220000 3688.980000) nil) | 6@@list("C6720" "TX_C0402_T02_H28" list(5737.180000 3772.350000) nil) | 6@@list("C6721" "TX_C0402" list(5867.500000 4497.510000) nil) | 6@@list("C6722" "TX_C0402_T02_H28" list(5962.510000 3770.500000) nil) | 6@@list("C6723" "TX_C0402_T02_H28" list(6401.180000 4129.350000) nil) | 6@@list("C6724" "TX_C0402_T02_H28" list(6061.160000 3504.720000) nil) | 6@@list("C6725" "TX_C0402_T02_H28" list(6226.500000 3676.510000) nil) | 6@@list("C6726" "TX_C0402_T02_H28" list(6057.500000 3638.510000) nil) | 6@@list("C6727" "TX_C0402_T02_H28" list(6288.000000 3567.000000) nil) | 6@@list("C6728" "TX_C0402_T02_H28" list(6151.000000 3825.000000) nil) | 6@@list("C6729" "TX_C0402_T02_H28" list(6258.000000 3751.000000) nil) | 6@@list("C6730" "TX_C0402_T02_H28" list(6191.510000 3751.500000) nil) | 6@@list("C6731" "TX_C0402_T02_H28" list(6167.500000 3679.510000) nil) | 6@@list("C6732" "TX_C0402" list(6374.500000 3493.000000) nil) | 6@@list("C6733" "TX_C0402" list(5802.490000 3731.500000) nil) | 6@@list("C6734" "TX_C0402" list(5822.500000 4497.510000) nil) | 6@@list("C6735" "TX_C0402" list(6474.510000 4159.500000) nil) | 6@@list("C6736" "TX_C0402" list(6316.490000 4103.500000) nil) | 6@@list("C6737" "TX_C0402" list(6268.500000 3941.510000) nil) | 6@@list("C6738" "TX_C0402" list(6216.490000 4006.500000) nil) | 6@@list("C6739" "TX_C0402" list(6369.510000 4065.500000) nil) | 6@@list("C6740" "TX_C0402" list(5897.510000 3785.500000) nil) | 6@@list("C6741" "TX_C0402" list(6216.510000 3968.500000) nil) | 6@@list("C6742" "TX_C0402" list(6030.790000 3573.530000) nil) | 6@@list("C6743" "TX_C0402" list(6355.510000 3884.500000) nil) | 6@@list("C6744" "TX_C0402" list(6350.510000 3921.500000) nil) | 6@@list("C6745" "TX_C0402" list(6366.510000 3570.500000) nil) | 6@@list("C6746" "TX_C0402_T02_H28" list(6357.490000 3683.500000) nil) | 6@@list("C6747" "TX_C0402" list(6356.510000 3739.500000) nil) | 6@@list("C6748" "TX_C0402" list(6356.510000 3776.500000) nil) | 6@@list("C6749" "TX_C0402" list(6461.000000 3631.000000) nil) | 6@@list("C6750" "TX_C0402" list(6547.500000 4174.490000) nil) | 6@@list("C6751" "TX_C0402" list(6437.180000 4004.210000) nil) | 6@@list("C6752" "TX_C0402" list(6382.510000 3823.500000) nil) | 6@@list("C6753" "TX_C0402" list(6474.490000 3730.500000) nil) | 6@@list("C6754" "TX_C0402" list(6282.510000 3991.500000) nil) | 6@@list("C6800" "TX_C0402" list(7690.000000 3368.000000) nil) | 6@@list("C6802" "TX_C0402" list(7077.000000 4144.000000) nil) | 6@@list("C6907" "TX_C0402" list(5913.450000 3609.080000) nil) | 6@@list("C6908" "TX_C0402" list(5989.000000 3946.000000) nil) | 6@@list("C7100" "TX_C0402_T02_H28" list(5897.490000 3746.500000) nil) | 6@@list("C7101" "TX_C0402_T02_H28" list(6216.510000 4066.500000) nil) | 6@@list("C7102" "TX_C0402" list(5897.510000 3824.500000) nil) | 6@@list("C7103" "TX_C0402" list(6316.490000 4028.500000) nil) | 6@@list("D2400" "TX_SOD323_H39" list(418.000000 2308.080000) nil) | 6@@list("D2401" "TX_SOT323_PAN" list(211.000000 1001.000000) nil) | 6@@list("D2500" "TX_SOD523_1D7_H28" list(3106.000000 1055.000000) nil) | 6@@list("D2600" "TX_ESD_2P_33_39X24_H24" list(303.000000 3298.000000) nil) | 6@@list("D2900" "TX_ESD_2P_33_39X24_H24" list(385.000000 3005.000000) nil) | 6@@list("D2901" "TX_ESD_2P_33_39X24_H24" list(385.000000 2860.000000) nil) | 6@@list("D2902" "TX_SOT323" list(485.000000 2925.000000) nil) | 6@@list("D3604" "TX_SOD523_1D7_H28" list(3710.000000 3559.000000) nil) | 6@@list("D3605" "TX_SOD523_1D7_H28" list(2150.000000 1198.000000) nil) | 6@@list("D5100" "TX_ESD_2P_33_39X24_H24" list(1790.000000 670.000000) nil) | 6@@list("D5101" "TX_ESD_2P_33_39X24_H24" list(1885.000000 670.000000) nil) | 6@@list("D5102" "TX_ESD_2P_33_39X24_H24" list(2015.000000 670.000000) nil) | 6@@list("D5103" "TX_ESD_2P_33_39X24_H24" list(2065.000000 670.000000) nil) | 6@@list("D5702" "TX_ESD_2P_33_39X24_H24" list(240.000000 3777.000000) nil) | 6@@list("D5703" "TX_ESD_2P_33_39X24_H24" list(240.000000 3695.000000) nil) | 6@@list("D5704" "TX_ESD_2P_33_39X24_H24" list(317.000000 3663.000000) nil) | 6@@list("D5707" "TX_ESD_2P_33_39X24_H24" list(238.000000 3884.000000) nil) | 6@@list("F2600" "TX_POLYSWITCH_2P_87X59" list(543.000000 3134.000000) nil) | 6@@list("J5300" "TX_FPC_12P_20_2HD_RA_PANA" list(3293.000000 432.820000) nil) | 6@@list("J5301" "TX_FPC_12P_20_2HD_RA_PANA" list(1525.180000 2747.000000) nil) | 6@@list("L3800" "TX_L0603_T015" list(544.380000 1122.860000) nil) | 6@@list("L3805" "TX_L0603_T015" list(594.050000 1680.920000) nil) | 6@@list("L5701" "TX_CHOKE_4P_49X39_MURA" list(321.000000 3729.000000) nil) | 6@@list("L5702" "TX_CHOKE_4P_49X39_MURA" list(491.000000 3619.000000) nil) | 6@@list("L5703" "TX_CHOKE_4P_49X39_MURA" list(473.000000 3354.000000) nil) | 6@@list("L5704" "TX_CHOKE_4P_49X39_MURA" list(509.000000 3535.000000) nil) | 6@@list("L5705" "TX_CHOKE_4P_49X39_MURA" list(647.000000 3461.000000) nil) | 6@@list("L6700" "TX_L0402_T02" list(5697.280000 3820.100000) nil) | 6@@list("L6701" "TX_L0402_T02" list(5916.000000 4497.510000) nil) | 6@@list("L6702" "TX_L0402" list(6437.800000 3504.000000) nil) | 6@@list("PC7600" "TX_C0402_H22" list(2060.000000 4548.000000) nil) | 6@@list("PC7602" "TX_C0402" list(1973.000000 4550.000000) nil) | 6@@list("PC7603" "TX_C0402" list(1190.000000 3778.000000) nil) | 6@@list("PC7604" "TX_C0402" list(2500.000000 4096.000000) nil) | 6@@list("PC7606" "TX_C0603_T015_H37" list(2105.000000 4548.000000) nil) | 6@@list("PC7607" "TX_C0603_T015_H37" list(1401.000000 4192.000000) nil) | 6@@list("PC7609" "TX_C0603" list(985.000000 4224.000000) nil) | 6@@list("PC7610" "TX_C0402" list(1295.000000 4263.560000) nil) | 6@@list("PC7611" "TX_C0603_T015_H37" list(1226.500000 4091.510000) nil) | 6@@list("PC7612" "TX_C0603_T015_H37" list(1257.000000 4163.000000) nil) | 6@@list("PC7807" "TX_C0402" list(6779.000000 2347.500000) nil) | 6@@list("PC7808" "TX_C0402" list(6742.000000 2346.000000) nil) | 6@@list("PC7809" "TX_C0402" list(6880.000000 2091.000000) nil) | 6@@list("PC7810" "TX_C0402_H22" list(6880.000000 2128.000000) nil) | 6@@list("PC7811" "TX_C0402" list(6840.000000 2010.000000) nil) | 6@@list("PC7813" "TX_C0402" list(6840.000000 1945.000000) nil) | 6@@list("PC7819" "TX_C0402" list(6678.000000 2438.000000) nil) | 6@@list("PC7821" "TX_C0402" list(6883.000000 2225.000000) nil) | 6@@list("PC7824" "TX_C0402" list(6572.000000 2378.000000) nil) | 6@@list("PC7825" "TX_C0402" list(6746.000000 2213.000000) nil) | 6@@list("PC7826" "TX_C0402" list(6880.000000 2165.000000) nil) | 6@@list("PC7827" "TX_C0402" list(6372.500000 2076.000000) nil) | 6@@list("PC7828" "TX_C0402_H22" list(6409.000000 2076.000000) nil) | 6@@list("PC7829" "TX_C0402" list(6285.000000 2084.000000) nil) | 6@@list("PC7830" "TX_C0402" list(6553.000000 1993.000000) nil) | 6@@list("PC7832" "TX_C0402" list(6787.000000 1929.000000) nil) | 6@@list("PC7836" "TX_C0402" list(6402.000000 2201.000000) nil) | 6@@list("PC7914" "TX_C0402" list(5729.000000 2215.000000) nil) | 6@@list("PC7915" "TX_C0402" list(5632.060000 2778.000000) nil) | 6@@list("PC8004" "TX_C0402" list(5681.060000 1794.000000) nil) | 6@@list("PC8012" "TX_C0402" list(5652.000000 3071.000000) nil) | 6@@list("PC8013" "TX_C0402" list(5690.060000 3120.000000) nil) | 6@@list("PC8100" "TX_C0603_T02_H39" list(4624.000000 2517.000000) nil) | 6@@list("PC8101" "TX_C0603_T02_H39" list(4335.000000 2519.500000) nil) | 6@@list("PC8102" "TX_C0603_T02_H39" list(4769.000000 2480.000000) nil) | 6@@list("PC8103" "TX_C0603_T02_H39" list(4776.000000 2571.500000) nil) | 6@@list("PC8104" "TX_C0603_T02_H39" list(4388.120000 2519.500000) nil) | 6@@list("PC8107" "TX_C0603_T02_H39" list(4475.620000 2415.000000) nil) | 6@@list("PC8108" "TX_C0603_T02_H39" list(4422.120000 2415.000000) nil) | 6@@list("PC8109" "TX_C0603_T02_H39" list(4367.120000 2415.000000) nil) | 6@@list("PC8110" "TX_C0603_T02_H39" list(4314.620000 2415.000000) nil) | 6@@list("PC8111" "TX_C0603_T02_H39" list(5450.000000 1709.000000) nil) | 6@@list("PC8112" "TX_C0603_T02_H39" list(5450.000000 1655.000000) nil) | 6@@list("PC8113" "TX_C0603_T02_H39" list(5445.000000 1600.000000) nil) | 6@@list("PC8114" "TX_C0603_T02_H39" list(5358.000000 1608.000000) nil) | 6@@list("PC8115" "TX_C0603_T02_H39" list(5450.000000 1762.000000) nil) | 6@@list("PC8116" "TX_C0603_T02_H39" list(5436.000000 1834.000000) nil) | 6@@list("PC8117" "TX_C0603_T02_H39" list(5381.000000 1845.000000) nil) | 6@@list("PC8118" "TX_C0603_T02_H39" list(4821.120000 2480.000000) nil) | 6@@list("PC8119" "TX_C0603_T02_H39" list(4418.120000 2310.000000) nil) | 6@@list("PC8120" "TX_C0603_T02_H39" list(4365.120000 2310.000000) nil) | 6@@list("PC8121" "TX_C0603_T02_H39" list(4312.120000 2310.000000) nil) | 6@@list("PC8122" "TX_C0603_T02_H39" list(4771.880000 2390.000000) nil) | 6@@list("PC8124" "TX_C0603_T02_H39" list(4471.120000 2310.000000) nil) | 6@@list("PC8125" "TX_C0603_T02_H39" list(4366.120000 2205.000000) nil) | 6@@list("PC8126" "TX_C0603_T02_H39" list(4523.120000 2205.000000) nil) | 6@@list("PC8127" "TX_C0603_T02_H39" list(4471.120000 2205.000000) nil) | 6@@list("PC8128" "TX_C0603_T02_H39" list(5447.100000 1961.000000) nil) | 6@@list("PC8129" "TX_C0603_T02_H39" list(4313.120000 2205.000000) nil) | 6@@list("PC8130" "TX_C0603_T02_H39" list(5376.560000 1951.000000) nil) | 6@@list("PC8131" "TX_C0603_T02_H39" list(5324.560000 1951.000000) nil) | 6@@list("PC8132" "TX_C0603_T02_H39" list(5457.000000 2015.000000) nil) | 6@@list("PC8133" "TX_C0603_T02_H39" list(4418.620000 2205.000000) nil) | 6@@list("PC8134" "TX_C0603_T02_H39" list(4261.120000 2205.000000) nil) | 6@@list("PC8135" "TX_C0603_T02_H39" list(4441.000000 2519.500000) nil) | 6@@list("PC8136" "TX_C0603_T02_H39" list(5457.000000 2068.000000) nil) | 6@@list("PC8137" "TX_C0603_T02_H39" list(4443.000000 2750.000000) nil) | 6@@list("PC8138" "TX_C0603_T02_H39" list(4390.000000 2750.000000) nil) | 6@@list("PC8139" "TX_C0603_T02_H39" list(4337.000000 2750.000000) nil) | 6@@list("PC8141" "TX_C0603_T02_H39" list(4674.000000 3305.000000) nil) | 6@@list("PC8142" "TX_C0603_T02_H39" list(4443.120000 2622.500000) nil) | 6@@list("PC8143" "TX_C0603_T02_H39" list(4334.880000 2622.500000) nil) | 6@@list("PC8144" "TX_C0603_T02_H39" list(4284.120000 2750.000000) nil) | 6@@list("PC8145" "TX_C0603_T02_H39" list(4180.500000 2781.000000) nil) | 6@@list("PC8146" "TX_C0603_T02_H39" list(4180.000000 2708.000000) nil) | 6@@list("PC8150" "TX_C0603_T02_H39" list(4390.120000 2622.500000) nil) | 6@@list("PC8153" "TX_C0603_T02_H39" list(4281.880000 2622.500000) nil) | 6@@list("PC8154" "TX_C0603_T02_H39" list(4171.620000 2654.000000) nil) | 6@@list("PC8155" "TX_C0603_T02_H39" list(4188.000000 3402.000000) nil) | 6@@list("PC8157" "TX_C0603_T02_H39" list(4532.120000 2102.000000) nil) | 6@@list("PC8158" "TX_C0603_T02_H39" list(4790.120000 2222.500000) nil) | 6@@list("PC8159" "TX_C0603_T02_H39" list(4477.120000 2102.000000) nil) | 6@@list("PC8160" "TX_C0603_T02_H39" list(4844.120000 2222.500000) nil) | 6@@list("PC8161" "TX_C0603_T02_H39" list(5304.060000 1623.000000) nil) | 6@@list("PC8163" "TX_C0603_T02_H39" list(4564.000000 3412.000000) nil) | 6@@list("PC8165" "TX_C0603_T02_H39" list(4188.940000 3455.000000) nil) | 6@@list("PC8168" "TX_C0603_T02_H39" list(4475.000000 3689.000000) nil) | 6@@list("PC8169" "TX_C0603_T02_H39" list(4674.000000 3414.000000) nil) | 6@@list("PC8170" "TX_C0603_T02_H39" list(4693.000000 3689.000000) nil) | 6@@list("PC8171" "TX_C0603_T02_H39" list(4639.000000 3689.000000) nil) | 6@@list("PC8172" "TX_C0603_T02_H39" list(4564.000000 3305.000000) nil) | 6@@list("PC8173" "TX_C0603_T02_H39" list(4900.000000 3689.000000) nil) | 6@@list("PC8174" "TX_C0603_T02_H39" list(4845.000000 3689.000000) nil) | 6@@list("PC8175" "TX_C0603_T02_H39" list(4564.000000 3358.000000) nil) | 6@@list("PC8178" "TX_C0603_T02_H39" list(5272.000000 1951.000000) nil) | 6@@list("PC8179" "TX_C0603_T02_H39" list(4282.000000 2519.500000) nil) | 6@@list("PC8180" "TX_C0603_T02_H39" list(5489.000000 2121.000000) nil) | 6@@list("PC8181" "TX_C0603_T02_H39" list(5489.000000 2176.000000) nil) | 6@@list("PC8182" "TX_C0603_T02_H39" list(5489.000000 2231.000000) nil) | 6@@list("PC8183" "TX_C0603_T02_H39" list(4674.000000 3360.000000) nil) | 6@@list("PC8185" "TX_C0603_T02_H39" list(4530.000000 3689.000000) nil) | 6@@list("PC8186" "TX_C0603_T02_H39" list(4585.000000 3689.000000) nil) | 6@@list("PC8600" "TX_C0402" list(3770.000000 4230.000000) nil) | 6@@list("PC8601" "TX_C0402" list(3613.000000 4165.000000) nil) | 6@@list("PC8604" "TX_C0402" list(3059.000000 4367.000000) nil) | 6@@list("PC8605" "TX_C0402" list(3877.000000 4043.000000) nil) | 6@@list("PC8609" "TX_C0402" list(3895.000000 4171.000000) nil) | 6@@list("PC8610" "TX_C0402" list(3033.000000 4536.000000) nil) | 6@@list("PC8611" "TX_C0402" list(3839.000000 3971.000000) nil) | 6@@list("PC8612" "TX_C0402" list(3890.000000 3957.000000) nil) | 6@@list("PC8613" "TX_C0402_T02_H28" list(3581.000000 4022.000000) nil) | 6@@list("PC8614" "TX_C0402_T02_H28" list(3645.000000 4000.000000) nil) | 6@@list("PC8615" "TX_C0402_T02_H28" list(3645.000000 3959.800000) nil) | 6@@list("PC8616" "TX_C0402" list(3759.000000 3956.000000) nil) | 6@@list("PC8621" "TX_C0402" list(4027.000000 4113.000000) nil) | 6@@list("PC8801" "TX_C0402" list(1393.000000 1029.000000) nil) | 6@@list("PC8802" "TX_C0402" list(1398.000000 874.500000) nil) | 6@@list("PC8803" "TX_C0402" list(1411.000000 962.500000) nil) | 6@@list("PC8810" "TX_C0402" list(4152.000000 4702.000000) nil) | 6@@list("PC8811" "TX_C0402" list(4018.000000 4752.000000) nil) | 6@@list("PC8814" "TX_C0402" list(1564.000000 787.000000) nil) | 6@@list("PC8921" "TX_C0402" list(7728.000000 2584.000000) nil) | 6@@list("PC9000" "TX_C0402" list(1222.000000 3113.000000) nil) | 6@@list("PC9001" "TX_C0402" list(1335.000000 3015.000000) nil) | 6@@list("PC9002" "TX_C0402" list(1079.000000 3000.500000) nil) | 6@@list("PC9003" "TX_C0402" list(1172.000000 2917.000000) nil) | 6@@list("PC9004" "TX_C0402" list(1236.000000 2917.000000) nil) | 6@@list("PC9005" "TX_C0402" list(1633.000000 3004.000000) nil) | 6@@list("PC9007" "TX_C0402" list(1092.000000 3037.000000) nil) | 6@@list("PC9205" "TX_C0402" list(5453.000000 1202.000000) nil) | 6@@list("PC9507" "TX_C0402" list(6187.790000 2823.700000) nil) | 6@@list("PC9515" "TX_C0402" list(6431.000000 4620.000000) nil) | 6@@list("PC9516" "TX_C0603" list(6728.000000 4731.000000) nil) | 6@@list("PC9604" "TX_C0402" list(5199.000000 4339.000000) nil) | 6@@list("PC9625" "TX_C0402" list(4865.000000 4596.000000) nil) | 6@@list("PC9804" "TX_C0402_H22" list(7338.000000 2878.000000) nil) | 6@@list("PC9808" "TX_C0402" list(7325.000000 3020.000000) nil) | 6@@list("PC9809" "TX_C0402" list(7323.000000 2762.000000) nil) | 6@@list("PC9811" "TX_C0402" list(1158.000000 3113.000000) nil) | 6@@list("PCE8601" "TX_SOD523_1D7_H28" list(3931.970000 3832.750000) nil) | 6@@list("PD7602" "TX_ESD_2P_33_39X24_COLAY" list(1595.000000 4015.500000) nil) | 6@@list("PD8800" "TX_SOD323_H39" list(1663.000000 745.000000) nil) | 6@@list("PL7600" "TX_L0603_T015" list(1499.000000 4260.000000) nil) | 6@@list("PL7601" "TX_L0603_T015" list(1599.000000 4258.000000) nil) | 6@@list("PL7602" "TX_L0603_T015" list(1910.000000 4288.000000) nil) | 6@@list("PL7603" "TX_L0603_T015" list(1205.000000 4163.000000) nil) | 6@@list("PL7604" "TX_L0603_T015" list(1150.000000 4163.000000) nil) | 6@@list("PL7605" "TX_L0402_H24" list(1595.000000 4056.000000) nil) | 6@@list("PL7606" "TX_L0603_T015" list(1086.000000 4199.000000) nil) | 6@@list("PQ7600" "TX_SI7501DN_H44" list(1606.500000 4530.480000) nil) | 6@@list("PQ7603" "TX_SC70_S6_H47" list(2381.000000 4140.000000) nil) | 6@@list("PQ7605" "TX_SOT363_PHILIPS" list(2582.000000 4428.000000) nil) | 6@@list("PQ7606" "TX_SOT363_PHILIPS" list(2581.970000 4531.900000) nil) | 6@@list("PQ7607" "TX_SI7501DN_H44" list(1865.000000 4536.000000) nil) | 6@@list("PQ7608" "TX_SC70_S6_H47" list(973.000000 4332.500000) nil) | 6@@list("PQ7609" "TX_SOT363_PHILIPS" list(2347.030000 4480.960000) nil) | 6@@list("PQ7610" "TX_SOT363_PHILIPS" list(1137.470000 4566.800000) nil) | 6@@list("PQ7611" "TX_SOT363_PHILIPS" list(973.000000 4497.300000) nil) | 6@@list("PQ7612" "TX_SC70_S6_H47" list(1125.900000 4471.490000) nil) | 6@@list("PQ7613" "TX_SI7501DN_H44" list(1273.980000 4399.920000) nil) | 6@@list("PQ7614" "TX_SI7501DN_H44" list(1414.010000 4468.580000) nil) | 6@@list("PR7601" "TX_R0402" list(2528.000000 4602.000000) nil) | 6@@list("PR7611" "TX_R0402" list(1270.000000 3778.000000) nil) | 6@@list("PR7612" "TX_R0402" list(1230.000000 3778.000000) nil) | 6@@list("PR7613" "TX_R0402" list(1220.000000 3607.000000) nil) | 6@@list("PR7614" "TX_R0402_0OHM" list(1297.000000 3644.000000) nil) | 6@@list("PR7615" "TX_R0402" list(2398.000000 4257.000000) nil) | 6@@list("PR7616" "TX_R0402" list(2472.000000 4257.000000) nil) | 6@@list("PR7617" "TX_R0402" list(2463.000000 4096.000000) nil) | 6@@list("PR7618" "TX_R0402" list(2538.000000 4096.000000) nil) | 6@@list("PR7620" "TX_R0402" list(2688.000000 4415.000000) nil) | 6@@list("PR7621" "TX_R0402" list(2688.000000 4478.500000) nil) | 6@@list("PR7622" "TX_R0402" list(2672.000000 4602.000000) nil) | 6@@list("PR7623" "TX_R0402" list(2736.000000 4602.000000) nil) | 6@@list("PR7624" "TX_R0402" list(2688.000000 4542.000000) nil) | 6@@list("PR7625" "TX_R0402" list(2009.550000 4550.000000) nil) | 6@@list("PR7626" "TX_R0402" list(1992.000000 4601.000000) nil) | 6@@list("PR7627" "TX_R0402" list(2463.000000 4477.000000) nil) | 6@@list("PR7628" "TX_R0402" list(2245.000000 4462.000000) nil) | 6@@list("PR7629" "TX_R0805_H26" list(1111.000000 4285.000000) nil) | 6@@list("PR7633" "TX_R0402" list(1143.000000 4397.000000) nil) | 6@@list("PR7634" "TX_R0402" list(1295.000000 4227.510000) nil) | 6@@list("PR7635" "TX_R0402" list(1076.000000 4398.000000) nil) | 6@@list("PR7636" "TX_R0402" list(1238.500000 4519.000000) nil) | 6@@list("PR7637" "TX_R0402" list(1256.000000 4575.000000) nil) | 6@@list("PR7638" "TX_R0402" list(917.000000 4395.000000) nil) | 6@@list("PR7639" "TX_R0402" list(981.000000 4396.000000) nil) | 6@@list("PR7640" "TX_R0402" list(1036.500000 4529.000000) nil) | 6@@list("PR7641" "TX_R0402" list(904.000000 4445.000000) nil) | 6@@list("PR7643" "TX_R0402" list(2423.000000 4555.000000) nil) | 6@@list("PR7644" "TX_R0402_0OHM" list(999.000000 4169.000000) nil) | 6@@list("PR7645" "TX_R0402" list(1316.000000 4506.000000) nil) | 6@@list("PR7646" "TX_R0402" list(2607.500000 4602.000000) nil) | 6@@list("PR7705" "TX_R0603_H24" list(7504.000000 1420.000000) nil) | 6@@list("PR7706" "TX_R0402" list(7586.000000 1420.000000) nil) | 6@@list("PR7711" "TX_R0402_0OHM" list(7603.000000 1192.000000) nil) | 6@@list("PR7805" "TX_R0402" list(5501.000000 2876.000000) nil) | 6@@list("PR7807" "TX_R0402" list(6890.000000 2053.800000) nil) | 6@@list("PR7808" "TX_R0402_0OHM" list(6814.000000 2477.000000) nil) | 6@@list("PR7809" "TX_R0402" list(6815.000000 2060.000000) nil) | 6@@list("PR7810" "TX_R0402" list(6803.000000 2010.000000) nil) | 6@@list("PR7811" "TX_R0402_0OHM" list(6759.000000 2474.000000) nil) | 6@@list("PR7819" "TX_R0402_0OHM" list(6641.000000 2484.000000) nil) | 6@@list("PR7823" "TX_R0402" list(6691.000000 2350.000000) nil) | 6@@list("PR7824" "TX_R0402" list(6599.000000 2441.000000) nil) | 6@@list("PR7825" "TX_R0402" list(6746.000000 2176.800000) nil) | 6@@list("PR7826" "TX_R0402" list(6767.000000 2127.000000) nil) | 6@@list("PR7827" "TX_R0402" list(6285.000000 2048.000000) nil) | 6@@list("PR7828" "TX_R0402" list(6635.000000 2359.000000) nil) | 6@@list("PR7831" "TX_R0402" list(6336.000000 2076.000000) nil) | 6@@list("PR7832" "TX_R0402" list(6506.000000 2115.000000) nil) | 6@@list("PR7833" "TX_R0402" list(6500.000000 2078.000000) nil) | 6@@list("PR7835" "TX_R0402" list(6516.000000 1993.000000) nil) | 6@@list("PR7838" "TX_R0402" list(6521.000000 1943.000000) nil) | 6@@list("PR7839" "TX_R0402" list(6506.000000 2152.000000) nil) | 6@@list("PR7840" "TX_R0402_SHORT" list(6474.000000 2200.000000) nil) | 6@@list("PR7842" "TX_R0402" list(6730.000000 1975.000000) nil) | 6@@list("PR7843" "TX_R0402" list(6505.000000 2240.000000) nil) | 6@@list("PR7844" "TX_R0402_0OHM" list(6286.000000 2127.000000) nil) | 6@@list("PR7845" "TX_R0402" list(6617.000000 1916.000000) nil) | 6@@list("PR7846" "TX_R0402" list(6381.000000 2259.000000) nil) | 6@@list("PR7847" "TX_R0402" list(6412.000000 2145.000000) nil) | 6@@list("PR7848" "TX_R0402" list(6655.000000 1916.000000) nil) | 6@@list("PR7850" "TX_R0402_0OHM" list(6555.000000 2255.000000) nil) | 6@@list("PR7853" "TX_R0402" list(6817.000000 2383.000000) nil) | 6@@list("PR7856" "TX_R0402" list(6572.000000 2341.000000) nil) | 6@@list("PR7914" "TX_R0805_0OHM_H26" list(5639.060000 2196.000000) nil) | 6@@list("PR7916" "TX_R0805_0OHM_H26" list(5615.000000 2701.060000) nil) | 6@@list("PR8001" "TX_R0805_0OHM_H26" list(5754.060000 1715.000000) nil) | 6@@list("PR8002" "TX_R0402" list(5681.060000 1758.000000) nil) | 6@@list("PR8009" "TX_R0402" list(5464.000000 2910.000000) nil) | 6@@list("PR8010" "TX_R0402" list(5427.000000 2910.000000) nil) | 6@@list("PR8012" "TX_R0805_0OHM_H26" list(5587.940000 3133.000000) nil) | 6@@list("PR8600" "TX_R0603_H24" list(3814.000000 4223.000000) nil) | 6@@list("PR8601" "TX_R0805_0OHM_H26" list(3585.000000 4114.000000) nil) | 6@@list("PR8602" "TX_R0402" list(3895.000000 4133.000000) nil) | 6@@list("PR8603" "TX_R0402_SHORT" list(3975.000000 4010.000000) nil) | 6@@list("PR8604" "TX_R0402" list(3975.000000 3973.000000) nil) | 6@@list("PR8605" "TX_R0402" list(3059.000000 4330.000000) nil) | 6@@list("PR8606" "TX_R0402" list(3895.000000 4096.000000) nil) | 6@@list("PR8608" "TX_R0402" list(3033.000000 4573.000000) nil) | 6@@list("PR8609" "TX_R0402" list(3803.000000 3971.000000) nil) | 6@@list("PR8610" "TX_R0402" list(3890.000000 3993.000000) nil) | 6@@list("PR8611" "TX_R0402" list(3732.000000 4230.000000) nil) | 6@@list("PR8612" "TX_R0402_SHORT" list(3709.000000 3975.000000) nil) | 6@@list("PR8614" "TX_R0402_SHORT" list(3976.000000 4096.000000) nil) | 6@@list("PR8615" "TX_R0402_0OHM" list(3874.390000 3822.400000) nil) | 6@@list("PR8616" "TX_R0402" list(3836.390000 3820.900000) nil) | 6@@list("PR8617" "TX_R0805_0OHM_H26" list(2969.620000 4324.840000) nil) | 6@@list("PR8618" "TX_R0805_0OHM_H26" list(3008.620000 4481.840000) nil) | 6@@list("PR8802" "TX_R0402" list(1337.000000 962.500000) nil) | 6@@list("PR8803" "TX_R0402" list(1374.000000 962.500000) nil) | 6@@list("PR8804" "TX_R0402" list(1398.000000 912.000000) nil) | 6@@list("PR8805" "TX_R0402" list(4091.000000 4752.000000) nil) | 6@@list("PR8807" "TX_R0402" list(4152.000000 4660.000000) nil) | 6@@list("PR8810" "TX_R0402" list(4173.000000 4752.000000) nil) | 6@@list("PR8812" "TX_R0402" list(1616.000000 773.000000) nil) | 6@@list("PR8813" "TX_R0402" list(1616.000000 708.000000) nil) | 6@@list("PR8814" "TX_R0402" list(1481.000000 790.000000) nil) | 6@@list("PR8900" "TX_R0603_H24" list(7507.450000 2620.160000) nil) | 6@@list("PR8912" "TX_R0402" list(7664.000000 2532.000000) nil) | 6@@list("PR9000" "TX_R0402_SHORT" list(1415.000000 2975.000000) nil) | 6@@list("PR9001" "TX_R0402" list(1333.000000 2973.000000) nil) | 6@@list("PR9004" "TX_R0402_SHORT" list(1513.000000 3039.000000) nil) | 6@@list("PR9005" "TX_R0402" list(1420.000000 3016.000000) nil) | 6@@list("PR9200" "TX_R0402_SHORT" list(5432.000000 1133.000000) nil) | 6@@list("PR9201" "TX_R0402" list(5373.000000 1119.000000) nil) | 6@@list("PR9205" "TX_R0402_SHORT" list(5406.000000 1272.000000) nil) | 6@@list("PR9207" "TX_R0402" list(5370.000000 1272.000000) nil) | 6@@list("PR9500" "TX_R0402" list(6241.010000 2771.000000) nil) | 6@@list("PR9503" "TX_R0402" list(6214.000000 2797.000000) nil) | 6@@list("PR9505" "TX_R0402" list(6288.000000 4569.000000) nil) | 6@@list("PR9506" "TX_R0805_H26" list(6623.000000 4718.000000) nil) | 6@@list("PR9508" "TX_R0402" list(6493.000000 4640.000000) nil) | 6@@list("PR9801" "TX_R0402_0OHM" list(7338.000000 2920.000000) nil) | 6@@list("PR9805" "TX_R0402" list(7338.000000 2840.000000) nil) | 6@@list("PR9809" "TX_R0402" list(7365.000000 3020.000000) nil) | 6@@list("PR9814" "TX_R0402" list(7362.000000 2762.000000) nil) | 6@@list("PR9815" "TX_R0402_SHORT" list(7399.000000 2762.000000) nil) | 6@@list("PT7701" "NB_TPC26T_50" list(7551.000000 1346.000000) nil) | 6@@list("PT8700" "NB_TPC28T_68" list(6555.000000 1782.000000) nil) | 6@@list("PT8704" "NB_TPC28T_68" list(6613.000000 1864.000000) nil) | 6@@list("PT9500" "NB_TPC28T_68" list(6287.000000 2758.000000) nil) | 6@@list("PT9501" "NB_TPC28T_68" list(6113.000000 2845.000000) nil) | 6@@list("PT9502" "NB_TPC28T_68" list(6031.000000 2889.000000) nil) | 6@@list("PT9503" "NB_TPC28T_68" list(6088.000000 2931.000000) nil) | 6@@list("PT9504" "NB_TPC28T_68" list(5976.000000 2848.000000) nil) | 6@@list("PT9505" "NB_TPC28T_68" list(5776.000000 2556.000000) nil) | 6@@list("PT9508" "NB_TPC28T_68" list(6355.000000 4575.000000) nil) | 6@@list("PT9513" "NB_TPC28T_68" list(5784.000000 2885.000000) nil) | 6@@list("PT9514" "NB_TPC28T_68" list(5783.000000 2814.000000) nil) | 6@@list("PT9800" "NB_TPC28T_68" list(7479.000000 2942.000000) nil) | 6@@list("PU8600" "TX_QFN_20P_16_S118_P_H31_4V" list(3745.000000 4105.000000) nil) | 6@@list("PU9000" "TX_SC70_S5_TI" list(1639.000000 3101.000000) nil) | 6@@list("PU9001" "TX_DFN_10P_16_122X83_P_COLA" list(1200.200000 3015.000000) nil) | 6@@list("Q2400" "TX_SC70_S6_H47" list(565.000000 2304.000000) nil) | 6@@list("Q2401" "TX_SC70_S6_H47" list(860.000000 1090.000000) nil) | 6@@list("Q2600" "TX_SOT23_2D4_122X55_H43" list(695.000000 3026.000000) nil) | 6@@list("Q2601" "TX_SOT23_2D4_H44" list(838.000000 3052.000000) nil) | 6@@list("Q2900" "TX_SC70_S6_H47" list(838.000000 2841.000000) nil) | 6@@list("Q2901" "TX_SC70_S6_H47" list(948.000000 2925.000000) nil) | 6@@list("R0401" "TX_R0402" list(4893.000000 3283.000000) nil) | 6@@list("R0402" "TX_R0402" list(4929.000000 3283.000000) nil) | 6@@list("R0404" "TX_R0402" list(4085.000000 1963.000000) nil) | 6@@list("R0405" "TX_R0402" list(3956.000000 1971.000000) nil) | 6@@list("R0406" "TX_R0402" list(4832.000000 3283.000000) nil) | 6@@list("R0407" "TX_R0402" list(4615.880000 2843.720000) nil) | 6@@list("R0408" "TX_R0402_SHORT" list(4754.500000 1406.000000) nil) | 6@@list("R0411" "TX_R0402" list(4756.000000 1258.000000) nil) | 6@@list("R0413" "TX_R0402" list(4730.320000 2690.000000) nil) | 6@@list("R0414" "TX_R0402" list(4758.000000 1331.000000) nil) | 6@@list("R0415" "TX_R0402" list(4795.000000 1399.000000) nil) | 6@@list("R0500" "TX_R0402" list(4122.000000 1945.000000) nil) | 6@@list("R0501" "TX_R0402" list(4048.000000 1963.000000) nil) | 6@@list("R0502" "TX_R0402" list(3995.000000 1971.000000) nil) | 6@@list("R0600" "TX_R0402_0OHM" list(4028.960000 2486.590000) nil) | 6@@list("R0606" "TX_R0402" list(4694.000000 2306.000000) nil) | 6@@list("R0607" "TX_R0402" list(4732.000000 2250.000000) nil) | 6@@list("R0702" "TX_R0402" list(6857.000000 2275.000000) nil) | 6@@list("R0703" "TX_R0402" list(6913.000000 2262.000000) nil) | 6@@list("R0900" "TX_R0402" list(4733.500000 2830.000000) nil) | 6@@list("R1002" "TX_R0402" list(3908.000000 1452.000000) nil) | 6@@list("R1003" "TX_R0402" list(3982.000000 1452.000000) nil) | 6@@list("R1004" "TX_R0402" list(3871.000000 1452.000000) nil) | 6@@list("R1005" "TX_R0402" list(4788.000000 2323.000000) nil) | 6@@list("R1006" "TX_R0402" list(4854.920000 2316.000000) nil) | 6@@list("R1007" "TX_R0402" list(3516.120000 1965.500000) nil) | 6@@list("R1008" "TX_R0402_0OHM" list(3436.880000 1917.000000) nil) | 6@@list("R1010" "TX_R0402" list(3945.000000 1452.000000) nil) | 6@@list("R1017" "TX_R0402" list(4658.000000 1217.000000) nil) | 6@@list("R1018" "TX_R0402" list(4722.000000 1218.990000) nil) | 6@@list("R1022" "TX_R0402" list(4215.000000 1285.000000) nil) | 6@@list("R1023" "TX_R0402" list(4224.400000 1375.200000) nil) | 6@@list("R1024" "TX_R0402" list(4251.000000 1285.000000) nil) | 6@@list("R1025" "TX_R0402" list(4287.000000 1285.000000) nil) | 6@@list("R1026" "TX_R0402" list(4323.000000 1285.000000) nil) | 6@@list("R1027" "TX_R0402" list(4261.000000 1375.000000) nil) | 6@@list("R1028" "TX_R0402" list(4286.200000 1484.300000) nil) | 6@@list("R1029" "TX_R0402" list(4305.000000 1377.300000) nil) | 6@@list("R1030" "TX_R0402" list(3834.000000 1452.000000) nil) | 6@@list("R1100" "TX_R0402" list(4709.500000 1383.500000) nil) | 6@@list("R1101" "TX_R0402" list(4652.000000 1391.000000) nil) | 6@@list("R1106" "TX_R0402" list(4178.300000 1338.900000) nil) | 6@@list("R1110" "TX_R0402" list(3508.000000 1712.000000) nil) | 6@@list("R1111" "TX_R0402" list(3472.000000 1712.000000) nil) | 6@@list("R1112" "TX_R0402" list(3435.000000 1712.000000) nil) | 6@@list("R1113" "TX_R0402" list(3394.000000 1712.000000) nil) | 6@@list("R1114" "TX_R0402" list(4614.200000 1369.990000) nil) | 6@@list("R1200" "TX_R0402" list(3538.000000 1549.000000) nil) | 6@@list("R1204" "TX_R0402" list(3437.000000 1370.000000) nil) | 6@@list("R1205" "TX_R0402" list(5275.000000 1544.000000) nil) | 6@@list("R1208" "TX_R0402" list(3363.500000 1371.000000) nil) | 6@@list("R1209" "TX_R0402" list(3400.000000 1371.000000) nil) | 6@@list("R1210" "TX_R0402" list(4359.000000 1285.000000) nil) | 6@@list("R1211" "TX_R0402_SHORT" list(4836.000000 1298.000000) nil) | 6@@list("R1212" "TX_R0402" list(4836.000000 1233.000000) nil) | 6@@list("R1217" "TX_R0402_0OHM" list(2567.000000 562.000000) nil) | 6@@list("R1218" "TX_R0402" list(2378.000000 779.000000) nil) | 6@@list("R1220" "TX_R0402" list(2300.000000 765.000000) nil) | 6@@list("R1221" "TX_R0402_0OHM" list(2235.000000 765.000000) nil) | 6@@list("R1226" "TX_R0402" list(3359.500000 1307.000000) nil) | 6@@list("R1229" "TX_R0402_0OHM" list(3356.000000 1451.000000) nil) | 6@@list("R1503" "TX_R0402" list(4468.000000 1154.000000) nil) | 6@@list("R1507" "TX_R0402" list(4142.000000 1339.000000) nil) | 6@@list("R1508" "TX_R0402" list(4143.600000 1410.400000) nil) | 6@@list("R1517" "TX_R0402" list(3445.000000 1528.000000) nil) | 6@@list("R1519" "TX_R0402" list(4463.000000 1298.500000) nil) | 6@@list("R1604" "TX_R0402_SHORT" list(4520.000000 1309.000000) nil) | 6@@list("R1606" "TX_R0402_SHORT" list(4751.000000 1920.000000) nil) | 6@@list("R1607" "TX_R0402" list(4395.500000 1245.000000) nil) | 6@@list("R1608" "TX_R0402" list(4207.400000 1491.600000) nil) | 6@@list("R1610" "TX_R0402_SHORT" list(4750.000000 2083.000000) nil) | 6@@list("R1611" "TX_R0402_SHORT" list(4790.000000 1994.000000) nil) | 6@@list("R1612" "TX_R0402_SHORT" list(4877.000000 1298.000000) nil) | 6@@list("R1615" "TX_R0402_0OHM" list(4578.000000 1369.990000) nil) | 6@@list("R1621" "TX_R0402_SHORT" list(5045.000000 1319.000000) nil) | 6@@list("R1622" "TX_R0402_SHORT" list(4264.000000 1934.000000) nil) | 6@@list("R1623" "TX_R0402_SHORT" list(4093.000000 1193.000000) nil) | 6@@list("R1624" "TX_R0402_SHORT" list(4528.000000 1396.000000) nil) | 6@@list("R1800" "TX_R0402_SHORT" list(2362.000000 567.000000) nil) | 6@@list("R1801" "TX_R0402_SHORT" list(2325.000000 567.000000) nil) | 6@@list("R1802" "TX_R0402" list(2420.000000 567.000000) nil) | 6@@list("R1803" "TX_R0402_SHORT" list(2486.000000 571.000000) nil) | 6@@list("R1804" "TX_R0402" list(2567.000000 680.000000) nil) | 6@@list("R1805" "TX_R0402_SHORT" list(2523.000000 571.000000) nil) | 6@@list("R1806" "TX_R0402_0OHM" list(2515.000000 666.000000) nil) | 6@@list("R1807" "TX_R0402" list(2528.000000 779.000000) nil) | 6@@list("R1914" "TX_R0402_SHORT" list(2735.000000 922.000000) nil) | 6@@list("R1915" "TX_R0402" list(2808.010000 952.000000) nil) | 6@@list("R1916" "TX_R0402_SHORT" list(1545.000000 1112.000000) nil) | 6@@list("R1917" "TX_R0402" list(2772.000000 952.000000) nil) | 6@@list("R1918" "TX_R0402" list(2747.000000 1081.990000) nil) | 6@@list("R1919" "TX_R0402" list(2720.000000 866.000000) nil) | 6@@list("R1920" "TX_R0402" list(3254.000000 647.000000) nil) | 6@@list("R1921" "TX_R0402" list(2836.000000 810.000000) nil) | 6@@list("R2000" "TX_R0402" list(2234.000000 2728.000000) nil) | 6@@list("R2001" "TX_R0402_0OHM" list(2234.000000 2765.000000) nil) | 6@@list("R2002" "TX_R0402" list(2386.000000 2569.000000) nil) | 6@@list("R2003" "TX_R0402" list(2211.810000 2093.620000) nil) | 6@@list("R2004" "TX_R0402" list(2211.810000 2167.620000) nil) | 6@@list("R2005" "TX_R0402" list(2211.810000 2205.620000) nil) | 6@@list("R2006" "TX_R0402" list(2127.310000 2155.620000) nil) | 6@@list("R2100" "TX_R0402" list(1755.810000 2455.700000) nil) | 6@@list("R2101" "TX_R0402" list(1742.000000 2250.000000) nil) | 6@@list("R2102" "TX_R0402" list(1742.000000 2213.000000) nil) | 6@@list("R2103" "TX_R0402" list(1741.810000 2176.620000) nil) | 6@@list("R2104" "TX_R0402" list(1661.560000 2319.510000) nil) | 6@@list("R2300" "TX_R0402" list(1365.000000 1267.000000) nil) | 6@@list("R2301" "TX_R0402_SHORT" list(1685.000000 1741.000000) nil) | 6@@list("R2302" "TX_R0402_SHORT" list(1562.000000 1794.000000) nil) | 6@@list("R2305" "TX_R0402" list(1674.000000 1672.000000) nil) | 6@@list("R2306" "TX_R0402" list(1631.000000 1817.000000) nil) | 6@@list("R2307" "TX_R0402_SHORT" list(1563.000000 2128.000000) nil) | 6@@list("R2308" "TX_R0402_SHORT" list(1559.000000 1866.500000) nil) | 6@@list("R2309" "TX_R0402" list(1632.200000 2431.220000) nil) | 6@@list("R2310" "TX_R0402" list(1632.000000 2505.000000) nil) | 6@@list("R2311" "TX_R0402" list(1607.500000 1557.000000) nil) | 6@@list("R2312" "TX_R0402" list(1588.000000 1493.500000) nil) | 6@@list("R2313" "TX_R0402" list(1624.000000 1493.500000) nil) | 6@@list("R2314" "TX_R0402" list(1632.000000 1607.000000) nil) | 6@@list("R2315" "TX_R0402" list(1596.000000 1607.000000) nil) | 6@@list("R2316" "TX_R0402" list(1305.000000 2110.000000) nil) | 6@@list("R2317" "TX_R0402" list(1264.000000 2091.000000) nil) | 6@@list("R2318" "TX_R0402" list(1283.000000 2309.000000) nil) | 6@@list("R2319" "TX_R0402" list(1313.910000 2205.350000) nil) | 6@@list("R2320" "TX_R0402" list(963.000000 1258.000000) nil) | 6@@list("R2321" "TX_R0402_SHORT" list(1439.000000 1267.000000) nil) | 6@@list("R2322" "TX_R0402" list(979.000000 2190.000000) nil) | 6@@list("R2323" "TX_R0402_SHORT" list(975.000000 2107.000000) nil) | 6@@list("R2324" "TX_R0402" list(1635.000000 1727.500000) nil) | 6@@list("R2325" "TX_R0402" list(1635.000000 1764.000000) nil) | 6@@list("R2326" "TX_R0402" list(1214.000000 2093.000000) nil) | 6@@list("R2328" "TX_R0402_0OHM" list(1565.000000 1658.000000) nil) | 6@@list("R2329" "TX_R0402_0OHM" list(1575.000000 1942.000000) nil) | 6@@list("R2330" "TX_R0402_0OHM" list(1577.000000 1983.000000) nil) | 6@@list("R2331" "TX_R0402" list(738.790000 1611.390000) nil) | 6@@list("R2332" "TX_R0402" list(1560.000000 1830.000000) nil) | 6@@list("R2333" "TX_R0402" list(1258.000000 1236.000000) nil) | 6@@list("R2334" "TX_R0402" list(738.000000 1994.000000) nil) | 6@@list("R2335" "TX_R0402" list(740.000000 1702.500000) nil) | 6@@list("R2336" "TX_R0402_SHORT" list(739.000000 1648.000000) nil) | 6@@list("R2337" "TX_R0402" list(1172.000000 1174.000000) nil) | 6@@list("R2338" "TX_R0402" list(1135.000000 1174.000000) nil) | 6@@list("R2339" "TX_R0402" list(1537.000000 2417.000000) nil) | 6@@list("R2341" "TX_R0402" list(1381.000000 2111.000000) nil) | 6@@list("R2342" "TX_R0402" list(1501.600000 2135.600000) nil) | 6@@list("R2343" "TX_R0402" list(1550.000000 1495.000000) nil) | 6@@list("R2344" "TX_R0402" list(915.000000 1260.000000) nil) | 6@@list("R2345" "TX_R0402_SHORT" list(737.000000 1893.000000) nil) | 6@@list("R2346" "TX_R0402_SHORT" list(934.000000 2103.000000) nil) | 6@@list("R2347" "TX_R0402" list(737.000000 1751.000000) nil) | 6@@list("R2348" "TX_R0402" list(1495.780000 2416.400000) nil) | 6@@list("R2349" "TX_R0402" list(1056.000000 1262.000000) nil) | 6@@list("R2351" "TX_R0402" list(1636.000000 1390.000000) nil) | 6@@list("R2400" "TX_R0402_SHORT" list(1221.000000 1237.000000) nil) | 6@@list("R2401" "TX_R0402_SHORT" list(494.000000 2190.000000) nil) | 6@@list("R2402" "TX_R0402_SHORT" list(495.000000 2259.000000) nil) | 6@@list("R2403" "TX_R0402_SHORT" list(316.000000 1012.000000) nil) | 6@@list("R2404" "TX_R0402_0OHM" list(479.000000 2418.000000) nil) | 6@@list("R2405" "TX_R0402" list(495.000000 2330.000000) nil) | 6@@list("R2406" "TX_R0402" list(653.000000 2278.000000) nil) | 6@@list("R2407" "TX_R0402" list(659.000000 2319.000000) nil) | 6@@list("R2408" "TX_R0402" list(653.000000 2237.000000) nil) | 6@@list("R2409" "TX_R0402_SHORT" list(866.000000 1212.000000) nil) | 6@@list("R2410" "TX_R0402_SHORT" list(891.000000 1171.000000) nil) | 6@@list("R2411" "TX_R0402" list(802.000000 1212.000000) nil) | 6@@list("R2412" "TX_R0402" list(1061.000000 2190.000000) nil) | 6@@list("R2413" "TX_R0402" list(1020.000000 2190.000000) nil) | 6@@list("R2414" "TX_R0402" list(991.000000 1056.000000) nil) | 6@@list("R2423" "TX_R0402" list(1007.000000 1258.000000) nil) | 6@@list("R2424" "TX_R0402" list(280.000000 1012.000000) nil) | 6@@list("R2500" "TX_R0402_0OHM" list(3493.000000 1115.650000) nil) | 6@@list("R2501" "TX_R0402" list(3581.000000 1452.650000) nil) | 6@@list("R2502" "TX_R0402" list(3654.000000 1452.650000) nil) | 6@@list("R2503" "TX_R0402" list(3730.000000 1452.650000) nil) | 6@@list("R2504" "TX_R0402" list(3508.000000 1452.650000) nil) | 6@@list("R2505" "TX_R0402" list(3544.500000 1452.650000) nil) | 6@@list("R2506" "TX_R0402" list(3617.500000 1452.650000) nil) | 6@@list("R2507" "TX_R0402" list(3693.000000 1452.650000) nil) | 6@@list("R2508" "TX_R0402" list(3767.000000 1452.650000) nil) | 6@@list("R2509" "TX_R0402" list(3420.000000 1122.650000) nil) | 6@@list("R2510" "TX_R0402_SHORT" list(3343.000000 1214.350000) nil) | 6@@list("R2511" "TX_R0402_SHORT" list(3494.000000 1279.000000) nil) | 6@@list("R2512" "TX_R0402" list(3457.000000 1122.650000) nil) | 6@@list("R2513" "TX_R0402" list(3346.000000 1144.650000) nil) | 6@@list("R2514" "TX_R0402" list(3383.000000 1124.650000) nil) | 6@@list("R2600" "TX_R0402" list(922.000000 3101.000000) nil) | 6@@list("R2601" "TX_R0402" list(656.000000 3128.000000) nil) | 6@@list("R2602" "TX_R0402" list(351.000000 3287.000000) nil) | 6@@list("R2900" "TX_R0402" list(813.000000 2747.000000) nil) | 6@@list("R2901" "TX_R0402" list(913.000000 2813.000000) nil) | 6@@list("R2903" "TX_R0402" list(622.000000 2821.000000) nil) | 6@@list("R2904" "TX_R0402" list(622.000000 2784.800000) nil) | 6@@list("R2905" "TX_R0402" list(654.000000 2729.000000) nil) | 6@@list("R2906" "TX_R0402" list(654.000000 2692.800000) nil) | 6@@list("R2907" "TX_R0402" list(654.000000 2633.000000) nil) | 6@@list("R2908" "TX_R0402" list(654.000000 2596.800000) nil) | 6@@list("R2909" "TX_R0402" list(655.990000 2912.000000) nil) | 6@@list("R2910" "TX_R0402" list(656.000000 2875.800000) nil) | 6@@list("R2911" "TX_R0402" list(385.000000 2905.000000) nil) | 6@@list("R2912" "TX_R0402" list(384.000000 2950.000000) nil) | 6@@list("R2913" "TX_R0402" list(957.000000 3024.000000) nil) | 6@@list("R3004" "TX_R0402_SHORT" list(2019.000000 4153.500000) nil) | 6@@list("R3009" "TX_R0402" list(2008.000000 4058.000000) nil) | 6@@list("R3102" "TX_R0402_0OHM" list(8424.000000 888.000000) nil) | 6@@list("R3103" "TX_R0402_SHORT" list(8445.000000 512.000000) nil) | 6@@list("R3104" "TX_R0402_SHORT" list(8521.000000 482.000000) nil) | 6@@list("R3105" "TX_R0402" list(8370.000000 429.000000) nil) | 6@@list("R3106" "TX_R0402_0OHM" list(8314.000000 411.000000) nil) | 6@@list("R3107" "TX_R0402" list(8370.000000 356.600000) nil) | 6@@list("R3113" "TX_R0402" list(8522.000000 445.000000) nil) | 6@@list("R3114" "TX_R0402" list(8370.000000 392.800000) nil) | 6@@list("R3116" "TX_R0402_0OHM" list(8505.000000 922.000000) nil) | 6@@list("R3609" "TX_R0402" list(2222.000000 1186.000000) nil) | 6@@list("R3612" "TX_R0402" list(2171.000000 1159.000000) nil) | 6@@list("R3613" "TX_R0402" list(3689.000000 3647.000000) nil) | 6@@list("R3614" "TX_R0402" list(3663.000000 3445.000000) nil) | 6@@list("R3700" "TX_R0402" list(5723.000000 1120.000000) nil) | 6@@list("R3701" "TX_R0402" list(5723.000000 1083.000000) nil) | 6@@list("R3702" "TX_R0402_SHORT" list(5872.000000 1272.000000) nil) | 6@@list("R3703" "TX_R0402" list(5723.000000 1046.000000) nil) | 6@@list("R3704" "TX_R0402_SHORT" list(5822.000000 1229.000000) nil) | 6@@list("R3705" "TX_R0402_SHORT" list(5723.000000 1211.000000) nil) | 6@@list("R3706" "TX_R0402_SHORT" list(5872.000000 1322.000000) nil) | 6@@list("R3707" "TX_R0402" list(125.000000 2472.000000) nil) | 6@@list("R3709" "TX_R0402" list(3497.000000 2056.000000) nil) | 6@@list("R3801" "TX_R0402" list(336.730000 1376.340000) nil) | 6@@list("R3804" "TX_R0402_0OHM" list(401.000000 1667.000000) nil) | 6@@list("R3806" "TX_R0603_0OHM_H24" list(-22.000000 877.480000) nil) | 6@@list("R3807" "TX_R0603_0OHM_H24" list(32.000000 877.480000) nil) | 6@@list("R3812" "TX_R0603_0OHM_H24" list(84.000000 876.480000) nil) | 6@@list("R3813" "TX_R0603_0OHM_H24" list(138.000000 876.480000) nil) | 6@@list("R3814" "TX_R0402" list(341.000000 1606.000000) nil) | 6@@list("R3815" "TX_R0402_0OHM" list(407.000000 2083.000000) nil) | 6@@list("R3816" "TX_R0402_0OHM" list(357.280000 1444.770000) nil) | 6@@list("R3817" "TX_R0402_0OHM" list(79.000000 1721.000000) nil) | 6@@list("R3819" "TX_R0402_0OHM" list(354.000000 2438.000000) nil) | 6@@list("R3821" "TX_R0402_0OHM" list(277.810000 1169.190000) nil) | 6@@list("R3826" "TX_R0402" list(271.000000 1106.000000) nil) | 6@@list("R3827" "TX_R0402_0OHM" list(401.040000 1704.320000) nil) | 6@@list("R3901" "TX_R0402_SHORT" list(1274.000000 2826.000000) nil) | 6@@list("R3902" "TX_R0402_SHORT" list(1186.000000 2506.000000) nil) | 6@@list("R3903" "TX_R0402_0OHM" list(1150.000000 2506.000000) nil) | 6@@list("R3904" "TX_R0402_0OHM" list(1353.000000 2615.000000) nil) | 6@@list("R3905" "TX_R0402_SHORT" list(1128.000000 2827.000000) nil) | 6@@list("R3907" "TX_R0402" list(1020.010000 2791.300000) nil) | 6@@list("R3908" "TX_R0402_SHORT" list(1020.010000 2718.500000) nil) | 6@@list("R3909" "TX_R0402" list(1009.010000 2682.000000) nil) | 6@@list("R3910" "TX_R0402" list(1076.000000 2506.010000) nil) | 6@@list("R3911" "TX_R0402" list(1114.000000 2506.000000) nil) | 6@@list("R3912" "TX_R0402_0OHM" list(1024.000000 2501.000000) nil) | 6@@list("R3913" "TX_R0402" list(1020.000000 2755.000000) nil) | 6@@list("R3914" "TX_R0402_0OHM" list(1353.000000 2579.000000) nil) | 6@@list("R3915" "TX_R0402_0OHM" list(1238.000000 2826.000000) nil) | 6@@list("R3916" "TX_R0402" list(1089.000000 2827.000000) nil) | 6@@list("R3917" "TX_R0402_0OHM" list(1323.500000 2843.000000) nil) | 6@@list("R3918" "TX_R0402_0OHM" list(1323.500000 2807.000000) nil) | 6@@list("R5000" "TX_R0402" list(289.000000 3878.000000) nil) | 6@@list("R5001" "TX_R0402" list(299.000000 3915.000000) nil) | 6@@list("R5002" "TX_R0402" list(730.000000 3793.000000) nil) | 6@@list("R5004" "TX_R0402" list(1028.000000 3928.000000) nil) | 6@@list("R5102" "TX_R0402" list(1943.500000 565.000000) nil) | 6@@list("R5103" "TX_R0402" list(1825.990000 565.000000) nil) | 6@@list("R5104" "TX_R0402" list(1862.500000 565.000000) nil) | 6@@list("R5105" "TX_R0402" list(2053.400000 565.000000) nil) | 6@@list("R5106" "TX_R0402" list(2125.800000 565.000000) nil) | 6@@list("R5107" "TX_R0402" list(1480.000000 520.000000) nil) | 6@@list("R5108" "TX_R0402" list(1980.000000 565.000000) nil) | 6@@list("R5109" "TX_R0402_SHORT" list(1477.000000 590.000000) nil) | 6@@list("R5704" "TX_R0402" list(663.930000 3313.460000) nil) | 6@@list("R5705" "TX_R0402" list(685.500000 3263.000000) nil) | 6@@list("R5706" "TX_R0402_0OHM" list(777.000000 3302.000000) nil) | 6@@list("R5707" "TX_R0402" list(740.000000 3302.000000) nil) | 6@@list("R5710" "TX_R0402" list(833.000000 3707.000000) nil) | 6@@list("R5711" "TX_R0402" list(762.000000 3707.000000) nil) | 6@@list("R5714" "TX_R0402_SHORT" list(926.000000 3300.000000) nil) | 6@@list("R5716" "TX_R0402_0OHM" list(1170.000000 3408.000000) nil) | 6@@list("R5717" "TX_R0402" list(1090.000000 3368.000000) nil) | 6@@list("R5718" "TX_R0402" list(1090.000000 3408.000000) nil) | 6@@list("R5719" "TX_R0402_SHORT" list(885.000000 3704.000000) nil) | 6@@list("R5720" "TX_R0402_0OHM" list(1170.000000 3368.000000) nil) | 6@@list("R5725" "TX_R0402" list(751.000000 3670.000000) nil) | 6@@list("R5800" "TX_R0402" list(824.000000 2582.000000) nil) | 6@@list("R5801" "TX_R0402_SHORT" list(824.000000 2647.000000) nil) | 6@@list("R5802" "TX_R0402" list(1578.000000 3440.000000) nil) | 6@@list("R5803" "TX_R0402" list(1430.000000 3526.000000) nil) | 6@@list("R5804" "TX_R0402" list(1430.000000 3489.500000) nil) | 6@@list("R5805" "TX_R0402_SHORT" list(1245.000000 3465.000000) nil) | 6@@list("R5806" "TX_R0402" list(1286.000000 3465.000000) nil) | 6@@list("R5807" "TX_R0402" list(1197.000000 3275.000000) nil) | 6@@list("R5808" "TX_R0402" list(1488.000000 3108.000000) nil) | 6@@list("R5809" "TX_R0402" list(1613.000000 3208.000000) nil) | 6@@list("R5810" "TX_R0402" list(1323.000000 3465.000000) nil) | 6@@list("R5811" "TX_R0402" list(1360.000000 3465.000000) nil) | 6@@list("R5812" "TX_R0402" list(1366.000000 3526.500000) nil) | 6@@list("R5816" "TX_R0402_0OHM" list(1405.000000 3060.000000) nil) | 6@@list("R5817" "TX_R0402" list(1136.000000 3820.000000) nil) | 6@@list("R5818" "TX_R0402" list(1158.500000 3150.000000) nil) | 6@@list("R5821" "TX_R0402" list(1202.000000 3311.000000) nil) | 6@@list("R5822" "TX_R0402" list(1197.000000 3203.000000) nil) | 6@@list("R5823" "TX_R0402" list(1197.000000 3239.000000) nil) | 6@@list("R5826" "TX_R0402" list(1518.000000 3466.000000) nil) | 6@@list("R5827" "TX_R0402" list(1481.000000 3466.000000) nil) | 6@@list("R5904" "TX_R0402" list(457.000000 3749.000000) nil) | 6@@list("R5906" "TX_R0402" list(570.000000 3749.000000) nil) | 6@@list("R5907" "TX_R0402" list(283.000000 3795.000000) nil) | 6@@list("R6200" "TX_R0402" list(5945.000000 3938.000000) nil) | 6@@list("R6202" "TX_R0402" list(5895.000000 3914.000000) nil) | 6@@list("R6203" "TX_R0402" list(5895.000000 3951.000000) nil) | 6@@list("R6204" "TX_R0402" list(5813.000000 3820.000000) nil) | 6@@list("R6205" "TX_R0402" list(5762.000000 3817.000000) nil) | 6@@list("R6206" "TX_R0402" list(5831.000000 3934.000000) nil) | 6@@list("R6207" "TX_R0402" list(5762.000000 3854.000000) nil) | 6@@list("R6300" "TX_R0402" list(6889.000000 3324.000000) nil) | 6@@list("R6301" "TX_R0402" list(6888.000000 3453.000000) nil) | 6@@list("R6302" "TX_R0402" list(6889.000000 3361.000000) nil) | 6@@list("R6308" "TX_R0402" list(6370.000000 3302.500000) nil) | 6@@list("R6309" "TX_R0402" list(6387.000000 3239.500000) nil) | 6@@list("R6803" "TX_R0402" list(7063.000000 4080.000000) nil) | 6@@list("R6805" "TX_R0402" list(7689.990000 3328.000000) nil) | 6@@list("R6808" "TX_R0402" list(7002.000000 4144.000000) nil) | 6@@list("R6809" "TX_R0402" list(7039.000000 4144.000000) nil) | 6@@list("R6818" "TX_R0402" list(7678.000000 3243.000000) nil) | 6@@list("R6908" "TX_R0402_0OHM" list(6271.000000 3482.000000) nil) | 6@@list("R6934" "TX_R0402" list(6108.000000 3452.990000) nil) | 6@@list("R6935" "TX_R0402" list(6138.000000 3482.990000) nil) | 6@@list("R6936" "TX_R0402" list(6426.000000 3390.000000) nil) | 6@@list("R6937" "TX_R0402" list(5372.000000 3451.000000) nil) | 6@@list("R6938" "TX_R0402" list(5786.000000 3152.000000) nil) | 6@@list("R6939" "TX_R0402" list(5697.000000 4355.000000) nil) | 6@@list("R6940" "TX_R0402" list(5659.000000 4355.000000) nil) | 6@@list("R6941" "TX_R0402" list(5418.000000 3401.000000) nil) | 6@@list("RN5701" "TX_2R4P0402_47X55_COLAY" list(321.000000 3729.000000) nil) | 6@@list("RN5702" "TX_2R4P0402_47X55_COLAY" list(491.000000 3619.000000) nil) | 6@@list("RN5703" "TX_2R4P0402_47X55_COLAY" list(473.000000 3353.000000) nil) | 6@@list("RN5704" "TX_2R4P0402_47X55_COLAY" list(509.000000 3535.000000) nil) | 6@@list("RN5705" "TX_2R4P0402_47X55_COLAY" list(647.000000 3461.000000) nil) | 6@@list("T0400" "NB_TPC26T_50" list(4797.000000 2844.500000) nil) | 6@@list("T0401" "NB_TPC26T_50" list(5269.000000 2754.000000) nil) | 6@@list("T0402" "NB_TPC26T_50" list(5267.000000 2819.000000) nil) | 6@@list("T0403" "NB_TPC26T_50" list(5320.000000 2829.000000) nil) | 6@@list("T0405" "NB_TPC26T_50" list(4858.000000 2786.500000) nil) | 6@@list("T0406" "NB_TPC26T_50" list(4760.500000 2775.500000) nil) | 6@@list("T0409" "NB_TPC26T_50" list(4671.000000 1270.000000) nil) | 6@@list("T0411" "NB_TPC26T_50" list(4792.000000 2719.000000) nil) | 6@@list("T0412" "NB_TPC26T_50" list(4807.500000 2795.000000) nil) | 6@@list("T0902" "NB_TPC26T_50" list(4104.750000 2841.410000) nil) | 6@@list("T0903" "NB_TPC26T_50" list(5268.000000 2877.000000) nil) | 6@@list("T0905" "NB_TPC26T_50" list(4045.000000 2811.000000) nil) | 6@@list("T0908" "NB_TPC26T_50" list(4859.320000 3370.040000) nil) | 6@@list("T0909" "NB_TPC26T_50" list(4888.320000 3434.040000) nil) | 6@@list("T0910" "NB_TPC26T_50" list(4770.320000 3274.040000) nil) | 6@@list("T0911" "NB_TPC26T_50" list(4749.320000 3373.040000) nil) | 6@@list("T0912" "NB_TPC26T_50" list(4788.320000 3421.040000) nil) | 6@@list("T0913" "NB_TPC26T_50" list(4844.320000 3473.040000) nil) | 6@@list("T0914" "NB_TPC26T_50" list(4742.320000 3473.040000) nil) | 6@@list("T0915" "NB_TPC26T_50" list(4762.320000 3324.040000) nil) | 6@@list("T0916" "NB_TPC26T_50" list(4738.320000 3422.040000) nil) | 6@@list("T0917" "NB_TPC26T_50" list(4793.320000 3472.040000) nil) | 6@@list("T0918" "NB_TPC26T_50" list(4896.320000 3336.040000) nil) | 6@@list("T0919" "NB_TPC26T_50" list(4908.320000 3386.040000) nil) | 6@@list("T0920" "NB_TPC26T_50" list(4839.320000 3420.040000) nil) | 6@@list("T0921" "NB_TPC26T_50" list(4809.320000 3371.040000) nil) | 6@@list("T1002" "NB_TPC26T_50" list(3977.000000 2025.000000) nil) | 6@@list("T1003" "NB_TPC26T_50" list(3514.000000 1880.000000) nil) | 6@@list("T1005" "NB_TPC26T_50" list(4720.000000 2507.000000) nil) | 6@@list("T1006" "NB_TPC26T_50" list(4707.000000 2557.000000) nil) | 6@@list("T1105" "NB_TPC26T_50" list(3499.000000 1555.000000) nil) | 6@@list("T1106" "NB_TPC26T_50" list(4046.000000 1500.000000) nil) | 6@@list("T1107" "NB_TPC26T_50" list(4309.910000 1155.900000) nil) | 6@@list("T1203" "NB_TPC26T_50" list(4214.000000 1915.000000) nil) | 6@@list("T1204" "NB_TPC26T_50" list(3461.000000 1471.000000) nil) | 6@@list("T1205" "NB_TPC26T_50" list(3324.000000 1374.000000) nil) | 6@@list("T1207" "NB_TPC26T_50" list(3400.000000 1818.000000) nil) | 6@@list("T1400" "NB_TPC26T_50" list(4853.000000 2701.000000) nil) | 6@@list("T1500" "NB_TPC26T_50" list(3488.000000 1832.000000) nil) | 6@@list("T1504" "NB_TPC26T_50" list(4487.000000 1234.000000) nil) | 6@@list("T1505" "NB_TPC26T_50" list(4370.000000 1417.000000) nil) | 6@@list("T1509" "NB_TPC26T_50" list(4520.000000 1150.000000) nil) | 6@@list("T1510" "NB_TPC26T_50" list(4101.710000 1509.310000) nil) | 6@@list("T1511" "NB_TPC26T_50" list(4020.000000 1456.000000) nil) | 6@@list("T1512" "NB_TPC26T_50" list(4197.000000 1173.000000) nil) | 6@@list("T1513" "NB_TPC26T_50" list(4500.000000 1925.500000) nil) | 6@@list("T2300" "TPC40T_68" list(1439.000000 1325.000000) nil) | 6@@list("T2301" "TPC40T_68" list(757.000000 1947.000000) nil) | 6@@list("T2302" "TPC40T_68" list(672.000000 1833.000000) nil) | 6@@list("T2303" "TPC40T_68" list(1573.000000 1380.000000) nil) | 6@@list("T2305" "TPC40T_68" list(1465.000000 1389.000000) nil) | 6@@list("T2306" "TPC40T_68" list(1514.000000 1334.000000) nil) | 6@@list("T2307" "TPC40T_68" list(1254.000000 1294.000000) nil) | 6@@list("T2308" "TPC40T_68" list(790.470000 1378.620000) nil) | 6@@list("T3600" "TPC40T_68" list(3786.000000 757.000000) nil) | 6@@list("T5700" "MX_TPC26T_S4_68" list(666.000000 3560.500000) nil) | 6@@list("T5701" "MX_TPC26T_S4_68" list(627.000000 3631.000000) nil) | 6@@list("T5801" "MX_TPC26T_S4_68" list(1153.000000 3517.000000) nil) | 6@@list("T6300" "MX_TPC26T_S4_68" list(6276.000000 3309.000000) nil) | 6@@list("T6301" "MX_TPC26T_S4_68" list(6447.000000 3439.000000) nil) | 6@@list("T6302" "NB_TPC26T_50" list(6437.000000 3915.000000) nil) | 6@@list("T6303" "NB_TPC26T_50" list(6401.000000 3628.000000) nil) | 6@@list("T6900" "NB_TPC26T_50" list(6364.000000 3426.000000) nil) | 6@@list("T6905" "NB_TPC26T_50" list(6034.000000 2975.000000) nil) | 6@@list("T6906" "NB_TPC26T_50" list(5672.000000 3258.000000) nil) | 6@@list("T6907" "NB_TPC26T_50" list(5634.000000 3295.000000) nil) | 6@@list("T6908" "NB_TPC26T_50" list(5845.000000 3129.000000) nil) | 6@@list("T6909" "NB_TPC26T_50" list(5711.000000 3221.000000) nil) | 6@@list("T6910" "NB_TPC26T_50" list(5762.000000 3198.000000) nil) | 6@@list("T6911" "NB_TPC26T_50" list(5887.000000 3093.000000) nil) | 6@@list("T6912" "NB_TPC26T_50" list(5927.000000 3001.000000) nil) | 6@@list("T6913" "NB_TPC26T_50" list(5926.000000 3054.000000) nil) | 6@@list("T6915" "NB_TPC26T_50" list(5978.000000 2954.000000) nil) | 6@@list("T6916" "NB_TPC26T_50" list(5927.000000 2948.000000) nil) | 6@@list("T6917" "NB_TPC26T_50" list(5979.000000 3004.000000) nil) | 6@@list("T6925" "NB_TPC26T_50" list(6223.000000 3387.000000) nil) | 6@@list("T6926" "NB_TPC26T_50" list(6270.000000 3368.000000) nil) | 6@@list("T6927" "NB_TPC26T_50" list(5597.000000 3258.000000) nil) | 6@@list("T6928" "NB_TPC26T_50" list(6105.000000 3614.000000) nil) | 6@@list("T6929" "NB_TPC26T_50" list(5608.000000 3208.000000) nil) | 6@@list("T6935" "NB_TPC26T_50" list(6178.000000 3417.000000) nil) | 6@@list("T6937" "NB_TPC26T_50" list(5555.000000 3230.000000) nil) | 6@@list("T6938" "NB_TPC26T_50" list(5489.000000 3393.000000) nil) | 6@@list("T6940" "NB_TPC26T_50" list(5699.000000 3891.000000) nil) | 6@@list("T6941" "NB_TPC26T_50" list(6173.000000 3501.000000) nil) | 6@@list("T6943" "NB_TPC26T_50" list(6789.000000 3062.000000) nil) | 6@@list("T6944" "NB_TPC26T_50" list(6226.000000 3483.000000) nil) | 6@@list("T6945" "NB_TPC26T_50" list(6780.000000 3003.000000) nil) | 6@@list("T6946" "NB_TPC26T_50" list(6780.000000 2928.000000) nil) | 6@@list("TR3700" "TX_R0402_H24" list(3953.000000 2078.000000) nil) | 6@@list("U2500" "A_BGA_153P_20_516X457_H39" list(3756.730000 1121.270000) nil) | 6@@list("U3701" "TX_LGA_12P_20_87X87_ST" list(5848.000000 1100.000000) nil) | 6@@list("U3901" "A_QFN_32P_20_S197_PAD_T01" list(1185.900000 2667.900000) nil) | 6@@list("U5703" "TX_QFN_40P_16_161X240_PD_8V" list(840.650000 3509.630000) nil) | 6@@list("U5800" "TX_QFN_40P_20_S240_P_4V" list(1380.000000 3275.000000) nil) | 6@@list("U6801" "TX_BGA_170P_31_555X476" list(7370.000000 4135.000000) nil) | 6@@list("U6803" "TX_BGA_170P_31_555X476" list(7370.410000 3387.730000) nil) | 6@@list("X1001" "TX_XTAL_2P_126X59" list(3368.060000 1914.000000) nil) | 6@@list("X2300" "TX_XTAL_2P_126X59" list(1597.310000 2043.490000) nil) | 7@@list("U2300" "TX_QFP_128P_16_559X559" list(1155.000000 1675.000000) nil) | 9@@list("" "INDEXB_CROSS" list(1125.000000 485.000000) t) | 9@@list("" "INDEXB_CROSS" list(7804.000000 4283.990000) t) | 9@@list("" "INDEXB_CROSS" list(8156.010000 1138.930000) t) | 9@@list("C0400" "TX_C0402" list(5056.000000 3227.000000) t) | 9@@list("C0500" "TX_C0402" list(3515.450000 4545.940000) t) | 9@@list("C0607" "TX_C0402" list(5064.000000 1200.800000) t) | 9@@list("C0608" "TX_C0402" list(5027.000000 1200.800000) t) | 9@@list("C0707" "TX_C0402" list(5008.000000 2205.000000) t) | 9@@list("C0708" "TX_C0402" list(5211.710000 2683.280000) t) | 9@@list("C0709" "TX_C0402" list(5212.000000 2574.000000) t) | 9@@list("C0710" "TX_C0402" list(4943.280000 2205.290000) t) | 9@@list("C0713" "TX_C0402" list(5196.000000 2485.000000) t) | 9@@list("C0714" "TX_C0402" list(5202.000000 2139.000000) t) | 9@@list("C0715" "TX_C0402" list(5211.710000 2646.780000) t) | 9@@list("C0716" "TX_C0402" list(5202.000000 2102.000000) t) | 9@@list("C0734" "TX_C0402" list(5212.000000 2538.000000) t) | 9@@list("C0735" "TX_C0402" list(5212.000000 2610.000000) t) | 9@@list("C0736" "TX_C0402" list(5202.000000 2176.000000) t) | 9@@list("C0737" "TX_C0402" list(5151.000000 2202.000000) t) | 9@@list("C0738" "TX_C0402" list(5113.050000 2201.600000) t) | 9@@list("C0739" "TX_C0402" list(5045.000000 2205.000000) t) | 9@@list("C0900" "TX_C0402" list(4788.000000 1325.000000) t) | 9@@list("C0901" "TX_C0402" list(4915.000000 1331.000000) t) | 9@@list("C1000" "TX_C0402" list(5007.000000 2273.000000) t) | 9@@list("C1001" "TX_C0402" list(5007.060000 2401.000000) t) | 9@@list("C1004" "TX_C0402" list(3609.020000 1996.000000) t) | 9@@list("C1005" "TX_C0402" list(4148.000000 1115.000000) t) | 9@@list("C1006" "TX_C0402" list(4066.000000 1131.000000) t) | 9@@list("C1104" "TX_C0402" list(3752.000000 1452.000000) t) | 9@@list("C1105" "TX_C0402" list(3678.000000 1452.000000) t) | 9@@list("C1200" "TX_C0402" list(3769.000000 1314.000000) t) | 9@@list("C1203" "TX_C0402" list(3706.000000 1879.000000) t) | 9@@list("C1206" "TX_C0402" list(3650.000000 888.000000) t) | 9@@list("C1207" "TX_C0402" list(3628.000000 1273.000000) t) | 9@@list("C1604" "TX_C0402" list(4389.510000 1249.010000) t) | 9@@list("C1607" "TX_C0603_T02_H39" list(4974.000000 1331.000000) t) | 9@@list("C1609" "TX_C0603_T02_H39" list(5087.000000 1419.800000) t) | 9@@list("C1610" "TX_C0402" list(4946.000000 1439.500000) t) | 9@@list("C1616" "TX_C0603_T02_H39" list(5012.620000 1528.000000) t) | 9@@list("C1617" "TX_C0402" list(3715.000000 1452.000000) t) | 9@@list("C1627" "TX_C0603_T02_H39" list(5234.000000 1490.000000) t) | 9@@list("C1628" "TX_C0603_T02_H39" list(4238.000000 1036.000000) t) | 9@@list("C1631" "TX_C0402" list(4344.000000 1195.000000) t) | 9@@list("C1633" "TX_C0603_T02_H39" list(4281.000000 1264.000000) t) | 9@@list("C1634" "TX_C0603_T02_H39" list(4562.000000 1369.000000) t) | 9@@list("C1900" "TX_C0402" list(3909.000000 962.000000) t) | 9@@list("C1901" "TX_C0402" list(509.000000 2190.000000) t) | 9@@list("C1902" "TX_C0402" list(568.000000 1962.000000) t) | 9@@list("C2900" "TX_C0402" list(653.000000 2729.200000) t) | 9@@list("C2901" "TX_C0402" list(656.000000 2912.000000) t) | 9@@list("C2902" "TX_C0402" list(654.000000 2632.200000) t) | 9@@list("C2903" "TX_C0402" list(654.000000 2596.000000) t) | 9@@list("C2904" "TX_C0402" list(622.000000 2822.000000) t) | 9@@list("C2905" "TX_C0402" list(656.000000 2875.800000) t) | 9@@list("C2906" "TX_C0402" list(653.000000 2693.000000) t) | 9@@list("C2907" "TX_C0402" list(622.000000 2785.800000) t) | 9@@list("C3000" "TX_C0402_T02_H26" list(1784.000000 4126.000000) t) | 9@@list("C3001" "TX_C0402" list(2184.500000 4125.500000) t) | 9@@list("C3002" "TX_C0402" list(2146.000000 4106.000000) t) | 9@@list("C3004" "TX_C0402" list(2540.000000 4152.600000) t) | 9@@list("C3005" "TX_C0402" list(2502.000000 4152.600000) t) | 9@@list("C3006" "TX_C0402" list(2465.000000 4101.100000) t) | 9@@list("C3007" "TX_C0402" list(2428.800000 4101.100000) t) | 9@@list("C3008" "TX_C0402" list(2352.000000 4138.600000) t) | 9@@list("C3009" "TX_C0402" list(2388.200000 4138.600000) t) | 9@@list("C3010" "TX_C0402" list(1525.000000 4151.000000) t) | 9@@list("C3011" "TX_C0402" list(2230.000000 4121.000000) t) | 9@@list("C3104" "TX_C0402" list(8142.000000 995.000000) t) | 9@@list("C3105" "TX_C0402" list(8136.000000 958.900000) t) | 9@@list("C3106" "TX_C0402" list(8199.000000 943.000000) t) | 9@@list("C3107" "TX_C0402" list(8197.000000 907.000000) t) | 9@@list("C3120" "TX_C0402" list(4579.000000 811.000000) t) | 9@@list("C3121" "TX_C0402" list(4578.790000 775.000000) t) | 9@@list("C3122" "TX_C0402" list(4579.000000 738.210000) t) | 9@@list("C3123" "TX_C0402" list(4579.000000 702.000000) t) | 9@@list("C3124" "TX_C0603_T02_H39" list(4127.000000 894.000000) t) | 9@@list("C3125" "TX_C0402" list(4189.000000 926.000000) t) | 9@@list("C3127" "TX_C0603_T02_H39" list(4075.000000 894.000000) t) | 9@@list("C3600" "TX_C0402" list(8012.000000 3624.000000) t) | 9@@list("C3601" "TX_C0402" list(8012.000000 3662.000000) t) | 9@@list("C3602" "TX_C0402" list(7880.000000 2730.000000) t) | 9@@list("C3603" "TX_C0402" list(8012.000000 3741.000000) t) | 9@@list("C3604" "TX_C0402" list(5381.780000 995.000000) t) | 9@@list("C3700" "TX_C0402" list(4763.000000 3775.000000) t) | 9@@list("C3706" "TX_C0402" list(7836.000000 4425.000000) t) | 9@@list("C3800" "TX_C0402_T02_H28" list(649.180000 1481.150000) t) | 9@@list("C3802" "TX_C0402_T02_H28" list(497.000000 1191.000000) t) | 9@@list("C3803" "TX_C0402" list(509.000000 1229.000000) t) | 9@@list("C3808" "TX_C0805_T02_H55" list(335.000000 1843.000000) t) | 9@@list("C3809" "TX_C0805_T02_H55" list(261.000000 1843.000000) t) | 9@@list("C3810" "TX_C0402" list(12.500000 1816.000000) t) | 9@@list("C3811" "TX_C0402" list(-10.000000 2380.000000) t) | 9@@list("C3812" "TX_C0402" list(359.500000 2207.500000) t) | 9@@list("C3813" "TX_C0402" list(254.000000 2384.000000) t) | 9@@list("C3814" "TX_C0402" list(632.000000 1290.000000) t) | 9@@list("C3815" "TX_C0402_T02_H28" list(244.780000 1422.210000) t) | 9@@list("C3816" "TX_C0402" list(683.060000 1316.020000) t) | 9@@list("C3819" "TX_C0402_T02_H28" list(341.500000 1606.500000) t) | 9@@list("C3820" "TX_C0402" list(364.000000 1660.000000) t) | 9@@list("C3822" "TX_C0402" list(341.460000 1567.660000) t) | 9@@list("C3825" "TX_C0402_T02_H28" list(335.460000 1214.950000) t) | 9@@list("C3826" "TX_C0402" list(374.280000 1214.950000) t) | 9@@list("C3827" "TX_C0402_T02_H28" list(462.080000 1666.830000) t) | 9@@list("C3828" "TX_C0402" list(424.080000 1666.830000) t) | 9@@list("C3829" "TX_C0402_T02_H28" list(298.320000 1660.000000) t) | 9@@list("C3830" "TX_C0402" list(232.000000 1302.000000) t) | 9@@list("C3831" "TX_C0402" list(290.000000 1279.000000) t) | 9@@list("C3833" "TX_C0402" list(648.070000 1563.620000) t) | 9@@list("C3834" "TX_C0402" list(262.000000 1169.000000) t) | 9@@list("C3839" "TX_C0402" list(649.180000 1443.130000) t) | 9@@list("C3840" "TX_C0402" list(647.710000 1602.370000) t) | 9@@list("C3841" "TX_C0402" list(356.000000 2430.000000) t) | 9@@list("C3842" "TX_C0402" list(89.000000 2426.000000) t) | 9@@list("C3843" "TX_C0402" list(262.000000 1103.000000) t) | 9@@list("C5100" "TX_C0402" list(3036.170000 809.090000) t) | 9@@list("C5101" "TX_C0402" list(3108.350000 809.010000) t) | 9@@list("C5102" "TX_C0402" list(3072.170000 809.090000) t) | 9@@list("C5103" "TX_C0402" list(2962.350000 805.010000) t) | 9@@list("C5104" "TX_C0402" list(3180.350000 809.010000) t) | 9@@list("C5105" "TX_C0402" list(2345.360000 838.690000) t) | 9@@list("C5106" "TX_C0402" list(3217.170000 809.090000) t) | 9@@list("C5107" "TX_C0402" list(2382.360000 838.690000) t) | 9@@list("C5108" "TX_C0402" list(2495.360000 837.6900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