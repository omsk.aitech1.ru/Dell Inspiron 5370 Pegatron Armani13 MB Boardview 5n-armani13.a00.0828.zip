# Allegro board 5n-armani13.a00.0828.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE6_WLAN_RXP: length 118.3
  IN1 w0.109: v3(123.6,43.1) 123.6,43.14 123.19,43.55 122.87,43.55 122.63,43.31 122.63,42.46 120.99,40.82 120.65,40.82 120.26,40.43 120.26,34.86 121.58,33.55 124.09,33.55 125.03,32.62 128.09,32.62 129.41,31.29 134.09,31.29 136.21,29.17 136.21,26.92 138.23,24.9 143.23,24.9 144.31,23.82 146.67,23.82 147.58,22.91 149.44,22.91 152.64,19.71 155.69,19.71 158.26,17.13 163.26,17.13 164.79,15.6 178.84,15.6 179.2,15.25 194.57,15.25 200.81,21.49 200.81,28.55 201.34,29.08 201.34,29.08 201.56,29.29 201.9,29.29 202.11,29.08 202.63,29.08 202.88,29.33 202.88,30.42 v5(203.1,30.63)
  BOTTOM w0.102: CON5103.17 205.6,31.26 205.46,31.4 204.93,31.4 204.39,30.86 203.33,30.86 v5(203.1,30.63) ; v3(123.6,43.1) 123.6,43 123.69,42.92 U0400.F18
PCIE6_WLAN_TXN: length 106.2
  IN1 w0.109: v1(140.16,30.91) 140.34,30.91 145.05,26.2 154.51,26.2 159.3,21.41 162.13,21.41 165.85,17.69 179.71,17.69 180.06,17.34 185.57,17.34 188.19,19.96 188.19,25.28 192.25,29.34 199.24,29.34 v1(201.98,32.08)
  BOTTOM w0.102: v1(140.16,30.91) 140.39,31.14 140.39,31.55 139.65,32.29 138.99,32.29 138.28,33 138.28,35.05 ; v1(201.98,32.08) 202.74,32.08 C5134.2 ; 138.28,35.05 138.28,38.47 136.98,39.77 136.98,42.96 133.54,46.41 132.39,46.41 131.67,45.7 130.77,45.7 130.43,45.36 130.43,45.06 129.77,44.4 128.93,44.4 128.84,44.31 127.11,44.31 126.77,43.97 126.52,43.97 126.47,43.92 126.19,43.92 125.88,44.23 U0400.D20 ; 138.28,35.05 v2(138.05,35.05)
PCIE6_WLAN_TXN_C: length 2.4
  BOTTOM w0.102: CON5103.20 205.6,32.76 205.45,32.6 204.96,32.6 204.46,32.11 204.29,32.11 C5134.1
PCIE6_WLAN_TXP: length 106.2
  IN1 w0.109: v1(140.34,30.33) 140.62,30.33 144.96,25.99 154.42,25.99 159.21,21.2 162.04,21.2 165.76,17.48 179.62,17.48 179.98,17.12 185.66,17.12 188.4,19.87 188.4,25.19 192.34,29.13 199.32,29.13 201.72,31.52 v1(202.24,31.52)
  BOTTOM w0.102: v1(140.34,30.33) 140.59,30.58 140.59,31.63 139.73,32.49 139.07,32.49 138.48,33.08 138.48,33.45 ; v2(138.74,33.45) 138.48,33.45 ; 138.48,33.45 138.48,38.56 137.19,39.86 137.19,43.05 133.62,46.61 132.3,46.61 131.59,45.9 130.68,45.9 130.23,45.44 130.23,45.15 129.68,44.6 128.85,44.6 128.75,44.51 127.03,44.51 126.69,44.17 126.37,44.17 U0400.C20 ; C5133.2 202.74,31.88 202.38,31.88 202.24,31.74 v1(202.24,31.52)
PCIE6_WLAN_TXP_C: length 2.4
  BOTTOM w0.102: C5133.1 204.34,31.9 204.55,31.9 205.04,32.4 205.45,32.4 205.59,32.26 CON5103.19
PCIE9_SSD1_RXN: length 139.4
  IN3 w0.127: v3(124.28,45.95) 124.42,46.09 124.42,46.36 124.74,46.69 126.35,46.69 126.68,47.02 127.94,47.02 128.98,45.98 130.1,45.98 130.58,45.49 130.58,44.69 129.69,43.79 127.88,43.79 127.56,43.47 127.56,42.92 127.81,42.67 129.77,42.67 130.42,42.02 131.92,42.02 133.78,40.16 134.82,40.16 136.73,38.25 136.73,35.89 134.28,33.44 134.28,31.74 137.08,28.93 137.08,25.99 137.41,25.66 137.41,21.19 136.28,20.06 136.28,14.34 137.97,12.66 142.99,12.66 143.92,13.59 147.17,13.59 148.19,14.61 151.1,14.61 151.22,14.48 155.77,14.48 156.41,13.83 163,13.83 165.8,11.04 181.29,11.04 182.02,10.31 202.23,10.31 203.86,11.93 203.86,14.12 208.29,18.54 v1(209.22,18.54)
  BOTTOM w0.102: U0400.E22 124.57,45.66 v3(124.28,45.95) ; CON3100.5 215.28,19.85 215.13,19.7 214.77,19.7 214.48,19.41 213.11,19.41 212.99,19.52 211.39,19.52 211.02,19.15 210.86,19.15 209.97,18.27 209.5,18.27 v1(209.22,18.54)
PCIE9_SSD1_RXP: length 139.4
  IN3 w0.127: v1(209.14,17.91) 208.74,18.32 208.38,18.32 204.09,14.02 204.09,11.84 202.33,10.08 181.92,10.08 181.19,10.81 165.7,10.81 162.91,13.6 156.32,13.6 155.67,14.25 151.13,14.25 151,14.38 148.29,14.38 147.27,13.36 144.02,13.36 143.08,12.43 137.87,12.43 136.06,14.25 136.06,20.15 137.19,21.28 137.19,25.56 136.86,25.89 136.86,28.84 134.05,31.65 134.05,33.53 136.5,35.99 136.5,38.16 134.73,39.93 133.68,39.93 131.82,41.79 130.33,41.79 129.67,42.45 127.71,42.45 127.33,42.83 127.33,43.56 127.79,44.02 129.59,44.02 130.35,44.78 130.35,45.4 130,45.75 128.89,45.75 127.85,46.79 126.77,46.79 126.44,46.46 124.84,46.46 124.64,46.27 124.64,46.17 v3(124.86,45.95)
  BOTTOM w0.102: v3(124.86,45.95) 124.97,46.06 124.97,46.33 124.87,46.43 124.67,46.43 U0400.E23 ; CON3100.7 215.25,19.35 215.1,19.5 214.86,19.5 214.56,19.2 213.02,19.2 212.91,19.32 211.48,19.32 211.11,18.95 210.95,18.95 210.06,18.06 209.3,18.06 v1(209.14,17.91)
PCIE9_SSD1_TXN: length 128.5
  IN3 w0.127: v3(128.55,47.14) 129.29,46.41 130.35,46.41 131.01,45.75 131.01,44.5 130.23,43.72 130.23,42.83 130.61,42.45 132.1,42.45 133.88,40.67 134.93,40.67 137.16,38.43 137.16,35 136.61,34.44 135.89,34.44 134.72,33.27 134.72,31.93 138.2,28.45 138.2,26.79 138.01,26.6 138.01,21.09 136.83,19.91 136.83,14.71 138.45,13.09 142.4,13.09 144.07,14.76 147.73,14.76 148.34,15.37 155.49,15.37 156.59,14.26 163.18,14.26 165.98,11.47 181.46,11.47 182.2,10.74 199.86,10.74 208.23,19.1 210.44,19.1 211.02,18.52 211.02,18.09 210.85,17.91 v1(210.57,17.91)
  BOTTOM w0.102: v3(128.55,47.15) 128.37,46.97 128.09,46.97 127.69,46.56 127.28,46.56 126.86,46.14 U0400.B23 ; v1(210.57,17.91) 210.82,17.91 C3104.1
PCIE9_SSD1_TXN_C: length 3.6
  BOTTOM w0.102: CON3100.11 215.07,18.35 214.96,18.24 213.18,18.24 C3104.2
PCIE9_SSD1_TXP: length 128.4
  IN3 w0.127: v3(129.24,47.09) 129.24,46.78 129.38,46.64 130.45,46.64 131.24,45.84 131.24,44.41 130.45,43.62 130.45,42.93 130.7,42.68 132.19,42.68 133.98,40.9 135.02,40.9 137.39,38.53 137.39,34.9 136.7,34.22 135.99,34.22 134.95,33.18 134.95,32.02 138.43,28.55 138.43,26.7 138.24,26.51 138.24,21 137.06,19.81 137.06,14.8 138.55,13.32 142.3,13.32 143.97,14.99 147.64,14.99 148.25,15.6 155.58,15.6 156.69,14.49 163.28,14.49 166.07,11.7 181.56,11.7 182.29,10.97 199.77,10.97 208.13,19.33 210.54,19.33 211.25,18.62 211.25,17.99 210.74,17.48 v1(210.74,17.33)
  BOTTOM w0.102: v1(210.74,17.33) 210.97,17.55 210.97,17.77 211.11,17.91 C3105.1 ; v3(129.24,47.09) 128.91,46.76 128.18,46.76 127.77,46.36 127.36,46.36 127.3,46.29 U0400.A23
PCIE9_SSD1_TXP_C: length 3.6
  BOTTOM w0.102: CON3100.13 215.07,17.85 214.88,18.04 212.58,18.04 C3105.2
PCIE10_SSD1_RXN: length 125.1
  IN3 w0.127: v3(124.28,47.68) 124.84,47.12 126.16,47.12 126.82,47.79 126.82,48.19 127.89,49.25 130.78,49.25 135.14,44.9 135.14,43.28 139.14,39.28 139.14,34.56 142.98,30.73 142.98,29.56 146.76,25.77 146.76,20.79 147.19,20.36 147.19,19.05 148.9,17.35 156.31,17.35 157.27,16.39 163.86,16.39 165.32,14.93 172.41,14.93 173.1,14.24 178.17,14.24 178.95,13.46 182.37,13.46 182.7,13.79 196.64,13.79 199.76,16.92 200.83,16.92 204.25,20.34 205.84,20.34 206.95,21.45 213.94,21.45 214.86,20.53 214.86,19.43 215.47,18.82 215.47,16.79 215.29,16.61 215.02,16.61 v5(214.78,16.85)
  BOTTOM w0.102: U0400.F25 124.28,47.61 v3(124.28,47.68) ; CON3100.17 v5(214.78,16.85)
PCIE10_SSD1_RXP: length 125.2
  IN3 w0.127: v1(214.81,16.16) 215.04,16.39 215.39,16.39 215.7,16.7 215.7,18.92 215.09,19.53 215.09,20.63 214.03,21.68 206.85,21.68 205.74,20.57 204.15,20.57 200.73,17.15 199.67,17.15 196.55,14.02 182.61,14.02 182.28,13.69 179.04,13.69 178.27,14.47 173.2,14.47 172.51,15.16 165.42,15.16 163.95,16.62 157.36,16.62 156.4,17.58 148.99,17.58 147.42,19.15 147.42,20.45 146.99,20.88 146.99,25.87 143.21,29.65 143.21,30.82 139.37,34.66 139.37,39.37 135.37,43.38 135.37,44.99 130.88,49.48 127.79,49.48 126.59,48.28 126.59,47.88 126.06,47.35 125.2,47.35 v3(124.85,47.7)
  BOTTOM w0.089: U0400.E25 124.85,47.53 v3(124.85,47.7)
  BOTTOM w0.102: v1(214.81,16.16) 215,16.35 CON3100.19
PCIE10_SSD1_TXN: length 119.5
  IN3 w0.127: v3(130.01,47.1) 130.36,47.45 130.72,47.45 131.67,46.5 131.67,44.84 132.26,44.26 132.26,43.23 134.16,41.33 135.21,41.33 137.82,38.71 137.82,33.87 141.61,30.08 141.61,29.06 145.39,25.27 145.39,18.93 148.29,16.03 155.76,16.03 156.87,14.93 163.46,14.93 166.25,12.13 181.74,12.13 182.47,11.4 186.01,11.4 186.94,12.32 200.43,12.32 207.95,19.84 210.64,19.84 212.85,17.63 212.85,17.05 212.73,16.92 v1(212.01,16.92)
  BOTTOM w0.076: 127.99,45.97 127.95,45.94 127.75,45.94 127.51,45.7 127.15,45.7 127.07,45.74 126.86,45.74 126.79,45.71 126.5,45.71 126.19,45.83 125.9,45.83 U0400.D23
  BOTTOM w0.102: C3106.1 213.18,17.38 212.6,16.79 212.14,16.79 v1(212.01,16.92) ; v3(130.01,47.1) 129.83,46.92 129.83,46.84 129.35,46.36 128.37,46.36 127.99,45.97
PCIE10_SSD1_TXN_C: length 3.5
  BOTTOM w0.102: CON3100.23 215.26,15.35 214.91,15.7 214.63,15.7 214.38,15.95 214.38,17.17 C3106.2
PCIE10_SSD1_TXP: length 119.6
  IN3 w0.127: v1(212.06,16.26) 212.5,16.69 212.82,16.69 213.08,16.95 213.08,17.72 210.74,20.07 207.86,20.07 200.34,12.55 186.84,12.55 185.92,11.63 182.57,11.63 181.83,12.36 166.35,12.36 163.55,15.15 156.96,15.15 155.86,16.26 148.39,16.26 145.62,19.03 145.62,25.37 141.83,29.15 141.83,30.18 138.05,33.96 138.05,38.81 135.3,41.56 134.26,41.56 132.49,43.33 132.49,44.35 131.9,44.94 131.9,46.59 130.81,47.68 v3(129.97,47.68)
  BOTTOM w0.076: U0400.C23 126.14,46 126.22,46 126.52,45.88 126.53,45.87 126.75,45.87 126.83,45.91 127.12,45.91 127.2,45.87 127.45,45.87 127.68,46.1 127.83,46.1 127.84,46.11
  BOTTOM w0.102: v1(212.06,16.26) 212.4,16.59 C3107.1 ; 127.84,46.11 128.29,46.56 129.26,46.56 129.62,46.92 129.62,47.32 v3(129.97,47.68)
PCIE10_SSD1_TXP_C: length 3.5
  BOTTOM w0.102: CON3100.25 214.82,14.85 214.75,14.92 214.75,15.16 214.91,15.32 214.91,15.42 214.83,15.5 214.55,15.5 214.17,15.87 214.17,16.41 C3107.2
PCIE11_SSD1_RXN: length 128.2
  IN3 w0.127: v3(124.85,48.56) 125.02,48.4 125.76,48.4 127.5,50.14 131.18,50.14 136.03,45.3 136.03,43.66 140.03,39.65 140.03,35.53 143.69,31.87 143.69,31.29 143.87,31.11 143.87,29.92 147.68,26.11 147.68,22.63 148.94,21.37 148.94,20.55 149.47,20.02 151.1,20.02 152.22,18.9 152.83,18.9 153.49,18.24 157.48,18.24 158.42,17.3 164.21,17.3 165.69,15.82 172.81,15.82 173.5,15.13 178.54,15.13 178.9,14.77 196.36,14.77 199.4,17.81 200.46,17.81 203.88,21.23 205.47,21.23 206.58,22.34 214.32,22.34 215.75,20.92 215.75,19.81 216.36,19.2 216.36,16.41 214.59,14.64 214.59,14.3 214.72,14.18 215.21,14.18 215.34,14.05 215.34,13.82 215.16,13.64 v5(214.78,13.64)
  BOTTOM w0.102: v5(214.78,13.64) 214.99,13.85 CON3100.29 ; U0400.E28 124.57,48.84 v3(124.85,48.56)
PCIE11_SSD1_RXP: length 128.3
  IN3 w0.127: v1(214.78,12.96) 214.36,13.38 214.36,14.74 216.13,16.5 216.13,19.1 215.52,19.71 215.52,20.82 214.23,22.11 206.67,22.11 205.56,21 203.98,21 200.55,17.58 199.49,17.58 196.46,14.54 178.8,14.54 178.45,14.9 173.4,14.9 172.71,15.59 165.6,15.59 164.11,17.07 158.33,17.07 157.39,18.01 153.39,18.01 152.73,18.67 152.12,18.67 151,19.79 149.38,19.79 148.71,20.46 148.71,21.28 147.45,22.54 147.45,26.02 143.64,29.83 143.64,31.02 143.46,31.19 143.46,31.78 139.8,35.43 139.8,39.56 135.8,43.56 135.8,45.2 131.09,49.91 127.6,49.91 125.85,48.17 124.67,48.17 v3(124.28,48.56)
  BOTTOM w0.089: v3(124.28,48.56) 124.28,48.46 U0400.E27
  BOTTOM w0.102: v1(214.78,12.96) 214.78,13.01 215.13,13.35 CON3100.31
PCIE11_SSD1_TXN: length 125.8
  TOP w0.102: C3111.1 214.29,14.58 214.41,14.7 214.41,14.9 214.27,15.04 213.55,15.04 213.16,14.65 213.16,13.69 213.28,13.57 v1(213.46,13.57)
  IN3 w0.127: v3(128.88,48.16) 128.88,48.4 128.97,48.48 129.42,48.48 129.79,48.11 130.99,48.11 131.13,47.97 132.33,46.77 132.33,45.12 132.9,44.55 133.08,44.55 133.36,44.27 134.25,44.27 134.46,44.07 134.46,43.02 138.48,38.99 138.48,34.19 142.27,30.41 142.27,29.33 146.1,25.5 146.1,20.36 146.51,19.95 146.51,18.77 148.59,16.69 156.04,16.69 157.02,15.71 163.61,15.71 166.53,12.79 182.29,12.79 182.73,12.35 185.95,12.35 186.63,13.03 196.86,13.03 199.8,15.98 200.82,15.98 204.52,19.68 206.86,19.68 207.97,20.79 210.63,20.79 214.02,17.4 214.02,15.46 213.69,15.13 213.69,14.15 213.64,14.1 213.44,14.1 213.37,14.03 213.37,13.66 v1(213.46,13.57)
  BOTTOM w0.076: U0400.D24 125.88,46.7 126.17,46.41 126.48,46.41 126.85,46.78 127.52,46.78 127.52,46.78 127.55,46.78 ; 127.64,46.86 127.69,46.92
  BOTTOM w0.102: 127.69,46.92 128.88,48.1 v3(128.88,48.16) ; 127.55,46.78 127.56,46.78 127.64,46.86
PCIE11_SSD1_TXN_C: length 7.8
  TOP w0.102: 215.71,11.78 215.49,11.56 215.16,11.56 v1(214.76,11.97) ; 215.71,11.78 v2(215.54,11.94) ; 215.71,11.78 215.87,11.94 215.87,14.98 215.56,15.29 215.4,15.29 215.27,15.16 215.27,14.7 215.14,14.58 C3111.2
  BOTTOM w0.102: v1(214.76,11.97) 215.14,12.35 CON3100.35
PCIE11_SSD1_TXP: length 125.9
  TOP w0.102: v1(213.41,12.96) 212.95,13.41 212.95,14.73 213.72,15.5 C3112.1
  IN3 w0.127: v3(128.3,48.14) 128.87,48.71 129.52,48.71 129.89,48.34 131.09,48.34 131.69,47.74 132.56,46.86 132.56,45.21 132.99,44.78 133.17,44.78 133.45,44.5 134.35,44.5 134.68,44.17 134.68,43.11 138.71,39.09 138.71,34.29 142.49,30.5 142.49,29.43 146.33,25.59 146.33,20.46 146.74,20.05 146.74,18.87 148.68,16.92 156.13,16.92 157.11,15.94 163.7,15.94 166.62,13.02 182.38,13.02 182.83,12.58 185.85,12.58 186.54,13.26 196.76,13.26 199.71,16.21 200.73,16.21 204.43,19.91 206.76,19.91 207.87,21.02 210.72,21.02 214.25,17.5 214.25,15.37 213.92,15.04 213.92,13.39 213.49,12.96 v1(213.41,12.96)
  BOTTOM w0.076: U0400.C24 126.54,46.7 126.78,46.94 127.45,46.94 127.49,46.99 127.49,46.99 127.49,47
  BOTTOM w0.102: v3(128.3,48.14) 128.3,47.81 127.49,47
PCIE11_SSD1_TXP_C: length 7.8
  TOP w0.102: 215.89,15.26 215.65,15.5 C3112.2 ; 215.89,15.26 v2(216.05,15.42) ; 215.89,15.26 216.08,15.06 216.08,11.86 215.58,11.36 v1(214.76,11.36)
  BOTTOM w0.102: CON3100.37 215.25,11.85 v1(214.76,11.36)
PCIE12_SATA_SSD1_RXN: length 146.6
  IN3 w0.127: v3(124.31,49.56) 124.67,49.2 125.56,49.2 127.16,50.8 131.47,50.8 132.44,49.84 136.04,49.84 137.35,48.53 137.35,44.86 138.94,43.27 149.1,43.27 150.08,44.25 152.72,44.25 154.86,42.12 157.04,42.12 158.22,40.94 158.22,28.17 160.68,25.71 160.68,24.27 167.81,17.14 173.48,17.14 174.17,16.45 179.09,16.45 179.44,16.09 195.31,16.09 201.42,22.2 202.31,22.2 202.76,22.65 205.02,22.65 206.03,23.66 214.87,23.66 217.93,20.6 217.93,12.78 217.27,12.12 216.92,12.12 216.54,11.74 216.54,7.88 215.9,7.24 214.33,7.24 213.64,7.93 213.64,9.76 213.29,10.11 212.42,10.11 v1(212.29,9.98)
  BOTTOM w0.102: U0400.E30 124.32,49.75 124.32,49.57 v3(124.31,49.56) ; v1(212.29,9.98) 212.41,10.1 213.02,10.1 213.28,9.83 R3112.2
PCIE12_SATA_SSD1_RXN_R: length 2.2
  BOTTOM w0.102: R3112.1 214.15,9.86 214.73,10.44 215.01,10.44 215.1,10.35 CON3100.43
PCIE12_SATA_SSD1_RXP: length 146.6
  IN3 w0.127: v3(123.75,49.55) 124.13,49.16 124.38,49.16 124.57,48.97 125.65,48.97 127.25,50.57 131.38,50.57 132.34,49.61 135.95,49.61 137.12,48.44 137.12,44.76 138.84,43.04 149.2,43.04 150.18,44.02 152.63,44.02 154.76,41.89 156.95,41.89 157.99,40.84 157.99,28.07 160.45,25.61 160.45,24.17 167.72,16.91 173.39,16.91 174.08,16.22 178.99,16.22 179.35,15.86 195.41,15.86 201.51,21.97 202.4,21.97 202.85,22.42 205.11,22.42 206.13,23.43 214.78,23.43 217.7,20.51 217.7,12.87 217.18,12.35 216.82,12.35 216.31,11.83 216.31,7.97 215.81,7.47 214.43,7.47 213.87,8.03 213.87,9.86 213.39,10.34 212.55,10.34 v1(212.29,10.59)
  BOTTOM w0.102: v1(212.29,10.59) 212.58,10.3 213.02,10.3 213.31,10.59 R3111.2 ; v3(123.75,49.55) 123.92,49.72 U0400.F30
PCIE12_SATA_SSD1_RXP_R: length 2.1
  BOTTOM w0.102: CON3100.41 215.22,10.85 215.03,10.66 214.85,10.66 214.56,10.95 214.38,10.95 214.17,10.75 R3111.1
PCIE12_SATA_SSD1_TXN: length 137.5
  TOP w0.102: v1(214.72,9.35) 214.72,9.31 215.37,8.66 216.21,8.66 216.28,8.74 216.28,9 216.15,9.13 C3113.1
  IN3 w0.127: v1(214.72,9.35) 214.72,9.26 214.94,9.04 215.3,9.04 215.65,9.39 215.65,12.55 216.28,13.19 216.28,15.6 216.97,16.28 216.97,19.23 216.18,20.02 216.18,21.1 214.5,22.77 206.4,22.77 205.29,21.66 203.7,21.66 200.28,18.24 199.22,18.24 196.18,15.2 179.08,15.2 178.72,15.56 173.75,15.56 173.06,16.25 167.44,16.25 160.4,23.29 159.11,23.29 156.45,25.95 156.45,30.62 157.22,31.39 157.22,40.59 156.6,41.2 154.41,41.2 152.46,43.14 150.24,43.14 148.16,41.06 142.39,41.06 141.1,42.35 138.58,42.35 136.46,44.46 136.46,46.69 135.69,47.46 135.51,47.46 v1(135.41,47.36)
  BOTTOM w0.102: U0400.A25 127.3,47.28 127.25,47.32 127.25,47.49 127.84,48.08 127.84,48.86 128.05,49.08 128.78,49.08 129.72,48.14 130.07,48.14 130.37,47.83 132.77,47.83 ; 132.77,47.83 v2(132.77,47.6) ; 132.77,47.83 134.94,47.83 v1(135.41,47.36)
PCIE12_SATA_SSD1_TXN_C: length 3.4
  TOP w0.102: v5(217.89,9.31) 217.53,8.94 217.32,8.94 217.14,9.13 C3113.2
  BOTTOM w0.102: CON3100.47 216.81,9.35 216.99,9.17 217.75,9.17 v5(217.89,9.31)
PCIE12_SATA_SSD1_TXP: length 137.3
  TOP w0.102: v1(214.71,8.69) 215.05,8.69 215.54,8.21 C3114.1
  IN3 w0.127: v1(214.71,8.69) 214.83,8.82 215.39,8.82 215.87,9.3 215.87,12.46 216.51,13.09 216.51,15.5 217.2,16.19 217.2,19.33 216.41,20.11 216.41,21.19 214.6,23 206.31,23 205.19,21.89 203.61,21.89 200.18,18.47 199.12,18.47 196.09,15.43 179.17,15.43 178.81,15.79 173.85,15.79 173.16,16.48 167.54,16.48 160.49,23.52 159.2,23.52 156.68,26.05 156.68,30.53 157.44,31.29 157.44,40.68 156.7,41.43 154.5,41.43 152.56,43.37 150.15,43.37 148.06,41.29 142.48,41.29 141.2,42.58 138.67,42.58 136.69,44.56 136.69,46.78 v1(135.4,48.07)
  BOTTOM w0.102: U0400.B25 126.84,47.27 127.05,47.47 127.05,47.58 127.64,48.16 127.64,48.95 127.97,49.28 128.86,49.28 129.8,48.34 130.15,48.34 130.45,48.03 135.37,48.03 v1(135.4,48.07)
PCIE12_SATA_SSD1_TXP_C: length 3.3
  TOP w0.102: v1(217.75,8.56) 217.58,8.74 217.22,8.74 216.79,8.31 C3114.2
  BOTTOM w0.102: CON3100.49 216.91,8.85 217.03,8.97 217.35,8.97 v1(217.75,8.56)
PCIE_RCOMPN: length 10.8
  IN2 w0.381: v1(129.9,32.18) 129.67,31.96 128.8,31.96 128.09,32.67 124.97,32.67 123.52,34.11 v3(123.52,35.82)
  BOTTOM w0.254: v3(123.52,35.82) 123.52,35.77 U0400.F5
  BOTTOM w0.381: R1401.2 v1(129.9,32.18)
PCIE_RCOMPP: length 10.8
  IN2 w0.381: v1(129.24,32.79) 128.94,32.79 128.38,33.35 125.25,33.35 124.82,33.79 124.82,34.75 124.23,35.33 v3(124.23,35.82)
  BOTTOM w0.254: v3(124.23,35.82) 124.23,35.71 124.38,35.56 U0400.E5
  BOTTOM w0.381: R1401.1 130,33.05 129.46,33.58 129.08,33.58 128.96,33.45 128.96,33.07 v1(129.24,32.79)
PCIE_WAKE#: length 255.7
  TOP w0.102: v1(87.31,6.1) 86.91,6.5 86.04,6.5 85.09,7.44 v2(85.09,9.5) 85.09,11.52 86.7,13.13 87.47,13.13 88.8,14.46 88.8,17.82 86.16,20.46 86.16,20.71 85.28,21.59 84.44,21.59 84.2,21.83 84.2,22.27 84.71,22.78 84.71,24.18 87.02,26.49 87.02,28.35 v1(86.59,28.78) ; U2300.4 39.7,42.24 39.07,41.61 39.07,39.62 v1(38.96,39.51)
  IN2 w0.102: v1(187.58,11.79) 179.94,11.79 179.12,12.61 172.74,12.61 172.11,11.98 166.19,11.98 164.63,13.54 156.77,13.54 v1(155.55,12.32) 154.23,11 150.28,11 149.92,10.65 147.3,10.65 147.09,10.85 143.14,10.85 142.81,11.18 138.91,11.18 137.83,10.09 108.78,10.09 108.26,10.62 107.47,10.62 106.86,10.01 105.03,10.01 102.82,7.8 102.82,6.07 100.46,3.71 96.86,3.71 94.09,6.48 90.7,6.48 90.32,6.1 v1(87.31,6.1)
  IN3 w0.102: v1(38.96,39.51) 38.96,38.89 39.91,37.95 39.91,37.04 39.7,36.83 39.7,31.97 44.29,27.38 44.65,27.38 45.75,26.29 48.77,26.29 54.76,20.3 54.76,20.02 55.52,19.26 61.77,19.26 62.81,20.3 70.1,20.3 70.73,20.93 72.41,20.93 75.74,24.26 75.92,24.44 80.27,24.44 84.62,28.78 v1(86.59,28.78) 88.25,28.78 89.52,30.05 91.78,30.05 92.59,30.86 93.04,30.86 93.32,31.14 93.32,31.91 93.92,32.51 95.4,32.51 96.47,33.58 v1(96.47,33.66)
  BOTTOM w0.076: U0400.BB15 104.47,41.25 104.45,41.28 103.98,41.28 103.58,40.87 102.77,40.87
  BOTTOM w0.102: 102.77,40.87 102.15,40.87 101.78,40.5 101.78,38.81 102.48,38.11 102.48,35.99 100.99,34.5 98.99,34.5 98.79,34.7 97,34.7 96.47,34.17 v1(96.47,33.66) 96.47,33.33 R1214.2 ; Q3102.3 155.89,13.65 155.55,13.31 v1(155.55,12.32) ; CON5104.3 191.32,20.67 190.78,21.21 186.58,21.21 186,20.64 186,16.61 186.26,16.36 186.26,12.48 186.95,11.79 v1(187.58,11.79)
PCIE_WAKE#_R: length 101.1
  TOP w0.102: v1(222.86,4.68) 222.68,4.85 R3113.2 ; v1(162.03,12.8) v2(163.12,12.8) 164.26,12.8 165.15,11.92 171.66,11.92 172.42,12.68 176.14,12.68 176.86,11.97 181.55,11.97 182.14,11.38 187.86,11.38 v1(188.24,11.76)
  IN1 w0.102: v1(222.86,4.68) 218.64,4.68 216.89,6.43 216.89,9.73 219.84,12.68 219.84,18.76 216.84,21.76 210.35,21.76 203.61,15.01 203.61,12.23 202.86,11.48 202.46,11.48 v1(202.16,11.79)
  IN2 w0.102: v1(188.24,11.76) 188.55,12.08 201.87,12.08 v1(202.16,11.79)
  BOTTOM w0.102: CON3100.54 222.66,7.6 222.53,7.47 222.53,6.3 223.32,5.51 223.32,5.08 222.91,4.68 v1(222.86,4.68) ; v1(162.03,12.8) 161.32,12.09 161.32,10.49 160.91,10.09 156.11,10.09 155.72,10.48 Q3102.2
PD_HPD: length 203
  TOP w0.102: v1(26.27,56.61) 25.97,56.9 25.4,56.9 v2(25.27,56.77) ; v1(27.36,88.65) 27.6,88.65 27.84,88.42 R5719.2 ; 38.07,81.13 38.48,80.72 38.65,80.72 38.89,80.49 38.89,80.32 39.16,80.05 U5800.18 ; 38.07,81.13 R5806.1 ; 38.07,81.13 38.1,81.13 38.48,81.51 38.48,82.46 v1(38.38,82.57)
  IN1 w0.097: v1(27.36,88.65) 28.45,87.57 28.45,80.44 30.25,78.64 34.2,78.64 38.13,82.57 v1(38.38,82.57) ; v1(26.27,56.61) 26.48,56.4 26.48,47.66 28.42,45.71 28.42,45.23 31.23,42.42 31.23,40.83 32.28,39.78 32.28,28.61 35.81,25.07 35.81,24.43 37.57,22.67 v1(37.57,17.33)
  IN3 w0.127: v1(38.38,82.57) 38.06,82.25 37.72,82.25 34.48,79 34.48,78.25 33.38,77.16 33.38,74.42 32.54,73.59 32.54,70.43 30.87,68.76 30.01,68.76 27.71,66.46 27.71,65.69 25.83,63.81 25.83,57.04 v1(26.27,56.61) ; v1(121.79,20.2) 121.79,19.28 117.17,14.66 109.96,14.66 109.87,14.75 109.12,14.75 108.26,13.89 103.36,13.89 102.62,13.16 102.29,13.16 101.09,11.97 96.6,11.97 95.38,10.75 90.77,10.75 89.99,9.97 84.59,9.97 83.99,9.36 70.91,9.36 68.94,7.39 63.45,7.39 62.64,8.21 61.57,8.21 61.28,7.91 51.6,7.91 46.86,12.65 43.59,12.65 40.31,15.93 39.73,15.93 38.33,17.33 v1(37.57,17.33)
  BOTTOM w0.102: Q5801.3 118.62,17.78 118.7,17.87 R5825.1 119.46,17.87 119.58,18 119.58,19.2 119.71,19.33 120.58,19.33 121.45,20.2 v1(121.79,20.2)
PD_HPD_R: length 1.9
  TOP w0.102: R5719.1 27.79,87.2 27.31,86.72 v2(27.31,86.44) U5703.23
PD_VBUS_C_CTRL1_A: length 16.6
  TOP w0.254: v1(28.85,101.88) 28.88,101.91 PQ7608.6 ; v2(35.28,105.44) 35.05,105.67 PR7633.2 34.39,106.99 34.53,107.13 PQ7612.5 35.76,107.13 35.89,107.25 35.89,107.65 35.76,107.78 PQ7612.6 v1(34.29,107.78)
  IN1 w0.254: v1(28.85,101.88) 29.13,101.6 30.56,101.6 32.82,103.86 32.82,105.59 34.29,107.06 v1(34.29,107.78)
PECI_PCH: length 267.8
  TOP w0.102: v3(128.98,63.02) 128.73,63.27 126.26,63.27 125.79,63.74 125.79,64.25 126.59,65.05 126.59,71.25 128.52,73.18 v3(128.52,73.97) ; v1(97.82,105.84) 98.5,106.53 v2(99.09,106.53) ; R2300.2 40.03,24.15 v1(39.89,24.01)
  IN1 w0.097: v1(97.82,105.84) 98.17,105.49 98.17,103.36 101.78,99.75 102.13,99.75 102.36,99.52 102.36,98.59 103.35,97.6 103.35,97.59 103.69,97.25 103.69,96.72 105.13,95.28 105.66,95.28 106.53,94.41 106.53,93.75 112.63,87.65 113.64,87.65 114.65,86.64 125.32,86.64 129.18,82.78 129.18,74.63 v3(128.52,73.97)
  IN3 w0.127: v1(30.51,18.57) 25.15,18.57 23.29,20.42 23.29,25.65 23.28,25.67 23.28,28.82 23.34,28.89 23.34,32.06 23.48,32.2 23.48,40.25 20.96,42.78 18.02,42.78 17.34,43.46 17.34,46.31 17.93,46.9 17.93,51.26 17.22,51.97 17.22,55.58 16.26,56.54 15.53,56.54 14.1,57.98 14.1,65.74 12.42,67.42 12.42,71.83 13.23,72.64 13.23,74.25 10.98,76.5 10.98,82.2 11.28,82.5 11.52,82.5 12.12,83.1 12.12,84.86 12.65,85.4 12.65,87.53 13.71,88.59 15.14,88.59 16.16,89.61 18.56,89.61 20.09,91.14 20.09,92.65 22.03,94.59 23.49,94.59 28.35,99.45 28.99,99.45 32.75,103.22 51.99,103.22 53.42,104.65 73.35,104.65 73.64,104.36 77.89,104.36 79.53,102.72 80.54,102.72 83.7,99.56 93.02,99.56 97.82,104.35 v1(97.82,105.84)
  BOTTOM w0.102: U0400.A54 127.49,63.49 127.54,63.44 128.03,63.44 128.22,63.25 128.75,63.25 v3(128.98,63.02) ; v1(30.51,18.57) 33.43,18.57 36.8,21.95 36.8,22.94 38.15,24.28 38.91,24.28 39.19,24.01 v1(39.89,24.01)
PERSTB_RST#: length 25.1
  IN1 w0.102: v1(142.87,88.53) 142.87,89.32 143.26,89.72 143.26,90 145.29,92.03 147.75,92.03 148.23,91.54 149.22,91.54 149.47,91.8 v1(150.65,91.8)
  BOTTOM w0.102: v1(150.65,91.8) 150.65,92.7 151.33,93.39 151.33,96.32 152.02,97.01 152.22,97.01 U6000.AL27 ; v1(142.87,88.53) 142.87,89.32 143.26,89.72 143.26,90.15 v2(142.88,90.54) 142.51,90.91 140.11,90.91 139.32,90.12 139.32,88.42 139.13,88.23 U6001.4
PGOOD_VCPU: length 1.7
  BOTTOM w0.102: PR7836.1 171.25,50.5 171.35,50.6 v2(171.7,50.6) 171.85,50.45 PU7800.39
PLL_ANALOG_IN: length 9.2
  TOP w0.102: v1(158.84,75.81) 158.84,69.33 T6905.1
  BOTTOM w0.102: v1(158.84,75.81) 159.23,76.21 U6000.AA1
PLL_ANALOG_OUT: length 6.9
  BOTTOM w0.102: R6907.2 159.44,73.85 v2(158.83,74.46) 157.96,75.33 157.96,78.49 158.29,78.82 U6000.AA3
PLT_RST#_BUF: length 329.2
  TOP w0.102: v1(203.71,18.14) 202.62,19.23 v1(202.62,21.57) ; v1(208.48,69.42) 208.15,69.09 200.38,69.09 v1(199.97,69.5) v2(199.4,68.93) ; v1(213.21,34.62) 213.84,35.26 213.84,38.94 212.56,40.23 204.43,40.23 v1(204.03,39.83) ; v1(218.8,6.53) 218.82,6.56 R3103.1
  IN1 w0.102: v1(103.98,26.59) 104.37,26.19 104.37,24.51 105.27,23.6 106.15,23.6 108.46,21.29 110.13,21.29 110.77,20.65 111.66,20.65 112.27,20.04 112.27,18.24 112.93,17.58 114.55,17.58 117.73,14.4 121.03,14.4 121.45,14.82 v1(121.46,14.82) ; v1(213.21,34.62) 216.84,30.99 216.84,28.68 215.48,27.32 215.48,23.41 220.04,18.85 220.04,7.77 v1(218.8,6.53) ; v1(143.66,79.63) 145.35,79.63 146.15,78.83 146.15,78.21 146.46,77.9 147.42,77.9 148.07,78.56 149.84,78.56 153.82,74.57 159.24,74.57 162.24,71.58 163.88,71.58 164.41,72.11 164.92,72.11 166.93,70.11 167.86,70.11 169.71,68.26 172.68,68.26 174,66.94 176.45,66.94 178.11,65.28 178.11,64.69 180.23,62.56 190.74,62.56 192.84,64.65 192.84,66.06 195.64,68.86 199.34,68.86 v1(199.97,69.5)
  IN2 w0.102: v1(204.03,39.83) 204.43,40.23 205.38,40.23 206.93,38.68 206.93,21.16 205.31,19.54 205.31,18.81 204.46,17.96 203.89,17.96 v1(203.71,18.14) ; v1(121.46,14.82) 127.77,14.82 128.19,15.24 132.66,15.24 134.59,17.17 137.54,17.17 138.43,18.06 150.55,18.06 151.54,19.05 152.98,19.05 154.2,17.83 157.32,17.83 158.23,16.92 198.54,16.92 202.62,20.99 v1(202.62,21.57)
  IN3 w0.102: v1(208.48,69.42) 208.48,65.81 207.26,64.59 207.26,54.41 207.54,53.7 209.14,52.1 209.14,40.65 213.61,36.18 213.61,35.03 v1(213.21,34.62) ; v1(136.07,88.83) 136.07,86.55 141.46,81.16 142.67,81.16 143.66,80.16 v1(143.66,79.63)
  BOTTOM w0.102: v1(136.07,88.83) 135.85,88.61 135.85,87.86 136.13,87.58 U6001.2 ; CON5103.36 205.55,40.76 205.24,40.45 204.66,40.45 v1(204.03,39.83) ; v1(103.98,26.59) 103.35,27.21 103.35,28.67 103.23,28.79 102.22,28.79 102.08,28.65 R1225.2 R1201.2 100.36,28.65 100.13,28.43 U1200.4
PLT_RST#_BUF_EMMC: length 23.3
  TOP w0.102: U2500.K5 99.53,20.67 v1(99.16,20.3) ; D2500.1 84.54,20.93 v1(84.51,20.93) ; R2514.1 91.29,22.96 v1(91.62,23.29)
  IN1 w0.102: v1(99.16,20.3) 99.09,20.22 94.87,20.22 93.42,21.67 92.95,21.67 91.62,23 v1(91.62,23.29)
  IN3 w0.102: v1(91.62,23.29) 89.29,20.96 84.53,20.96 v1(84.51,20.93)
  BOTTOM w0.102: v1(84.51,20.93) 85.06,20.93 86.82,19.18 v2(86.82,18.39)
PM_PCH_PWROK: length 41.4
  BOTTOM w0.076: U0400.BA20 105.1,43.67 104.84,43.93 104.83,43.93 104.82,43.94 104.29,43.94 103.7,43.35 103.1,43.35 102.77,43.02 102.77,43
  BOTTOM w0.102: 102.77,43 102.57,42.8 100.08,42.8 100,42.88 98.68,42.88 98.43,42.62 R1213.1 97.97,42.29 97.85,42.17 95.33,42.17 87.35,34.19 87.35,30 88.19,29.16 88.65,29.16 89.64,28.17 89.86,28.17 90.3,27.73 90.3,26.27 90.2,26.16 90.2,25.38 90.83,24.74 93.22,24.74 94.18,25.71 95.83,25.71 v2(96.06,25.48) 96.52,25.02 R1228.2 R1227.1
PM_THRMTRIP#: length 241.7
  TOP w0.102: Q2401.1 26.88,21.89 27.31,21.47 27.31,19.84 29.11,18.04 31.8,18.04 v2(34.38,20.61) v1(34.9,21.14) ; D2401.3 10.72,17 12.81,14.9 16.7,14.9 v1(17.42,15.62)
  IN3 w0.102: v1(34.9,21.14) 34.9,23.52 32.79,25.63 32.79,26.95 29.16,30.58 29.16,39.6 28.47,40.29 28.47,41.85 28.47,43.87 26.84,45.5 26.84,55.17 23.79,58.22 23.28,58.22 22.12,59.39 22.12,69.96 23.05,70.89 23.68,70.89 27.34,74.55 27.34,79.67 28.75,81.09 28.75,84.41 30.75,86.4 31.97,86.4 32.6,87.02 38.25,87.02 40.31,89.08 40.31,91.88 46.15,97.72 48.03,97.72 49.16,98.85 65.41,98.85 66.99,100.42 79.62,100.42 82.47,97.57 82.47,97.56 82.78,97.26 82.78,97.26 83.14,96.9 93.75,96.9 100.92,104.07 107.42,104.07 108.11,103.38 113.74,103.38 115.01,102.11 115.01,102.08 116.05,101.04 116.99,101.04 117.2,100.84 117.2,96.15 119.18,94.17 119.18,92.74 121.25,90.67 125.15,90.67 125.82,91.34 v1(129.97,91.34)
  BOTTOM w0.102: D3700.1 131.85,93.88 129.97,92 v1(129.97,91.34) ; v1(34.9,21.14) 32.89,19.13 28.73,19.13 24.28,14.68 18.36,14.68 v1(17.42,15.62)
POWER_SW_IN#: length 22.2
  TOP w0.102: U2300.127 41.62,41.9 41.25,42.27 41.25,42.88 41.55,43.18 41.55,44.66 41.22,44.99 41.22,45.32 v2(41.62,45.71) 41.73,45.82 43.41,45.82 44.17,46.59 45.52,46.59 C2311.1 46.58,47.65 46.58,50.22 45.47,51.34 45.47,54.31 v2(45.85,54.69) 46.03,54.87 R2309.1 46.92,54.87 47.35,55.3 47.35,56.31 46.91,56.75 R2310.2
PQ7608B_3: length 2.5
  TOP w0.254: PR7635.2 32.26,105.69 31.93,105.36 31.93,104.52 31.65,104.25 PQ7608.3
PQ7608B_4: length 6.8
  TOP w0.254: v2(33.55,105.44) 33.55,106.35 33.43,106.48 PQ7612.3 32.43,106.48 31.39,105.44 31.39,104.96 31.12,104.68 30.71,104.68 30.28,104.25 PQ7608.4
PRIM_PWRGD: length 4.1
  TOP w0.102: U2300.30 29.3,45.12 29.08,45.34 R2346.2 28.63,46.54 28.09,47.07 v2(28.09,47.32)
PRO_THM:
  vias: v2(19.02,91.9)
PROC_POPIRCOMP: length 1.5
  TOP w0.305: v3(108.79,42.22) 108.79,42.65 R0404.2
  BOTTOM w0.254: v3(108.79,42.22) 108.79,42.12 U0400.AT16
PROC_SELECT#: length 12.4
  IN3 w0.102: v1(133.93,67.06) 133.43,66.55 133.43,64.75 v1(133.91,64.26)
  BOTTOM w0.076: U0400.C64 126.97,69.01 127,69.04 127.61,69.04 127.72,68.93 128.5,68.93 128.52,68.95
  BOTTOM w0.102: 128.52,68.95 129.52,68.95 130.33,68.14 131.91,68.14 v2(131.94,68.11) 132.46,67.59 133.4,67.59 v1(133.93,67.06) ; R0902.1 134.19,64.26 v1(133.91,64.26)
PROCHOT: length 223.6
  TOP w0.102: U2300.83 35.7,29.41 35.55,29.55 35.55,31.49 v1(34.45,32.59)
  IN1 w0.102: v1(99.16,104.55) 99.16,103.16 102.02,100.31 102.36,100.31 103.91,98.76 103.91,97.83 104.73,97.01 104.73,96.47 105.36,95.84 105.89,95.84 106.12,95.61 106.13,95.61 107.19,94.55 107.19,93.88 112.75,88.32 113.76,88.32 114.65,87.43 125.32,87.43 129.95,82.81 v1(129.95,75.87) ; v1(34.45,32.59) 34.03,33.01 34.03,40.44 33.3,41.18 33.3,42.71 30.86,45.15 30.86,49.91 30.76,50.01 30.76,52.55 29.24,54.07 29.24,58.87 27.41,60.71 27.41,65.99 24.56,68.84 23.73,68.84 22.44,70.13 16.34,70.13 v1(14.44,72.03)
  IN3 w0.102: v1(99.16,104.55) 98.83,104.22 98.83,103.94 93.04,98.15 83.67,98.15 80.16,101.67 62.61,101.67 61.25,103.02 53.22,103.02 52.4,102.21 45.93,102.21 44.1,100.38 31.39,100.38 28.4,97.39 27.7,97.39 23.86,93.55 22.45,93.55 21.26,92.36 21.26,90.26 19.47,88.47 17.17,88.47 16.28,87.58 14.72,87.58 14.48,87.34 14.48,87.04 13.7,86.26 13.7,85 13.13,84.43 13.13,82.69 12.43,82 12.43,78.4 14.44,76.39 v1(14.44,72.03)
  BOTTOM w0.102: R0418.1 v2(132.11,74.58) 131.24,74.58 v1(129.95,75.87)
PROCHOT#: length 281.5
  TOP w0.102: PQ7603.3 65.19,99.31 65.46,99.04 66.6,99.04 66.82,99.26 67.26,99.26 68.19,100.19 70.8,100.19 71.15,99.85 v1(74.4,99.85) ; v1(149.05,13.85) 149.61,14.4 v2(149.61,14.86) 149.61,15.9 147.04,18.47 147.04,20.4 146.2,21.24 146.2,25.01 150.65,29.45 150.65,30.41 151.56,31.32 158.61,31.32 160.15,32.86 160.15,41.07 159.16,42.06 159.16,43.41 159.66,43.92 159.66,47.38 164.01,51.72 v1(167.46,51.72)
  IN2 w0.109: v1(167.12,21.36) 167.12,20.9 167.31,20.7 176.65,20.7 177.25,21.3 177.25,25.1 178.81,26.67 189.89,26.67 192.84,29.62 197.35,29.62 v1(198.2,30.47)
  IN3 w0.127: v1(161.51,10.11) 160.17,11.46 157.27,11.46 156.62,12.11 156.62,12.46 156.19,12.88 154.76,12.88 153.82,13.82 150.44,13.82 150.03,13.4 149.49,13.4 v1(149.05,13.85) ; v1(136.35,63.02) 137.74,61.62 137.74,58.07 139.52,56.29 139.52,54.76 140.09,54.19 144.26,54.19 146.95,56.89 157.87,56.89 158.32,57.33 159.97,57.33 161.11,56.19 162.37,56.19 163.3,55.26 163.3,53.97 165.55,51.72 v1(167.46,51.72) ; v1(74.4,99.85) 74.73,100.18 79.3,100.18 82.82,96.66 93.86,96.66 98.37,101.17 107.01,101.17 110.48,97.7 111.7,97.7 115.34,94.06 116.31,94.06 116.99,93.37 116.99,91.19 119.02,89.16 124.49,89.16 130.4,83.25 130.4,78.04 131.96,76.48 v1(133.1,76.48)
  BOTTOM w0.102: Q3600.3 147.77,14.44 148.36,13.85 v1(149.05,13.85) ; v1(198.2,30.47) 198.25,30.42 PR7723.2 ; PR7834.2 169.79,50.03 169.67,50.14 169.67,50.42 169.24,50.85 168.33,50.85 v1(167.46,51.72) ; v1(167.12,21.36) 167.12,20.97 165.67,19.52 165.67,14.67 161.6,10.59 161.6,10.19 v1(161.51,10.11) ; R0416.2 133.2,76.38 v1(133.1,76.48) 129.9,76.48 129.49,76.08 129.49,75.39 131.37,73.51 131.37,69.83 132.72,68.48 135.08,68.48 135.4,68.16 R0410.1 135.4,67.32 136.42,66.3 R0400.2 137.11,66.3 137.49,65.92 137.49,65.15 137.1,64.76 137.1,64.02 136.77,63.69 136.77,63.44 v1(136.35,63.02)
PROCHOT#_R: length 9.5
  BOTTOM w0.076: U0400.C65 126.27,69.3 126.44,69.3 126.57,69.17 126.9,69.17 126.93,69.21 127.68,69.21 127.77,69.12 128.45,69.12 128.47,69.14
  BOTTOM w0.102: 128.47,69.14 129.6,69.14 130.14,68.61 132.06,68.61 132.64,68.02 v2(133.78,68.02) 133.9,68.02 R0410.2
PROCPWRGD: length 5.6
  BOTTOM w0.102: U0400.A68 127.53,71.57 128.12,72.16 128.12,75.8 T1202.1
PROG1_VCPU: length 2.4
  TOP w0.102: v1(171.73,47.27) 171.98,47.53 v2(171.98,47.86)
  TOP w0.229: PR7832.1 v1(171.73,47.27)
  BOTTOM w0.229: v1(171.73,47.27) 171.86,47.27 172.23,47.65 PU7800.32
PROG2_VCPU: length 4
  TOP w0.102: v2(173.43,46.87) 173.38,46.92 172.01,46.92 v1(171.68,46.59)
  TOP w0.229: v1(171.68,46.59) 171.15,46.59 PR7833.1
  BOTTOM w0.229: v1(171.68,46.59) 171.73,46.59 172.39,47.25 PU7800.31
PROJECT_ID0: length 13.8
  TOP w0.102: v3(111.5,35.06) 111.02,34.58 111.02,33.96 111.63,33.35 112.6,33.35 113.35,32.6 113.35,29.53 112.73,28.91 R1023.1 112.22,28.91 112.08,28.77 112.08,27.24 112.42,26.9 R1022.2 112.07,26.62 111.94,26.49 111.94,25.94 111.48,25.48 v2(111.18,25.48)
  BOTTOM w0.102: v3(111.5,35.06) 111.6,35.06 U0400.AK6
PROJECT_ID1: length 11.1
  TOP w0.102: v3(111.5,35.68) 111.88,35.3 111.88,34.35 113.55,32.69 113.55,29.4 113.59,29.36 R1027.1 114.05,28.45 114.05,27.26 113.41,26.62 R1024.2
  BOTTOM w0.102: U0400.AK7 111.57,35.68 v3(111.5,35.68)
PROJECT_ID2: length 12.7
  TOP w0.102: v3(111.5,36.96) 112.1,36.36 112.1,34.42 114.23,32.3 R1028.1 114.23,31.37 114.1,31.24 113.88,31.24 113.75,31.12 113.75,29.48 114.25,28.99 R1025.2
  BOTTOM w0.102: v3(111.5,36.96) 111.55,36.96 U0400.AK9
PROJECT_ID3: length 15.7
  TOP w0.102: v3(111.5,37.67) 112.32,36.85 112.32,34.51 114.71,32.12 R1029.1 115.24,28.43 115.24,27.13 115.16,27.05 R1026.2 115.16,26.29 115.29,26.16 115.49,26.16 115.62,26.04 115.62,25.38 v2(114.96,24.72)
  BOTTOM w0.102: v3(111.5,37.67) 111.61,37.67 U0400.AK10
PS8743_SBU1: length 24.5
  TOP w0.102: v1(25.5,86.36) 25.71,86.15 U5703.27 ; D5704.1 14.17,86.59 v1(15.01,85.75)
  IN3 w0.102: v1(25.5,86.36) 23.47,84.33 20.75,84.33 20.3,83.88 17.15,83.88 16.82,84.2 16.15,84.2 15.01,85.35 v1(15.01,85.75)
  BOTTOM w0.102: v1(25.5,86.36) 24.97,86.36 v2(24.87,86.26) ; v1(15.01,85.75) 14.73,85.47 10.44,85.47 9.78,86.13 9.78,86.88 9.46,87.2 9.09,87.2 8.7,87.59 8.2,87.59 8.04,87.75 CON5700.A8
PS8743_SBU2: length 30.7
  TOP w0.102: U5703.26 v1(26.11,86.24)
  IN1 w0.102: v1(10.08,82.7) 10.82,81.97 10.82,80.8 11.25,80.37 12.04,80.37 12.4,80.72 14.22,80.72 14.68,80.27 14.68,80.04 v1(14.81,79.91)
  IN3 w0.102: v1(14.81,79.91) 14.81,80.38 17.74,83.31 20.04,83.31 20.85,84.13 24,84.13 v1(26.11,86.24) ; CON5700.B8 6.02,85.76 6.1,85.67 6.1,85.58 6.17,85.42 6.38,85.19 6.59,85.04 7.21,84.41 9.25,84.41 10.08,83.57 v1(10.08,82.7)
  BOTTOM w0.102: v1(14.81,79.91) 14.71,80.01 14.71,80.17 14.07,80.8 D5705.1 ; v1(26.11,86.24) v2(26.75,86.24)
PS_ID: length 22
  TOP w0.102: U2300.36 27.96,41.1 v1(28.02,41.15)
  IN1 w0.102: v1(23.22,51.72) 23.5,51.44 23.5,44.09 26.43,41.15 v1(28.02,41.15)
  BOTTOM w0.102: PR7619.2 19.79,51.16 19.26,51.69 PD7601.3 ; PR7619.2 PR7607.2 ; PR7619.2 20.17,50.78 20.78,50.17 v2(22.2,50.17) 22.66,50.62 22.66,51.31 23.06,51.72 v1(23.22,51.72)
PSID_IN: length 10.8
  TOP w0.102: v1(38.68,96.83) 38.94,96.57 v2(44.65,96.57) PL7605.1
  BOTTOM w0.102: CON7600.4 37.83,100.37 37.83,97.68 v1(38.68,96.83)
PTP_DIS#: length 8.9
  TOP w0.102: v2(39.07,21.03) 39.37,21.03 40.3,21.97 D2300.2 40.3,22.74 39.97,23.07 39.6,23.07 38.99,23.68 38.99,26.09 38.5,26.58 U2300.90
PTP_DIS#_R: length 30.4
  TOP w0.102: v1(48.51,9.28) 48.51,12.22 49.2,12.91 49.2,14.41 50.38,15.59 v2(50.38,17.07) 50.38,19.14 50.09,19.43 47.8,19.43 45.12,22.12 45.12,22.52 44.93,22.71 43.51,22.71 43.18,22.38 D2300.1 ; R5108.2 v1(55.65,8.94)
  IN1 w0.102: v1(55.65,8.94) 55.22,9.38 54.43,9.38 53.92,8.86 52.12,8.86 51.71,9.28 v1(48.51,9.28)
  BOTTOM w0.102: v1(55.65,8.94) 55.65,9.37 55.73,9.46 CON5100.3
PU5101_EN1: length 173.8
  TOP w0.102: PR9205.1 143.1,26.29 143.23,26.16 143.23,25.25 142.9,24.92 142.57,24.92 v1(142.14,24.49) ; v1(48.62,22.23) 49.38,22.23 50.33,21.27 51.36,21.27 53.31,19.32 53.31,18.38 v1(54.79,16.91) ; v1(42.98,69.12) PR9000.1 41.73,69.17 42.21,69.64 v2(43.66,69.64) 44.17,69.13 44.92,69.13 46.34,70.55 PU9000.4
  IN2 w0.102: v1(142.14,24.49) 142.14,23.18 141.8,22.84 136.21,22.84 135.99,23.07 134.71,23.07 134.14,22.5 134.14,21.48 130.75,18.09 122.64,18.09 122.23,17.68 119.26,17.68 117.81,16.23 112.52,16.23 111.95,16.8 109.82,16.8 109.59,17.03 107.1,17.03 106.51,16.44 93.15,16.44 90.76,14.05 82.55,14.05 81.17,12.67 69.35,12.67 67.01,15.01 64.31,15.01 63.65,15.67 60.22,15.67 59.03,16.87 54.83,16.87 v1(54.79,16.91) ; v1(45.42,23.4) 45.42,24.27 42.67,27.01 42.67,33.48 40.97,35.18 40.97,39.6 41.68,40.31 41.68,43.21 42.27,43.79 42.27,46.36 41.68,46.94 41.68,52.64 46.46,57.42 46.46,62.46 47.63,63.63 47.63,67.68 46.77,68.54 43.55,68.54 v1(42.98,69.12)
  BOTTOM w0.102: v1(48.62,22.23) 46.58,22.23 v1(45.42,23.4)
PU5101_EN1_A: length 6.1
  TOP w0.203: PU9001.3 37.36,69.73
  TOP w0.254: v2(40.28,68.18) 40.87,68.76 PR9000.2 40.87,69.45 40.72,69.6 39.32,69.6 PR9001.1 38.02,69.07 37.36,69.73
PU5101_SS1_A: length 1.7
  TOP w0.203: PU9001.12 34.27,69.73
  TOP w0.254: PC9002.1 33.84,69.76 v2(33.95,69.65) 34.19,69.65 34.27,69.73
PU5101_SS2_A: length 11.3
  TOP w0.127: v2(33.02,74.07) 32.59,74.5 30.96,74.5 30.49,74.03 30.49,72.39 30.35,72.25 30.35,71.15 30.61,70.89 31.19,70.89 32,71.71 32.51,71.71 PC9007.1
  TOP w0.229: PU9001.10 34.07,70.53
  TOP w0.254: 34.07,70.53 33.91,70.69 PC9007.1
PU5101_VOUT1_S:
  vias: v2(33.88,67.77)
PU5101_VOUT2_S:
  vias: v2(33.66,71.53)
PU5102_EN1_A: length 2.9
  BOTTOM w0.102: PU9100.3 197.72,51.18 197.18,51.72 PR9110.1 196.8,51.31 196.79,51.3 PR9109.2
PU5102_EN2_A: length 3.4
  BOTTOM w0.102: PU9100.5 198.19,51.98 v2(197.61,52.56) 197.38,52.78 197.38,53.14 197.05,53.47 PR9107.1 197.05,53.9 196.91,54.04 PR9106.2
PU5102_SS1_A: length 1.9
  BOTTOM w0.102: PC9112.1 201.65,51.59 201.65,51.46 201.37,51.18 PU9100.12
PU5102_SS2_A: length 1.9
  BOTTOM w0.102: PU9100.10 200.82,51.98 201.19,52.35 201.47,52.35 PC9108.1
PU5102_VOUT2_S: length 2
  BOTTOM w0.508: 201.88,53.67 201.93,53.62 203.56,53.62 PR9108.2
PU5104_EN1_A: length 3.8
  BOTTOM w0.229: PU9101.3 180.11,12.94 180.47,12.58
  BOTTOM w0.432: 180.47,12.58 181,12.04 PR9101.1 PR9100.2 182.98,12.04 v2(183.06,11.97)
PU5104_EN2_A: length 4.5
  BOTTOM w0.102: v2(176.17,11.94) 176.38,11.74 177.37,11.74 177.67,12.04 PR9103.2
  BOTTOM w0.229: PU9101.5 179.31,12.66 179.2,12.55
  BOTTOM w0.432: PR9103.2 PR9104.1 179.04,12.4 179.2,12.55
PU5104_SS1_A: length 4.1
  BOTTOM w0.102: PC9102.1 179.71,16.94 179.78,17.02 180.04,17.02 180.16,17.15 180.16,18.27 v2(179.68,18.75)
  BOTTOM w0.229: PU9101.12 180.11,15.93
  BOTTOM w0.432: 180.11,15.93 180.11,16.16 PC9102.1
PU5104_SS2_A: length 2.9
  BOTTOM w0.102: v2(177.93,17.66) 177.93,17.38 178.74,16.56 PC9105.1
  BOTTOM w0.229: 179.06,16.27 179.31,16.02 PU9101.10
  BOTTOM w0.432: 179.06,16.27 PC9105.1
PU5104_VOUT1_S:
  vias: v2(182.6,16.64)
PU5104_VOUT2_S:
  vias: v2(176.99,16.21)
PU5106_EN1_A: length 4
  TOP w0.102: PR9205.2 PR9207.1 141.76,24.72 v1(141.5,24.46)
  BOTTOM w0.203: PU9200.3 140.3,24.18 v2(140.51,24.39) 140.59,24.46 v1(141.5,24.46)
PU5106_EN2_A: length 4.8
  TOP w0.102: v2(142.32,23.24) v1(141.63,23.24) 141.83,23.04 PR9201.1 142.29,22.41 142.37,22.33 PR9200.2
  BOTTOM w0.203: v1(141.63,23.24) 140.13,23.24 140,23.38 PU9200.5
PU5106_SS1_A: length 1.5
  BOTTOM w0.203: PU9200.12 136.94,24.18 136.78,24.33 PC9201.1
PU5106_SS2_A: length 2.3
  BOTTOM w0.203: PC9204.1 136.12,22.84 136.25,22.72 136.5,22.72 137.17,23.38 PU9200.10
PU5106_VOUT1_S:
  vias: v2(136.42,25.33)
PU5106_VOUT2_S:
  vias: v2(136.53,20.63)
PWM1_B: length 24.3
  TOP w0.102: v1(178.79,51.04) 178.79,50.27 v2(178.91,50.15)
  IN1 w0.381: v1(170.87,52.28) 170.87,51.73 170.14,51.01 164.43,51.01 v1(162.5,49.08)
  IN2 w0.381: v1(170.87,52.28) 170.87,51.18 171.26,50.79 172.59,50.79 172.9,51.09 176.64,51.09 177.06,50.68 177.75,50.68 178.12,51.04 v1(178.79,51.04)
  BOTTOM w0.229: v1(178.79,51.04) 178.17,51.04 177.57,50.45 PU7800.12
  BOTTOM w0.381: PR7918.1 161.27,48.57 161.77,49.08 v1(162.5,49.08)
PWM2_B: length 23.1
  IN3 w0.254: v1(164.82,58.65) 166.62,58.65 169.82,55.45 175.18,55.45 176.35,54.28 176.35,54.27 178.29,52.33 v1(178.29,50.41)
  BOTTOM w0.229: PU7800.13 177.71,50.05 178.06,50.41 v1(178.29,50.41)
  BOTTOM w0.254: PR7920.1 162.94,57.48 v2(163.78,58.32) 164.11,58.65 v1(164.82,58.65)
PWM_A: length 41.7
  TOP w0.102: v1(177.44,45.75) 176.94,46.26 v2(176.56,46.26)
  IN2 w0.254: v1(162.29,67.16) 162.29,66.17 163.47,64.99 163.47,61.68 165.51,59.64 174.24,59.64 174.85,59.03 179.25,59.03 179.43,58.85 179.43,58.08 179.43,58.08 179.43,52.61 179.65,52.38 179.65,48.46 179.55,48.36 179.55,48.29 178.97,47.7 178.97,46.3 178.41,45.75 v1(177.44,45.75)
  BOTTOM w0.229: v1(177.44,45.75) 176.93,45.75 176.3,46.37 PU7800.22
  BOTTOM w0.254: v1(162.29,67.16) 162.29,67.35 162.01,67.63 PR8016.1
PWM_C: length 52
  TOP w0.102: v1(149.37,30.28) v2(149.97,30.88)
  IN2 w0.102: v1(149.37,30.28) 149.76,30.66 157.11,30.66 159.97,33.52 159.97,40.97 155.02,45.93 155.02,49.41 155.42,49.81 159.36,49.81 159.69,49.48 163.04,49.48 164.21,48.31 167.59,48.31 168.15,47.75 171.17,47.75 171.25,47.68 171.9,47.68 172.14,47.44 172.14,46.74 v1(172.36,46.51)
  BOTTOM w0.102: PU7800.30 173.1,46.34 173,46.23 172.64,46.23 v1(172.36,46.51) ; v1(149.37,30.28) PR8014.1
PWMA_SW_OUT_S: length 1.9
  TOP w0.102: v4(145.97,67.97) 145.97,69.04 v2(146.57,69.64)
  vias: v4(146.86,67.95)
PWR_BTN#: length 280.8
  TOP w0.102: R2309.2 45.68,55.74 v1(45.42,55.48)
  IN2 w0.102: v1(203.94,38.43) 204.01,38.43 204.24,38.66 205.32,38.66 206.02,37.96 206.02,22.46 199.09,15.52 156,15.52 155.06,16.46 144.07,16.46 143.15,15.55 135.29,15.55 132.3,12.55 124.36,12.55 123.9,13.01 115.68,13.01 115.67,13.01 115.5,13.01 114.61,12.12 109.64,12.12 108.5,13.26 106.08,13.26 104.86,12.04 104.21,12.04 103.19,11.03 103.07,10.9 102.99,10.82 97.76,10.82 97.17,10.24 97.16,10.24 92.81,10.24 91.52,8.94 71.56,8.94 69.88,7.27 61.63,7.27 60.59,8.31 54.54,8.31 53.99,8.87 50.5,8.87 47.53,11.84 38.73,11.84 38.07,12.5 35.52,12.5 27.76,20.26 27.76,21.69 25.37,24.08 25.37,26.39 26.34,27.36 26.34,29.16 24.74,30.76 24.74,35.88 25.49,36.63 25.74,36.63 26.49,37.38 26.49,41.2 25.27,42.42 25.27,52.57 23.97,53.87 23.97,54.94 v1(24.18,55.16)
  BOTTOM w0.102: v1(203.94,38.43) 203.94,38.93 203.04,39.83 203.04,41.76 204.11,42.83 204.11,43.51 205.36,44.76 CON5103.44 ; v1(45.42,55.48) 44.27,54.33 25.86,54.33 v2(25.15,55.05) 25.04,55.16 v1(24.18,55.16)
PX_MODE: length 11.7
  BOTTOM w0.102: T6947.1 151.33,86.11 151.33,86.69 151.85,87.2 154.56,87.2 154.76,87.4 154.76,88.25 155.08,88.57 156.98,88.57 157.25,88.3 157.25,88.09 157.48,87.86 157.88,87.86 U6000.AB16
R: length 4.3
  BOTTOM w0.102: v2(10.47,38.41) 9.73,38.41 9.57,38.56 R3828.1
  BOTTOM w0.432: C3809.1 10.73,39.51 10.67,39.45 R3828.1
R_HPOUT_L: length 8.9
  BOTTOM w0.381: J3800.2 10.38,52.28 10.91,52.81 13.1,52.81 13.66,52.24 D3802.2 14.51,51.52 14.06,51.07 C3812.1 14.06,49.22 14.13,49.14 L3801.2
R_HPOUT_R: length 10.8
  BOTTOM w0.381: J3800.3 4.18,41.72 4.32,41.58 D3800.2 4.87,37.64 5.72,38.48 ; v2(6.83,38.48) 5.72,38.48 ; 5.72,38.48 5.25,38.95 C3810.1 L3804.2
RASA0#: length 44.1
  TOP w0.127: v1(170.05,92.42) 170.05,92.76 170.23,92.94 172.56,92.94 172.92,93.31 172.92,94.45 173.65,95.18 175.3,95.18 175.86,94.62 179.96,94.62 180.18,94.4 180.36,94.4 181.54,93.22 181.54,93.04 181.17,92.67 181.17,92.49 181.35,92.31 181.53,92.31 181.9,92.68 182.08,92.68 182.26,92.5 182.26,92.32 181.89,91.95 181.89,91.78 182.07,91.6 182.25,91.6 182.61,91.96 182.79,91.96 182.97,91.78 182.97,91.6 182.61,91.24 182.61,91.06 182.79,90.88 182.97,90.88 183.33,91.24 v2(183.67,91.24) 185.72,91.24 186.08,90.88 190.86,90.88 192.13,92.15 192.13,97.2 193.39,98.46 193.39,100.32 194.39,101.32 195.5,101.32 195.75,101.07 v1(195.75,100.61) 195.75,100.58 U6801.L3
  BOTTOM w0.102: v1(170.05,92.42) 170.05,92.64 U6000.G22
  BOTTOM w0.127: U6801.L3 195.75,100.58 v1(195.75,100.61)
RASA1#: length 50.5
  TOP w0.127: U6803.G3 188.93,81.2 v1(188.57,81.56) 186.53,81.56 184.08,84.02 183.04,84.02 182.77,84.29 182.77,85.45 182.64,85.57 181.61,85.57 181.48,85.7 181.48,85.95 181.61,86.08 182.64,86.08 182.77,86.21 182.77,86.46 182.64,86.59 181.61,86.59 181.48,86.72 181.48,86.97 181.61,87.1 182.51,87.1 182.64,87.22 182.64,87.46 182.51,87.58 181.28,87.58 181.15,87.46 181.15,85.12 181.02,84.99 180.77,84.99 180.64,85.12 180.64,86.37 ; v1(171.81,89.99) 172.63,89.17 172.63,88.99 172.33,88.68 172.33,88.5 172.5,88.34 172.7,88.34 172.99,88.63 173.17,88.63 173.35,88.45 173.35,88.27 173.06,87.98 173.06,87.8 173.24,87.62 173.42,87.62 173.71,87.91 173.89,87.91 174.09,87.71 174.34,87.71 174.47,87.58 174.47,87.42 174.6,87.29 174.85,87.29 174.98,87.42 174.98,87.58 175.11,87.71 175.36,87.71 175.49,87.58 175.49,87.42 175.61,87.29 175.87,87.29 175.99,87.42 175.99,88.04 176.12,88.17 177.09,88.17 177.22,88.04 177.22,87.75 177.35,87.62 177.6,87.62 177.73,87.75 177.73,88.04 177.86,88.17 178.38,88.17 178.61,87.94 178.61,84.51 178.74,84.38 178.99,84.38 179.12,84.51 179.12,87.58 179.25,87.71 179.5,87.71 179.63,87.58 179.63,85.07 179.75,84.94 180.01,84.94 180.13,85.07 180.13,87.58 180.26,87.71 180.52,87.71 180.64,87.58 180.64,86.37 ; 180.64,86.37 v2(180.65,86.36)
  BOTTOM w0.102: v1(171.81,89.99) 171.36,89.55 171.09,89.55 170.96,89.42 U6000.G17
  BOTTOM w0.127: v1(188.57,81.56) 188.93,81.2 U6803.G3
RESET_OUT#: length 95.4
  TOP w0.102: v1(57.91,20.46) 57.91,20.4 57.89,20.37 57.89,19.38 58.57,18.7 58.57,16.34 v2(60.18,14.73) 60.96,14.73 v1(61.7,14) ; U2300.73 31.7,27.38 v1(31.42,27.1)
  IN2 w0.102: v1(31.42,27.1) 31.42,21.15 36.98,15.6 40.71,15.6 41.49,14.81 43.88,14.81 44.16,15.09 46.76,15.09 47.56,14.3 48.1,14.3 48.79,14.99 50.39,14.99 52.63,12.75 56.6,12.75 57.85,14 v1(61.7,14) ; v1(57.91,20.46) 58.07,20.46 58.37,20.75 63.65,20.75 63.89,20.51 70.61,20.51 70.74,20.37 75.22,20.37 75.58,20.74 78.26,20.74 81.7,24.18 85.19,24.18 85.28,24.1 86.12,24.1 86.51,24.49 86.51,25 89.74,28.22 91.01,28.22 92.43,26.8 93.24,26.8 94.16,25.89 94.23,25.89 v1(95.57,24.54)
  BOTTOM w0.102: R1228.1 96.47,24.16 96.42,24.11 96.01,24.11 v1(95.57,24.54)
RING2: length 22.9
  IN3 w1.016: 12.08,31.81 12.08,35.32 14.3,37.54 14.3,39.45 14.09,39.66 14.09,53.74
  vias: v1(12.57,29.03) v1(13.18,29.06) v1(13.56,54.97) v1(13.56,54.36)
RR_HPOUT_L: length 1
  BOTTOM w0.381: L3801.1 14.13,46.83 14.15,46.81 R3802.2
RR_HPOUT_R: length 2.5
  BOTTOM w0.381: v2(8.86,40.31) 8.36,40.82 R3803.2 6.62,40.82 L3804.1
RSMRST#: length 65.5
  TOP w0.102: v1(75.49,15.37) 75.49,14.66 72.48,11.65 72.48,10.83 71.96,10.3 71.96,9.2 71.02,8.26 R1217.1 ; v1(91.09,25.73) 90.45,25.73 90.23,25.95 90.23,26.76 90.65,27.18 R1226.1
  IN1 w0.102: v1(75.49,15.37) 75.9,14.96 78.7,14.96 80.64,16.89 85.75,16.89 87.8,18.94 87.8,22.93 87.98,23.11 87.98,24.18 88.72,24.92 90.28,24.92 v1(91.09,25.73)
  BOTTOM w0.076: U0400.AY17 105.7,42.71 104.54,42.71 104.43,42.64 103.67,42.64 103.3,42.27 102.77,42.27
  BOTTOM w0.102: 102.77,42.27 101.44,42.27 100.77,41.61 100.18,41.61 99.92,41.35 C1203.1 99.92,41.18 99.57,40.82 98.17,40.82 98.07,40.72 R1216.1 97.69,40.29 97.46,40.06 95.23,40.06 v2(91.04,35.87) 89.39,34.22 89.39,29.18 89.87,28.7 90.17,28.7 90.83,28.04 90.83,25.99 v1(91.09,25.73) ; U1202.4 75.43,15.43 v1(75.49,15.37)
RTC_DET#: length 275.7
  TOP w0.102: v2(117.3,22.03) v1(117.98,22.03) 118.38,22.43 R1503.2
  IN2 w0.102: v1(48.08,83.06) 48.49,83.47 48.49,91.48 52.49,95.48 67.16,95.48 67.95,96.27 72.43,96.27 72.99,95.71 97.84,95.71 99.7,93.86 103.71,93.86 105.23,92.33 108.05,92.33 111.73,88.65 114.63,88.65 v1(114.99,89)
  IN3 w0.076: 118.71,30.89 118.71,31.6 119.05,31.94 v3(119.13,31.94)
  IN3 w0.102: v1(48.08,83.06) 48.08,72.37 43.38,67.67 43.38,59.35 38.87,54.84 35.25,54.84 30.76,50.35 30.76,48.1 30.87,47.99 30.87,41.09 32.04,39.92 32.04,35.77 33.48,34.34 33.48,32.71 35.36,30.83 35.36,29.43 39.45,25.34 41.57,25.34 44.68,22.23 45.91,22.23 48.19,19.94 49.92,19.94 52.69,17.17 52.69,15.09 52.55,14.96 52.55,13.94 53.56,12.94 58,12.94 58.65,13.59 63.81,13.59 64.26,14.05 65.43,14.05 66.27,13.21 69.49,13.21 69.98,12.73 71.75,12.73 73.08,14.05 73.08,14.68 76.17,17.77 76.17,18.24 78.32,20.39 78.87,20.39 79.38,19.88 79.38,18.44 81.62,16.2 87.76,16.2 89.42,14.54 91.5,14.54 91.81,14.85 93.36,14.85 93.98,15.47 93.98,16.04 94.82,16.88 105.01,16.88 106.57,18.44 108.9,18.44 109.14,18.2 114.25,18.2 115.28,19.23 117.45,19.23 117.84,19.62 117.84,21.64 118.03,21.83 118.03,21.98 v1(117.98,22.03) 117.98,22.4 119.02,23.44 119.02,27.92 119.01,27.93 119.01,28.69 119.53,29.21 119.53,29.79 119.14,30.18 119.13,30.18 118.71,30.6 118.71,30.89
  BOTTOM w0.076: U0400.P1 119.81,32.48 119.27,31.94 v3(119.13,31.94)
  BOTTOM w0.102: Q3601.3 111.23,81.97 112.75,83.49 112.75,86.77 v1(114.99,89)
RTC_RST#: length 30.4
  TOP w0.102: v1(110.2,25.31) 110.62,24.89 110.62,24.01 v2(110.44,23.83)
  IN2 w0.109: v1(110.2,25.31) 110.61,25.72 110.61,27.2 110.4,27.41 110.4,30.79 110.19,30.99 110.19,32.53 111.47,33.81 111.56,33.81 112.2,34.45 112.2,40.26 111.33,41.13 v3(111.33,41.28)
  BOTTOM w0.089: U0400.AM16 111.33,41.47 v3(111.33,41.28)
  BOTTOM w0.102: Q1000.3 109.37,18.62 109.63,18.88 109.63,21.16 109.88,21.41 110.69,21.41 C1005.1 111.48,22.2 111.86,22.2 112.14,22.48 112.14,23.17 R1011.2 111.58,24.26 111.61,24.28 111.61,24.95 111.24,25.31 v1(110.2,25.31)
RTC_X1: length 24.4
  TOP w0.102: v2(92.49,41.06) 92.66,41.22 R1008.2 93.02,41.81 93.12,41.91 93.12,42.47 93.32,42.67 C1003.1 94.3,42.67 R1007.2 95.42,43.04 95.99,43.61 103.36,43.61 103.76,43.21 103.76,42.82 104.39,42.19 104.83,42.19 105.41,41.61 109.75,41.61 109.83,41.68 110.29,41.68 110.31,41.66 111.55,41.66 111.89,42 111.89,42.62 v3(111.32,43.2)
  BOTTOM w0.102: U0400.AM18 111.04,42.91 v3(111.32,43.2)
RTC_X2: length 26
  TOP w0.102: C1002.1 93.94,44.57 94.6,43.91 R1007.1 95.64,43.91 95.73,43.82 103.44,43.82 103.96,43.3 103.96,42.91 104.45,42.42 104.92,42.42 105.53,41.81 109.65,41.81 109.72,41.88 110.44,41.88 110.46,41.86 111.46,41.86 111.68,42.08 111.68,42.4 111.31,42.78 111.13,42.78 v3(110.72,43.18) ; C1002.1 92.85,44.57 92.18,43.89 92.18,43.67 91.93,43.42 X1001.1 ; C1002.1 92.94,45.29 v2(93.12,45.47)
  BOTTOM w0.102: U0400.AM20 111.04,43.5 v3(110.72,43.18)
