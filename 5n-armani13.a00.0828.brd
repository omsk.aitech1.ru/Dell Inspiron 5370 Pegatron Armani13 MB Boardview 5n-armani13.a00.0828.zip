# Allegro board 5n-armani13.a00.0828.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 45.02,106.85 45.02,103.37 43.66,102.01 43.66,99.6 43.85,99.41 43.85,98.77 43.76,98.68 43.41,98.68 43.31,98.78 43.31,99.37 43,99.67 42.34,99.67 42.09,99.42 41.77,99.42 40.99,98.64 38.74,98.64 38.58,98.81 38.58,101.21 39.4,102.03 39.4,104.4 41.99,106.99 44.88,106.99
GND on BOTTOM (solid shape): 196.37,53.83 196.37,53.19 196.19,53.01 196.19,52.45 196.09,52.35 196.09,51.59 195.96,51.46 195.47,51.46 195.35,51.48 195.24,51.46 195.2,51.46 195.12,51.54 195.12,51.81 195.13,51.86 195.14,51.89 195.33,52.07 195.33,53.49 195.45,53.62 195.76,53.62 196.01,53.88 196.32,53.88
GND on BOTTOM (solid shape): 152.95,8.97 152.27,8.82 151.57,8.23 151.35,8.17 150.15,8.17 150.15,9.67 152.95,9.67
GND on BOTTOM (solid shape): 83.52,111.46 83.52,109.88 82.86,109.22 82.86,108.69 82.8,108.64 82.47,108.64 82.42,108.69 82.42,109.1 82.4,109.12 82.22,109.12 82.19,109.1 82.19,108.64 81.79,108.64 81.79,109.07 81.74,109.12 81.59,109.12 81.56,109.1 81.56,108.64 77.44,108.64 77.11,108.97 77.11,110.47 77.42,110.77 80.47,110.77 81.28,111.58 83.39,111.58
GND on BOTTOM (solid shape): 197.57,66.72 197.57,65.74 198.12,65.19 198.12,64.57 197.71,64.16 196.34,64.16 196.09,64.42 196.09,64.87 195.99,64.98 194.28,64.98 193.95,65.31 193.95,65.56 193.53,65.98 193.53,66.23 193.29,66.47 192.37,66.47 192.36,66.47 191.99,66.47 191.98,66.48 191.98,66.7 191.99,66.71 193.59,66.71 193.86,66.98 197.31,66.98
GND on BOTTOM (solid shape): 31.34,107.32 31.46,107.18 31.64,107.11 31.93,106.99 32.21,107.11 32.23,107.09 32.23,103.71 31.67,103.15 29.26,103.15 28.32,104.09 28.32,106.1 29.54,107.32
GND on BOTTOM (solid shape): 179.78,15.65 179.78,14.89 179.91,14.76 182.5,14.76 182.52,14.73 182.52,13.62 182.42,13.52 181.33,13.52 181.2,13.64 181.2,13.9 181.15,13.95 178.38,13.95 178.22,13.78 178.22,13.63 178.11,13.52 178.03,13.52 178,13.49 177.99,13.49 177.52,13.02 176.57,13.02 176.45,13.13 176.45,14.56 176.66,14.76 179.53,14.76 179.6,14.84 179.6,15.65 179.65,15.7 179.73,15.7
GND on BOTTOM (solid shape): 200.2,54.69 200.2,53.83 200,53.62 200,50.24 200.16,50.08 201.26,50.08 201.43,49.9 201.43,48.78 201.65,48.57 202.29,48.57 202.41,48.44 202.41,48.03 202.34,47.96 201.52,47.96 201.12,48.36 201.12,49.46 200.89,49.68 199.14,49.68 199.03,49.79 199.03,53.63 199,53.67 199,54.93 199.09,55.02 199.87,55.02
GND on BOTTOM (solid shape): 93.75,113.06 93.75,111.31 93.68,111.24 92.81,111.24 92.7,111.12 92.7,109.77 92.79,109.68 94.18,109.68 94.41,109.45 94.41,108.87 94.31,108.77 92.34,108.77 92.34,109.45 90.65,109.45 90.5,109.6 90.5,112.98 90.51,112.99 91.83,112.99 92.28,113.06 92.69,113.26 93.55,113.26
GND on BOTTOM (solid shape): 177.44,35.36 181.66,35.36 181.85,35.17 182.54,35.17 182.91,34.8 182.91,30.97 182.78,30.84 181.13,30.84 181,30.71 181,29.67 180.8,29.47 178.66,29.47 178.41,29.72 178.41,29.8 178.4,29.88 178.4,32.49 178.34,32.49 178.34,33.36 177.94,33.76 177.75,33.76 177.36,34.15 176.88,34.15 176.74,34.29 176.74,35.29 176.3,35.72 174.77,35.72 174.77,35.73 174.77,35.96 176.84,35.96
GND on BOTTOM (solid shape): 125.45,112.14 125.45,107.75 125.22,107.52 124.38,107.52 124.28,107.42 124.28,106.1 125.17,105.21 125.17,104.29 125.35,104.12 132.33,104.12 133.17,103.28 133.17,99.49 132.99,99.32 132.18,99.32 132.03,99.16 132.03,97.94 131.9,97.82 130.61,97.82 130.51,97.92 130.51,102.59 130.2,102.9 124.13,102.9 123.9,103.13 123.9,105.49 122.78,106.61 122.78,110.95 122.35,111.38 116.97,111.38 116.51,111.84 116.51,113.97 116.94,114.4 123.19,114.4
GND on BOTTOM (solid shape): 186.31,94.97 186.31,94.76 186.31,94.75 186.28,94.62 186.31,94.49 186.31,94.48 186.31,93.11 186.26,92.93 186.3,92.74 186.31,92.73 186.31,92.61 186.23,92.53 186,92.53 185.62,92.92 185.62,94.44 185.24,94.82 185.06,94.82 184.95,94.94 184.95,95.47 185.08,95.61 185.67,95.61
GND on BOTTOM (solid shape): 10.63,73.9 9.95,73.9 9.65,74.3 9.18,74.45 4.74,74.45 4.74,75.11 4.89,75.55 4.74,75.99 4.74,79.8 10.63,79.8
GND on BOTTOM (solid shape): 139.8,66.35 139.8,65.48 139.65,65.33 138.3,65.33 138.11,65.14 138.11,63.34 137.57,62.79 137.57,57.84 137.41,57.69 136.32,57.69 136.04,57.97 136.04,62.51 136.14,62.61 136.53,62.61 136.75,62.84 136.75,63.17 137.08,63.5 137.08,63.63 137.3,63.85 137.3,64.68 137.8,65.18 137.8,66.22 138.05,66.47 139.67,66.47
GND on BOTTOM (solid shape): 189.99,18.43 200.15,18.43 200.15,20.31 203.12,20.31 203.12,12.65 187.02,12.65 187.02,14.53 200.33,14.53 200.33,15.53 203.02,15.53 203.02,19.13 201.42,19.13 201.42,15.53 200.33,15.53 200.33,16.23 197.61,16.23 197.61,14.53 192.53,14.53 192.53,16.23 189.81,16.23 189.81,14.53 187.02,14.53 187.02,15.53 188.72,15.53 188.72,19.13 187.12,19.13 187.12,15.53 187.02,15.53 187.02,20.31 189.99,20.31
GND on BOTTOM (solid shape): 8.14,84.23 9.2,84.23 9.29,84.13 9.29,83.9 8.93,83.54 8.36,83.54 7.83,84.18 7.12,83.76 7.12,84.04 7.08,84.24 6.97,84.41 7.95,84.41
GND on BOTTOM (solid shape): 19.03,36.77 19.03,36.1 19.08,36.1 19.08,35.54 18.7,35.17 17.2,35.17 17.08,35.04 17,34.98 16.93,34.89 16.59,34.55 16.48,34.55 16.46,34.57 16.2,34.57 15.87,34.9 15.85,34.95 15.85,35.77 16,35.92 17.76,35.92 18.01,36.17 18.27,36.17 18.27,36.73 18.3,36.8 18.37,36.83 18.44,36.84 18.52,36.86 18.95,36.86
GND on BOTTOM (solid shape): 172.39,43.79 173.61,43.79 173.68,43.72 173.68,43.2 173.69,43.2 173.69,42.49 173.63,42.44 173.03,42.44 173,42.47 172.95,42.47 172.91,42.51 172.87,42.55 172.47,42.58 172.26,42.24 172.08,42.06 171.88,42.06 171.78,42.25 171.6,42.36 171.6,44.02 171.68,44.1 172.09,44.1
GND on BOTTOM (solid shape): 182.75,46.75 182.75,46.14 182.8,46.1 182.8,45.88 182.98,45.7 183.36,45.7 183.46,45.6 183.46,44.37 183.99,43.84 183.99,43.43 183.9,43.33 182.13,43.33 182,43.21 182,42.43 181.2,41.63 174.94,41.63 174.83,41.74 174.83,42.98 174.96,43.11 180.59,43.11 180.96,43.47 180.96,45.42 181.13,45.59 181.15,45.58 181.52,45.67 181.66,46.03 181.66,46.06 181.66,46.12 182.35,46.81 182.7,46.81
GND on BOTTOM (solid shape): 117.27,24.97 117.93,24.97 117.96,24.95 117.96,24.26 117.88,24.18 117.15,24.18 117.12,24.21 116.58,24.42 116.46,23.85 116.46,23.62 116.41,23.57 115.93,23.57 115.9,23.6 115.9,24.53 115.95,24.57 115.94,24.64 115.96,24.76 116.03,24.85 116.04,24.85 116.28,25.1 117.15,25.1
GND on BOTTOM (solid shape): 9.4,90.81 9.4,90.37 9.4,90.32 9.4,90.28 9.4,89.81 9.3,89.71 9.3,89.71 9.2,89.61 8,89.61 7.99,89.6 7.39,89.6 7.36,89.63 7.36,89.76 7.4,89.84 7.5,89.86 7.52,89.85 8.15,89.98 8.34,90.59 8.36,90.68 8.44,90.71 8.55,90.71 8.78,90.94 9.26,90.94
GND on BOTTOM (solid shape): 168.88,50.24 168.88,49.78 168.86,49.77 168.65,49.54 168.67,49.24 168.68,49.2 168.61,49.13 168.59,49.12 168.47,49.09 168.37,49.02 167.92,49.02 167.31,48.41 167.31,45.9 167.21,45.8 166.68,45.8 166.55,45.93 166.55,47.04 166.68,47.17 166.68,49.25 167.2,49.78 167.31,49.78 167.32,49.78 167.62,49.81 167.81,50.04 167.81,50.06 168.12,50.37 168.76,50.37
GND on BOTTOM (solid shape): 152.63,73.97 152.63,64.95 152.17,64.49 152.17,59.39 152.63,58.93 152.63,55.55 153.24,54.94 153.24,54.21 152.83,53.8 152.83,45.83 152.96,45.7 152.96,41.89 153.98,40.87 153.98,39.73 153.77,39.52 150.62,39.52 150.29,39.86 150.29,43.72 149.73,44.27 149.73,45.01 149.89,45.16 149.91,45.16 150.17,45.42 150.17,48.8 150.34,48.97 150.9,48.97 151.23,49.3 151.23,49.61 151.24,49.62 151.24,49.95 151.36,50.07 151.97,50.07 152.07,50.17 152.07,51.62 151.82,51.87 144.09,51.87 143.61,52.35 143.61,55.17 143.84,55.4 144.73,55.4 144.82,55.49 145.58,55.49 146.1,56.01 150.09,56.01 150.19,56.11 150.19,58.23 150.09,58.23 150.09,59.08 149.53,59.64 149.53,62.44 150.52,63.43 150.52,64.29 149.15,65.66 149.15,68.73 149.91,69.5 149.91,72.62 150.9,72.62 151.03,72.75 151.03,74.27 152.33,74.27
GND on BOTTOM (solid shape): 11.75,87.33 13.54,87.33 13.66,87.45 13.89,87.45 14.55,86.79 14.55,85.91 14.3,85.65 11.58,85.65 11.5,85.69 11.49,85.79 11.51,85.94 11.46,86.09 11.2,86.28 10.89,86.21 10.85,86.2 10.82,86.21 10.63,86.35 10.41,86.35 10.32,86.36 10.27,86.44 10.27,86.93 10.52,87.18 10.52,87.5 10.56,87.55 10.61,87.6 10.76,87.75 11.33,87.75
GND on BOTTOM (solid shape): 126.25,65.46 126.45,65.37 126.45,65.14 126.16,64.85 126.12,64.86 125.96,64.89 125.81,64.82 125.53,64.82 125.21,64.86 125.07,64.57 125.05,64.49 124.99,64.45 124.87,64.44 124.76,64.39 124.56,64.39 124.41,64.54 124.41,64.67 124.59,64.88 124.56,65.16 124.55,65.21 124.58,65.25 124.63,65.27 124.72,65.3 124.79,65.36 124.86,65.36 124.96,65.46 125.61,65.46
GND on BOTTOM (solid shape): 17.54,95.47 17.54,94.2 16.61,93.27 15.6,93.27 15.05,92.73 12.03,92.73 11.98,92.68 11.58,93.07 11.58,93.6 14.12,93.6 14.13,93.55 14.14,93.49 14.16,93.44 14.18,93.39 14.22,93.35 14.26,93.31 14.3,93.28 14.35,93.25 14.41,93.23 14.46,93.22 14.52,93.22 14.57,93.23 14.63,93.24 14.68,93.26 14.73,93.29 14.77,93.33 14.81,93.37 14.84,93.41 14.86,93.46 14.88,93.52 14.88,93.57 14.88,93.63 14.88,93.68 14.86,93.74 14.84,93.79 14.81,93.84 14.77,93.88 14.73,93.91 14.68,93.94 14.63,93.96 14.57,93.98 14.52,93.98 14.46,93.98 14.41,93.97 14.35,93.95 14.3,93.93 14.26,93.9 14.22,93.86 14.18,93.81 14.16,93.76 14.14,93.71 14.13,93.66 14.12,93.6 11.58,93.6 11.58,94.49 14.44,94.49 14.53,94.49 14.7,94.5 14.87,94.52 15.04,94.54 15.21,94.58 15.38,94.62 15.54,94.67 15.7,94.73 15.86,94.79 16.02,94.87 16.17,94.95 16.32,95.04 16.46,95.13 16.6,95.23 16.73,95.34 16.86,95.46 16.96,95.56 17.45,95.56
GND on BOTTOM (solid shape): 44.81,95.63 44.81,91.65 42.62,89.46 34.76,89.46 34.63,89.59 34.63,90.53 36.78,90.53 36.78,90.47 36.79,90.42 36.81,90.37 36.84,90.32 36.88,90.27 36.92,90.23 36.96,90.2 37.01,90.18 37.06,90.16 37.12,90.15 37.17,90.15 37.23,90.15 37.28,90.17 37.34,90.19 37.38,90.22 37.43,90.25 37.46,90.29 37.49,90.34 37.52,90.39 37.53,90.45 37.54,90.5 37.54,90.56 37.53,90.61 37.52,90.66 37.49,90.72 37.46,90.76 37.43,90.8 37.38,90.84 37.34,90.87 37.28,90.89 37.23,90.9 37.17,90.91 37.12,90.91 37.06,90.9 37.01,90.88 36.96,90.85 36.92,90.82 36.88,90.78 36.84,90.74 36.81,90.69 36.79,90.64 36.78,90.58 36.78,90.53 34.63,90.53 34.63,91.47 35.02,91.86 37.65,91.86 37.74,91.95 37.78,91.98 37.82,92.02 37.85,92.07 37.87,92.12 37.89,92.17 37.9,92.23 37.9,92.28 37.89,92.32 37.89,95.1 38.3,95.51 43.66,95.51 43.81,95.66 43.86,95.66 43.92,95.67 43.98,95.69 44.03,95.73 44.08,95.76 44.1,95.79 44.65,95.79
GND on BOTTOM (solid shape): outline of 85 points within 138.12,12.02 146.58,16.69
GND on BOTTOM (solid shape): 107.67,46.66 107.67,46.6 107.65,46.58 107.57,46.52 107.52,46.44 107.24,46.15 107.23,46.14 107.14,45.89 107.24,45.65 107.27,45.61 107.28,45.57 107.3,45.54 107.33,45.55 107.38,45.53 107.43,45.49 107.45,45.43 107.45,45.39 107.43,45.34 107.38,45.34 107.21,45.39 107.04,45.36 107.03,45.35 106.41,45.35 106.39,45.34 106.29,45.34 106.2,45.43 105.6,45.43 105.56,45.47 105.56,45.72 105.69,45.85 106.27,45.85 106.42,45.99 106.45,45.97 106.84,46.03 106.78,46.42 106.78,46.77 106.83,46.81 107.52,46.81
GND on BOTTOM (solid shape): 165.66,67.9 165.66,66.5 165.68,66.47 166.57,66.47 166.7,66.35 166.7,65.31 166.52,65.13 165.49,65.13 165.13,65.49 165.13,66.18 164.14,66.18 164.14,66.19 163.69,66.19 163.68,66.18 163.59,66.18 163.59,66.1 163.58,66.08 163.58,66.05 163.51,66.05 163.51,65.56 163.53,65.5 163.47,65.45 163.47,60.53 163.35,60.4 162.28,60.4 161.87,60.81 161.87,62.59 162.03,62.74 162.47,62.8 162.69,63.18 162.69,63.2 162.77,63.27 162.77,63.9 162.52,64.14 161.93,64.14 161.93,64.15 160.27,64.15 160.26,64.16 159.91,64.16 159.87,64.2 159.87,65.14 159.92,65.19 160.51,65.19 160.52,65.18 160.82,65.18 160.83,65.19 161.43,65.19 161.43,65.33 161.51,65.33 161.51,65.81 161.43,65.81 161.43,65.95 161.41,65.95 161.41,66.28 161.56,66.42 161.97,66.42 162.09,66.3 162.09,66.2 162.18,66.12 162.64,66.12 163.09,66.57 163.09,67.08 163.09,67.08 163.23,67.22 164.63,67.22 164.71,67.31 164.71,67.78 164.74,67.85 164.81,67.87 164.97,67.9 165.11,68 165.56,68
GND on BOTTOM (solid shape): 132.74,49.3 137.13,49.3 137.29,49.15 137.29,44.71 138.2,43.79 140.21,43.79 141.43,42.57 141.43,40.29 141.17,40.03 138.66,40.03 138.06,40.63 138.06,43.21 134.49,46.78 134.49,47.55 134.59,47.65 134.87,47.65 134.98,47.54 134.98,47.5 135.52,46.91 135.74,47.68 135.72,47.72 135.74,47.75 135.65,48.45 134.98,48.24 134.97,48.21 133.32,48.21 133.31,48.22 130.7,48.22 130.33,48.59 130.12,48.59 129.9,48.82 129.9,49.48 130.02,49.61 132.44,49.61
GND on BOTTOM (solid shape): 48.31,70.69 48.31,66.98 47.4,66.07 47.4,64.85 47.15,64.59 46.11,64.59 46.02,64.65 46.02,64.75 45.81,65.43 45.33,64.9 45.33,64.89 45.3,64.86 45.3,64.79 45.29,64.76 45.27,64.74 45.24,64.71 45.21,64.68 45.1,64.66 45.03,64.76 45.03,69.01 46.47,70.45 46.56,70.48 46.63,70.43 47.14,70.27 47.31,70.77 47.31,70.78 47.31,70.84 47.39,70.84 47.78,71.23
GND on BOTTOM (solid shape): outline of 105 points within 52.73,100.84 74.35,108.94
GND on BOTTOM (solid shape): 124.04,49.31 124.07,49.29 124.17,49.23 124.29,49.2 124.3,49.17 124.3,49.14 124.29,49.1 124.29,49.07 124.3,48.98 124.28,48.94 124.02,48.81 123.92,48.57 124.01,48.33 124.24,48.21 124.26,48.2 124.29,48.17 124.3,48.09 124.28,48.06 124.25,48.04 124,47.9 123.93,47.62 123.94,47.58 123.88,47.55 123.85,47.53 123.79,47.5 123.75,47.48 123.55,47.48 123.39,47.63 123.39,47.91 123.42,47.93 123.55,48.17 123.42,48.41 123.39,48.42 123.39,48.83 123.42,48.84 123.52,48.95 123.55,49.09 123.55,49.11 123.65,49.2 123.67,49.2 123.85,49.2 124,49.29
GND on BOTTOM (solid shape): 207.73,113.53 208.8,113.53 209.09,113.23 209.09,111.18 209.04,111.09 208.94,111.1 208.76,111.15 208.57,111.11 208.56,111.11 208.42,111.11 208.42,111.2 207.74,111.2 207.74,111.15 207.73,111.15 207.73,110.39 207.74,110.39 207.74,110.25 207.56,110.25 207.56,110.62 207.59,110.77 207.56,110.92 207.56,110.93 207.56,111.2 206.88,111.2 206.88,111.15 205.33,111.15 205.04,110.86 205.03,110.86 204.92,110.2 205.57,110.32 205.58,110.32 205.64,110.39 206.87,110.39 206.87,109.81 207.29,109.4 207.29,108.77 208.25,108.77 208.25,108.98 208.27,108.98 208.27,110.33 208.42,110.33 208.42,110.42 208.58,110.42 208.59,110.42 208.77,110.39 208.94,110.45 209.04,110.45 209.09,110.36 209.09,108.74 208.54,108.19 208.54,107.65 208.25,107.65 208.25,107.44 208.24,107.44 208.24,106.94 207.61,106.31 207.32,106.31 207.32,105.82 207.04,105.54 206.63,105.54 206.17,106 206.17,109.58 206.07,109.68 203.86,109.68 203.32,110.22 203.32,110.58 203.89,111.16 203.89,112.45 204.24,112.8 205.12,112.8 205.12,112.58 206.4,112.58 206.4,113.54 205.13,113.54 205.13,113.46 205.03,113.46 205.04,113.47 205.04,113.83 207.73,113.83
GND on BOTTOM (solid shape): 114.72,72.13 114.79,72.11 114.86,72.11 114.89,72.12 114.94,72.05 114.97,71.96 114.94,71.86 114.91,71.82 114.91,71.44 114.94,71.4 114.97,71.3 114.94,71.21 114.91,71.17 114.91,70.79 114.94,70.75 114.97,70.65 114.94,70.55 114.91,70.52 114.91,70.14 114.94,70.1 114.97,70 114.94,69.9 114.91,69.87 114.91,69.49 114.94,69.45 114.97,69.35 114.94,69.25 114.91,69.22 114.91,68.84 114.94,68.8 114.96,68.72 114.95,68.63 114.88,68.56 114.72,68.56 114.68,68.62 114.64,68.66 114.46,68.79 114.24,68.8 114.21,68.8 114.18,68.83 114.15,68.88 114.11,68.94 114.11,69.12 114.2,69.35 114.11,69.59 114.11,69.77 114.2,70 114.11,70.24 114.11,70.42 114.2,70.64 114.12,70.87 114.11,70.89 114.11,70.97 114.15,70.98 114.38,71.15 114.38,71.44 114.37,71.46 114.41,71.52 114.65,71.77 114.65,72.1 114.69,72.13
GND on BOTTOM (solid shape): 125.26,63.22 125.34,63.21 125.43,63.22 125.44,63.22 125.9,63.22 125.91,63.22 126,63.21 126.08,63.22 126.09,63.22 126.25,63.22 126.48,62.99 126.48,62.79 126.41,62.72 126.37,62.72 126.37,62.72 126.22,62.72 126.2,62.74 126.14,62.74 126.04,62.78 125.69,62.78 125.65,62.74 125.44,62.74 125.26,62.56 125.19,62.53 125.12,62.56 124.69,62.62 124.52,62.23 124.53,62.2 124.48,62.15 124.44,62.13 124.05,62.13 124.04,62.14 123.92,62.16 123.8,62.14 123.8,62.13 123.69,62.03 123.64,61.89 123.64,61.78 123.61,61.76 123.55,61.75 123.49,61.72 123.21,61.72 123.14,61.8 123.14,61.85 123.14,62.46 123.16,62.48 123.19,62.49 123.23,62.5 123.3,62.49 123.37,62.51 123.37,62.53 123.4,62.55 123.46,62.59 123.5,62.64 123.69,62.64 124,62.53 124.2,62.78 124.22,62.81 124.25,62.82 124.51,62.92 124.62,63.17 124.62,63.22 125.25,63.22
GND on BOTTOM (solid shape): 107.08,39.59 107.08,39.57 107.09,39.39 107.18,39.24 107.32,39.13 107.49,39.1 107.5,39.07 107.5,39.04 107.54,38.89 107.64,38.78 107.66,38.76 107.66,38.72 107.69,38.38 107.99,38.22 108.04,38.22 108.04,38.11 108.01,38.04 107.94,38.01 107.84,37.99 107.75,37.95 107.67,37.94 107.6,37.99 107.26,38.18 106.95,37.94 106.94,37.91 106.55,37.91 106.42,38.04 105.67,38.04 105.45,38.26 105.45,38.37 105.68,38.37 105.95,38.63 106.01,38.63 106.13,38.66 106.21,38.73 106.26,38.77 106.32,38.77 106.39,38.7 106.4,38.7 106.89,38.83 106.48,39.12 106.4,39.2 106.48,39.24 106.54,39.32 106.57,39.46 106.54,39.59 106.54,39.69 106.62,39.74 106.72,39.76 106.8,39.81 106.84,39.84
GND on BOTTOM (solid shape): 156.04,105.72 156.28,105.64 156.51,105.72 157.89,105.72 157.99,105.62 157.99,105.13 157.81,104.94 157.8,104.68 157.81,104.65 157.73,104.57 157.38,104.57 157.38,104.61 157.31,104.68 157.32,104.7 157.13,105.12 156.68,105.06 156.64,105.05 156.61,105.06 156.15,105.12 155.97,104.7 155.95,104.61 155.87,104.57 155.59,104.57 155.51,104.61 155.49,104.7 155.31,105.12 154.85,105.06 154.81,105.05 154.78,105.06 154.3,105.11 154.15,104.66 154.15,104.65 154.15,104.57 153.82,104.57 153.7,104.45 153.7,101.68 152.73,100.71 150.62,100.71 150.34,100.43 150.34,99.29 150.19,99.14 149.89,99.14 149.38,98.63 149.38,93.4 148.46,92.48 141.45,92.48 141.1,92.84 141.1,94.74 141.4,95.05 147.63,95.05 147.73,95.15 147.73,105.11 148.08,105.46 149.78,105.46 149.89,105.36 149.89,103.05 150.32,102.62 152.63,102.62 152.88,102.87 152.88,105.56 153.04,105.72
GND on BOTTOM (solid shape): 106.97,42.09 106.99,42.06 107.02,42.02 107.13,41.94 107.26,41.91 107.28,41.91 107.52,41.67 107.52,41.66 107.59,41.56 107.69,41.5 107.7,41.5 108.1,41.1 108.1,40.85 108.1,40.83 108.17,40.65 108.33,40.54 108.38,40.49 108.39,40.42 108.38,40.36 108.38,40.3 108.34,40.26 108.33,40.25 108.25,40.21 108.15,40.11 108.07,40.09 108,40.12 107.69,40.2 107.5,39.95 107.47,39.89 107.41,39.86 107.34,39.84 106.98,40.2 106.83,40.2 106.56,40.3 106.35,40.11 106.3,40.07 106.25,40.11 106.24,40.14 106.24,40.35 106.08,40.51 106.03,40.51 106.03,40.5 105.67,40.5 105.61,40.57 105.61,40.79 106.12,40.79 106.18,40.85 106.2,40.85 106.25,40.9 106.25,41.21 106.25,41.22 106.3,41.26 106.35,41.22 106.9,41.29 106.35,41.39 106.3,41.35 106.26,41.39 106.25,41.41 106.25,41.51 106.34,41.6 106.36,41.6 106.49,41.68 106.57,41.81 106.57,41.83 106.83,42.09
GND on BOTTOM (solid shape): 125.65,60.42 126.03,60.36 126.23,60.43 126.35,60.46 126.47,60.35 126.47,60.07 126.33,59.93 126.13,59.93 126.12,59.94 125.89,59.95 125.72,59.79 125.72,59.79 125.69,59.69 125.7,59.58 125.69,59.55 125.68,59.51 125.68,59.42 125.66,59.4 125.63,59.4 125.36,59.09 125.63,58.79 125.71,58.74 125.71,58.65 125.74,58.36 125.99,58.22 126.03,58.22 126.06,58.14 126.16,58.08 126.19,58.04 126.4,57.96 126.43,57.93 126.43,57.82 126.34,57.73 125.66,57.73 125.47,57.53 125.28,57.53 125.18,57.63 125.18,57.66 125.18,57.79 125.14,57.91 125.05,58.04 124.92,58.12 124.9,58.13 124.87,58.17 124.88,58.19 124.83,58.39 124.64,58.54 124.64,58.57 124.56,58.85 124.22,59.02 124.2,59.1 124.06,59.39 123.73,59.35 123.52,59.35 123.16,59.7 123.16,60.15 123.23,60.22 123.39,60.22 123.4,60.22 123.48,60.18 123.56,60.16 123.62,60.12 123.64,60.06 123.84,59.79 124.16,59.91 124.25,59.96 124.33,59.91 124.6,59.78 124.83,59.95 124.85,60.01 124.85,60.06 124.85,60.08 124.94,60.17 124.95,60.18 125.09,60.27 125.17,60.41 125.2,60.51 125.54,60.51
GND on BOTTOM (solid shape): outline of 246 points within 23.88,72.93 28.98,78.84
GND on BOTTOM (solid shape): outline of 263 points within 0.81,52.86 13.73,60.91
GND on BOTTOM (solid shape): outline of 268 points within 29.92,73.33 37.67,78.01
GND on BOTTOM (solid shape): outline of 110 points within 108.55,56.24 111.66,62.05
GND on BOTTOM (solid shape): outline of 425 points within 0.51,71.11 13.39,84.1
GND on BOTTOM (solid shape): outline of 168 points within 121.34,67.24 126.44,74.25
GND on BOTTOM (solid shape): 3.78,17.76 4.47,17.06 4.47,16.29 3.78,15.6 3.78,10.65 4.06,9.95 4.76,9.67 12.03,9.67 14.32,9.11 16.1,7.58 20.01,4.22 25.02,3.02 103.52,3.02 103.52,6.35 104.4,8.48 106.53,9.37 108.88,9.37 109.79,9.28 110.66,9.03 111.56,8.77 112.49,8.68 151.34,8.68 152.05,9.27 152.95,9.48 202.68,9.48 204.33,9.63 205.91,10.08 211.49,9.41 214.09,4.43 214.08,4.28 214.08,1.02 215.39,1.02 215.52,1.15 215.52,1.63 215.7,1.81 217.7,1.81 217.86,1.65 217.86,1.45 218.29,1.02 220.3,1.02 220.64,0.67 221.1,0.51 214.07,0.51 213.72,0.65 213.58,1 213.58,4.28 213.58,4.43 211.2,9 206.09,9.61 204.42,9.13 202.68,8.97 152.95,8.97 152.27,8.81 151.57,8.23 151.35,8.17 112.49,8.17 111.46,8.27 110.48,8.56 109.69,8.78 108.88,8.86 106.53,8.86 104.76,8.12 104.02,6.35 104.02,3 103.88,2.65 103.53,2.51 25.02,2.51 19.78,3.77 15.69,7.28 14.09,8.66 12.03,9.16 4.76,9.16 3.7,9.59 3.27,10.65 3.27,36.98 3.78,36.98
GND on BOTTOM (solid shape): outline of 232 points within 122.64,48.82 126.5,58.39
GND on BOTTOM (solid shape): outline of 751 points within 23.85,61.17 42.85,79.63
GND on BOTTOM (solid shape): outline of 353 points within 105.56,46.13 112.7,55.65
GND on BOTTOM (solid shape): outline of 293 points within 0.51,0.51 226.32,115.29
GND on BOTTOM (solid shape): outline of 1384 points within 106.59,33.53 115.28,46.06
GND on BOTTOM (solid shape): outline of 1447 points within 105.52,52.46 114,72.43
GND on BOTTOM (solid shape): outline of 1637 points within 158.23,94.21 168.3,100.74
GND on BOTTOM (solid shape): outline of 2012 points within 23.95,52.83 48.34,70.46
GND on BOTTOM (solid shape): outline of 2144 points within 114.9,33.53 126.49,48.43
GND on GND1 (solid shape): outline of 2012 points within 0.51,0.51 226.32,115.29
GND on IN1 (solid shape): 213.06,7.82 214.09,4.43 214.08,4.28 214.08,1.02 220.3,1.02 220.64,0.67 221.1,0.51 214.07,0.51 213.72,0.65 213.58,1 213.58,4.28 213.58,4.43 212.47,7.78 209.56,9.77 209.94,9.89 210.3,10.05
GND on IN1 (solid shape): outline of 270 points within 0.81,52.86 14.81,61.5
GND on IN1 (solid shape): 3.78,10.65 4.06,9.95 4.76,9.67 12.03,9.67 14.32,9.11 16.1,7.58 20.01,4.22 25.02,3.02 103.52,3.02 103.52,6.35 104.4,8.48 106.53,9.37 108.88,9.37 109.79,9.28 110.66,9.03 111.56,8.77 112.49,8.68 151.34,8.68 152.05,9.27 152.95,9.48 202.68,9.48 204.33,9.63 205.91,10.08 206.24,10.19 206.57,10.29 206.91,10.08 207.27,9.92 206.67,9.79 206.09,9.61 204.42,9.13 202.68,8.97 152.95,8.97 152.27,8.81 151.57,8.23 151.35,8.17 112.49,8.17 111.46,8.27 110.48,8.56 109.69,8.78 108.88,8.86 106.53,8.86 104.76,8.12 104.02,6.35 104.02,3 103.88,2.65 103.53,2.51 25.02,2.51 19.78,3.77 15.69,7.28 14.09,8.66 12.03,9.16 4.76,9.16 3.7,9.59 3.27,10.65 3.27,36.98 3.78,36.98
GND on IN1 (solid shape): outline of 615 points within 0.51,71.3 14.12,84.12
GND on IN1 (solid shape): outline of 1642 points within 0.51,0.51 226.32,115.29
GND on VCC (solid shape): 195.5,55.98 195.5,52.56 195.48,52.48 195.5,52.4 195.5,50.75 194.14,49.39 194.12,49.35 194.11,49.3 194.11,48.75 187.53,42.17 172.21,42.17 171.97,42.41 171.93,42.44 171.88,42.45 170.26,42.45 170.21,42.44 170.17,42.41 169.92,42.17 166.4,42.17 166.4,51.72 168.26,53.58 168.29,53.62 168.3,53.67 168.3,56.19 170,56.19 170.05,56.2 170.09,56.22 170.79,56.92 194.56,56.92
GND on VCC (solid shape): outline of 229 points within 60.22,23.65 117.68,93.27
GND on VCC (solid shape): outline of 1888 points within 0.51,0.51 226.32,115.29
GND on IN2 (solid shape): 213.06,7.82 214.09,4.43 214.08,4.28 214.08,1.02 220.3,1.02 220.64,0.67 221.1,0.51 214.07,0.51 213.72,0.65 213.58,1 213.58,4.28 213.58,4.43 212.47,7.78 209.56,9.77 209.94,9.89 210.3,10.05
GND on IN2 (solid shape): outline of 270 points within 0.81,52.86 14.81,61.5
GND on IN2 (solid shape): 3.78,10.65 4.06,9.95 4.76,9.67 12.03,9.67 14.32,9.11 16.1,7.58 20.01,4.22 25.02,3.02 103.52,3.02 103.52,6.35 104.4,8.48 106.53,9.37 108.88,9.37 109.79,9.28 110.66,9.03 111.56,8.77 112.49,8.68 151.34,8.68 152.05,9.27 152.95,9.48 202.68,9.48 204.33,9.63 205.91,10.08 206.24,10.19 206.57,10.29 206.91,10.08 207.27,9.92 206.67,9.79 206.09,9.61 204.42,9.13 202.68,8.97 152.95,8.97 152.27,8.81 151.57,8.23 151.35,8.17 112.49,8.17 111.46,8.27 110.48,8.56 109.69,8.78 108.88,8.86 106.53,8.86 104.76,8.12 104.02,6.35 104.02,3 103.88,2.65 103.53,2.51 25.02,2.51 19.78,3.77 15.69,7.28 14.09,8.66 12.03,9.16 4.76,9.16 3.7,9.59 3.27,10.65 3.27,36.98 3.78,36.98
GND on IN2 (solid shape): outline of 663 points within 0.51,71.3 14.12,84.18
GND on IN2 (solid shape): outline of 1692 points within 0.51,0.51 226.32,115.29
GND on IN2 (solid shape): outline of 14306 points within 165.56,70.11 202.24,111.94
GND on IN2 (solid shape): outline of 22848 points within 49.17,22.96 118.03,95.13
GND on IN3 (solid shape): 213.06,7.82 214.09,4.43 214.08,4.28 214.08,1.02 220.3,1.02 220.64,0.67 221.1,0.51 214.07,0.51 213.72,0.65 213.58,1 213.58,4.28 213.58,4.43 212.47,7.78 209.56,9.77 209.94,9.89 210.3,10.05
GND on IN3 (solid shape): outline of 267 points within 0.81,52.86 13.72,61.5
GND on IN3 (solid shape): 3.17,94.21 7.95,94.21 8.16,94 7.66,93.43 8.23,93.94 9.3,92.87 9.3,91.42 9.32,91.39 9.32,91.32 9.19,91.19 9.19,89.97 9.02,89.79 8.46,89.79 8.43,89.82 8.23,89.82 8.14,89.88 8.16,89.99 8.35,90.36 8.27,90.76 8.28,90.86 8.36,90.92 8.52,90.92 9.08,91.47 8.52,92.03 7.73,92.03 7.21,91.69 7.32,91.09 7.35,91.01 7.32,90.94 7.24,90.86 7.18,90.78 7.1,90.73 7.01,90.77 6.41,90.95 6.05,90.44 6.05,89.96 6.06,89.89 6.04,89.84 5.97,89.86 5.97,89.86 5.83,89.94 5.67,89.96 5.6,89.99 5.57,90.06 5.57,90.88 6.05,91.55 5.87,92.36 5.86,92.46 5.95,92.52 6.38,92.52 6.94,93.07 6.38,93.63 5.19,93.63 4.71,93.36 4.7,92.81 4.71,92.73 4.66,92.67 4.39,92.5 4.19,92.26 0.98,92.26 0.98,92.46 1.02,92.55 1.12,92.56 1.22,92.53 1.33,92.52 2.52,92.52 3.08,93.07 2.52,93.63 1.33,93.63 0.95,93.49 0.77,93.12 0.77,93.1 0.72,93.05 0.63,93.05 0.55,93.07 0.51,93.14 0.51,94.14 2.16,94.14 2.59,94.2 2.99,94.39
GND on IN3 (solid shape): 3.78,10.65 4.06,9.95 4.76,9.67 12.03,9.67 14.32,9.11 16.1,7.58 20.01,4.22 25.02,3.02 103.52,3.02 103.52,6.35 104.4,8.48 106.53,9.37 108.88,9.37 109.79,9.28 110.66,9.03 111.56,8.77 112.49,8.68 151.34,8.68 152.05,9.27 152.95,9.48 202.68,9.48 204.33,9.63 205.91,10.08 206.24,10.19 206.57,10.29 206.91,10.08 207.27,9.92 206.67,9.79 206.09,9.61 204.42,9.13 202.68,8.97 152.95,8.97 152.27,8.81 151.57,8.23 151.35,8.17 112.49,8.17 111.46,8.27 110.48,8.56 109.69,8.78 108.88,8.86 106.53,8.86 104.76,8.12 104.02,6.35 104.02,3 103.88,2.65 103.53,2.51 25.02,2.51 19.78,3.77 15.69,7.28 14.09,8.66 12.03,9.16 4.76,9.16 3.7,9.59 3.27,10.65 3.27,36.98 3.78,36.98
GND on IN3 (solid shape): outline of 533 points within 0.51,71.3 13.04,84.18
GND on IN3 (solid shape): outline of 185 points within 0.51,0.51 226.32,115.29
GND on GND2 (solid shape): 126.16,36.35 126.16,36.12 125.84,35.8 125.82,35.76 125.81,35.71 125.81,31.3 125.82,31.25 125.84,31.21 126.07,30.98 126.11,30.95 126.16,30.94 126.39,30.94 126.86,30.47 126.9,30.44 126.95,30.43 128.01,30.43 129.22,29.22 129.26,29.2 129.31,29.19 129.59,29.19 129.9,28.88 129.9,28.45 129.91,28.4 129.93,28.36 131.24,27.05 131.24,22.97 130.91,22.63 127.38,22.63 127.31,22.71 127.31,23.55 127.3,23.6 127.27,23.64 127.15,23.75 127.15,26.06 127.14,26.11 127.12,26.15 126.52,26.75 126.52,27.43 126.63,27.55 126.66,27.59 126.67,27.64 126.67,29.52 126.66,29.57 126.63,29.61 125.2,31.04 125.2,31.96 125.19,32 125.16,32.05 124.64,32.57 124.64,33.58 124.85,33.8 124.88,33.84 124.89,33.89 124.89,34.52 125.54,35.17 125.57,35.21 125.58,35.26 125.58,36.14 125.86,36.43 126.08,36.43
GND on GND2 (solid shape): outline of 2183 points within 0.51,0.51 226.32,115.29
VCCAMPHYPLL_1P0 on BOTTOM (solid shape): 134.54,31.35 134.54,30.58 134.8,30.58 135.13,30.25 135.43,30.25 135.59,30.1 135.59,29.11 135.51,29.03 135.03,29.03 134.98,29.09 134.98,29.97 134.93,30.03 134.7,30.03 134.47,30.25 133.91,30.25 133.91,30.5 133.92,30.5 133.92,30.53 133.96,30.57 133.96,30.91 134.01,30.97 134.01,31.27 134.11,31.37 134.52,31.37
VCCAPLL_1P0 on BOTTOM (solid shape): 134.42,33.15 134.42,32.39 134.26,32.24 133.81,32.24 133.68,32.11 133.68,31.93 133.63,31.88 133.15,31.88 133.1,31.93 133.1,33.25 132.94,33.4 131.58,33.4 131.58,33.33 131.47,33.33 131.37,33.43 131.37,33.73 131.44,33.8 131.49,33.88 131.7,34.09 133.48,34.09
VCCCLK1_CLK6_R on TOP (solid shape): 133.88,26.8 133.88,26.27 133.43,25.81 131.85,25.81 131.62,26.04 131.62,26.57 131.7,26.65 131.72,26.65 131.79,26.65 131.85,26.67 132.2,26.67 132.61,26.29 132.96,26.71 132.99,26.79 133.06,26.82 133.86,26.82
VCCMPHYGT_1P0 on TOP (solid shape): outline of 1907 points within 119.52,27.64 132.82,42.7
VCCMPHYGT_1P0 on BOTTOM (solid shape): 131.84,29.14 132.82,29.14 133.07,28.88 135.1,28.88 135.15,28.83 135.15,28.27 135.1,28.22 132.31,28.22 132.23,28.15 132.23,27.87 132.13,27.76 131.12,27.76 130.45,28.43 130.45,28.58 130.44,28.59 130.44,29.1 130.63,29.29 131.68,29.29
VCCMPHYGT_1P0 on BOTTOM (solid shape): 120.81,41.93 120.81,41.67 120.61,41.47 120.61,41 120.29,40.67 119.29,40.67 119.19,40.77 119.19,40.99 119.24,41.19 119.19,41.38 119.19,41.54 119.29,41.64 119.46,41.64 120.11,42.29 120.45,42.29
VCCPRIM on TOP (solid shape): 132.82,31.96 132.82,30.79 132.97,30.63 132.97,29.8 132.84,29.67 132.18,29.67 131.39,30.46 131.39,31.4 132.08,32.08 132.69,32.08
VCCPRIM on VCC (solid shape): 136.18,35.37 136.22,35.34 136.27,35.33 136.68,35.33 136.68,33.84 136.21,33.37 136.18,33.33 136.17,33.28 136.17,32.29 136.18,32.24 136.21,32.2 136.86,31.55 136.86,29.95 136.71,29.81 136.69,29.78 132.01,29.75 130.39,31.36 130.35,31.39 130.3,31.4 123.4,31.4 123.05,31.74 123.01,31.77 122.96,31.78 122.25,31.78 122.2,31.77 122.16,31.74 121.82,31.4 120.22,31.4 119.24,32.38 119.2,32.4 119.15,32.41 118.11,32.41 116.48,34.04 116.48,40.44 116.8,40.76 116.83,40.8 116.84,40.85 116.84,41.56 116.83,41.61 116.8,41.65 115.98,42.47 115.98,43.33 128.22,43.33
VCCPRIM on IN2 (solid shape): 117.76,43.97 117.75,43.94 117.86,43.54 118.27,43.51 118.7,43.51 118.86,43.44 119.04,43.45 119.07,43.46 119.25,43.28 119.25,42.17 119.05,41.96 116.56,41.96 116.18,42.34 116.18,42.59 116.22,42.67 116.31,42.69 116.76,43.04 116.29,43.37 116.2,43.38 116.15,43.46 116.15,43.89 116.3,44.04 116.33,44.04 116.41,44.03 116.5,44.05 117.68,44.05
VCCSRAM_1P0 on TOP (solid shape): 119.1,43.89 119.1,43.54 119.02,43.46 118.75,43.46 118.57,43.28 118.57,42.88 118.54,42.85 118.26,42.85 118.19,42.93 118.19,43.41 118.23,43.46 118.31,43.51 118.36,43.59 118.77,44 119,44
VCCSRAM_1P0 on BOTTOM (solid shape): 129.34,32.08 129.53,31.63 130.01,31.73 130.04,31.76 130.07,31.8 131.39,31.8 131.47,31.73 132.33,31.73 132.43,31.64 132.43,30.63 132.41,30.61 131.8,30.61 131.52,30.89 129.5,30.89 129.08,31.31 128.61,31.61 128.43,31.08 128.38,31.01 128.34,30.93 128.33,30.9 127.94,30.9 127.94,30.95 127.92,31.02 127.89,31.09 127.45,31.25 127.24,30.83 127.22,30.75 127.14,30.71 126.9,30.71 126.75,30.86 126.74,30.9 126.74,31.89 127.01,32.16 129.26,32.16
VCCSRAM_1P0 on IN3 (solid shape): outline of 1907 points within 114.05,30 127.18,44.27
VDDC_PH1 on BOTTOM (solid shape): 128.68,99.8 128.68,99.47 128.52,99.32 127.86,99.32 127.61,99.06 127.61,96.6 127.86,96.34 128.58,96.34 128.75,96.17 128.75,95 128.52,94.77 127.58,94.77 127.24,95.11 127.24,96.28 127,96.52 127,99.42 127.58,100 128.47,100
VDDC_PH2 on BOTTOM (solid shape): 120.98,108.13 120.98,107.5 120.9,107.42 117.68,107.42 117.56,107.54 117.56,108.1 117.73,108.27 120.84,108.27
VDDC_UG1 on BOTTOM (solid shape): 132.23,97.36 132.23,96.22 132.22,96.21 132.22,95.67 131.9,95.35 131.88,95.35 131.61,95.24 131.44,94.98 131.43,94.95 130.78,94.95 130.63,95.1 130.63,95.56 130.84,95.76 131.19,95.76 131.27,95.84 131.27,97.34 131.34,97.41 132.18,97.41
VDDQC on TOP (solid shape): outline of 146 points within 107.93,55.72 111.04,57.51
+0P95VGA_FB on BOTTOM (solid shape): 169.6,113.74 169.6,112.91 169.55,112.85 169.34,112.85 169.32,112.88 169.32,113.44 169.24,113.52 168.76,113.52 168.58,113.34 165.53,113.34 165.47,113.4 165.47,113.92 165.68,114.14 169.2,114.14
+0P95VGA_LX on BOTTOM (solid shape): 170.61,110.14 170.81,110.14 170.81,110.72 171.11,110.72 171.11,110.14 171.31,110.14 171.31,110.72 171.65,110.72 173.48,108.89 173.48,107.01 173.2,106.73 170.66,106.73 169.9,107.5 169.9,109.23 170.05,109.38 170.31,109.44 170.47,109.65 170.46,109.89 170.31,110.08 170.31,110.14 170.31,110.14 170.31,110.67 170.36,110.72 170.61,110.72
+0P95VGA_VIN on BOTTOM (solid shape): 182.58,114 182.58,113.49 182.4,113.31 182.4,112.12 182.22,111.94 181.28,111.94 181.18,112.04 172.72,112.04 171.91,112.85 171.37,112.85 171.32,112.91 171.32,113.52 171.3,113.54 171.12,113.54 171.09,113.52 171.09,112.93 171.02,112.85 170.87,112.85 170.84,112.88 170.84,113.44 170.76,113.52 170.64,113.52 170.59,113.46 170.59,112.93 170.51,112.85 170.38,112.85 170.33,112.91 170.33,113.46 170.28,113.52 170.28,114.16 170.38,114.26 182.31,114.26
+0P95VO on BOTTOM (solid shape): outline of 105 points within 163.32,105.56 170.36,111.41
+1P2V_DUAL on TOP (solid shape): 37.55,69.1 37.55,68.57 38.33,67.8 38.74,67.8 38.91,67.62 38.91,67.01 38.84,66.93 37.24,66.93 36.98,67.19 36.98,68.13 36.5,68.61 36.5,69.45 37.21,69.45
+1P2V_DUAL on TOP (solid shape): 61.87,63.05 61.87,62.71 62.14,62.45 62.46,62.29 62.81,62.35 62.82,62.36 62.97,62.36 63.02,62.41 63.05,62.39 63.48,62.28 63.86,62.5 63.87,62.51 63.92,62.54 63.94,62.53 64.16,62.49 64.36,62.58 64.43,62.6 64.49,62.58 64.68,62.49 64.88,62.51 64.94,62.42 65.02,62.35 65.06,62.25 64.99,62.17 64.81,62.07 64.69,61.91 64.56,61.93 64.44,61.91 63.78,62.14 63.37,61.57 63.37,60.69 63.86,60.2 64.43,60.05 64.85,60.47 64.85,60.48 64.9,60.53 64.97,60.45 65.19,60.45 65.19,59.33 65.19,59.33 65.19,58.5 65.16,58.43 65.09,58.4 64.94,58.37 64.81,58.29 64.74,58.27 64.68,58.29 64.4,58.42 64.11,58.31 64.05,58.28 63.98,58.31 63.85,58.4 63.69,58.42 63.62,58.45 63.59,58.52 62.63,61.01 60.27,62.23 60.18,62.3 60.22,62.41 60.25,62.44 60.29,62.47 60.33,62.51 60.33,63.02 60.43,63.12 61.8,63.12
+1P2V_DUAL on TOP (solid shape): outline of 136 points within 50.5,29.14 56.15,36.98
+1P2V_DUAL on TOP (solid shape): outline of 18555 points within 43.43,23.01 110.08,103.58
+1P2V_DUAL on BOTTOM (solid shape): 94.16,103.18 94.16,99.14 94.01,98.99 94.01,96.29 93.8,96.09 91.75,96.09 91.62,96.22 91.62,98.45 91.14,98.94 89.41,98.94 89.21,99.14 89.21,101.35 92.81,101.35 92.81,101.29 92.83,101.24 92.85,101.19 92.87,101.14 92.91,101.09 92.95,101.05 92.99,101.02 93.04,101 93.1,100.98 93.15,100.97 93.21,100.97 93.26,100.97 93.32,100.99 93.37,101.01 93.42,101.04 93.46,101.07 93.5,101.11 93.53,101.16 93.55,101.21 93.57,101.27 93.57,101.32 93.57,101.38 93.57,101.43 93.55,101.49 93.53,101.54 93.5,101.58 93.46,101.62 93.42,101.66 93.37,101.69 93.32,101.71 93.26,101.72 93.21,101.73 93.15,101.73 93.1,101.72 93.04,101.7 92.99,101.67 92.95,101.64 92.91,101.6 92.87,101.56 92.85,101.51 92.83,101.46 92.81,101.4 92.81,101.35 89.21,101.35 89.21,102.09 89.4,102.28 92.34,102.28 92.34,103.14 92.76,103.56 93.78,103.56
+1P2V_DUAL on BOTTOM (solid shape): outline of 89 points within 58.7,52.56 61.01,63.96
+1P2V_DUAL on IN1 (solid shape): outline of 2685 points within 49.45,35.08 61.77,58.68
+1P2V_DUAL_BST on TOP (solid shape): 97.76,98.73 97.77,98.53 97.76,98.43 97.78,98.34 97.92,98.14 98.16,98.07 98.47,98.07 98.56,97.98 98.77,97.98 98.83,97.92 99.42,97.92 99.42,97.72 98.48,97.72 98.07,97.31 97.03,97.31 96.93,97.41 96.93,98.68 97.03,98.78 97.71,98.78
+1P2V_DUAL_FB_VOUT_R_A on TOP (solid shape): 99.44,97.51 99.44,97.34 99.42,97.31 98.75,97.31 98.7,97.26 98.7,96.77 97.79,95.86 97.13,95.86 97.1,95.84 97.1,95.51 96.96,95.37 96.41,95.37 96.29,95.48 96.29,96.12 96.23,96.18 96.23,96.19 96.21,96.19 96.01,96.4 96.01,96.73 96.29,97.01 97.94,97.01 97.97,97.03 98.01,97.03 98.51,97.54 99.42,97.54
+1P2V_DUAL_FB_VOUT_R_A on BOTTOM (solid shape): 93.88,108.59 94.56,108.59 94.56,108.61 94.74,108.61 94.74,108.59 95.08,108.59 95.58,108.09 95.58,105.77 96.01,105.34 98.4,105.34 98.78,104.96 98.78,101.37 97.97,100.56 97.97,98.79 97.76,98.45 97.97,98.12 97.97,96.67 97.31,96.01 94.62,96.01 94.56,96.07 94.56,103.08 93.48,104.16 93.23,104.16 93.23,104.27 90.12,104.27 90.12,106.07 90.25,106.07 90.45,106.28 90.45,107.75 91.19,108.49 92.34,108.49 92.34,108.61 93.88,108.61
+1P2V_DUAL_HG on TOP (solid shape): 80.29,104.12 80.29,102.85 80.11,102.67 79.07,102.67 78.82,102.92 78.82,104.78 79.02,104.98 79.43,104.98
+1P2V_DUAL_HGR on TOP (solid shape): 82.96,105.49 82.96,105.01 82.86,104.9 82.86,103.13 82.45,102.72 81.51,102.72 81.31,102.92 81.31,105.06 81.97,105.72 82.73,105.72
+1P2V_DUAL_HGR on BOTTOM (solid shape): 83.77,106.23 83.77,105.23 83.64,105.11 82.79,105.11 82.61,104.93 82.27,104.93 82.02,105.18 82.02,105.5 82.22,105.7 83.03,105.7 83.03,105.75 83.06,105.78 83.06,106.23 83.2,106.37 83.63,106.37
+1P2V_DUAL_LG on TOP (solid shape): 81.25,107.93 81.25,106.73 80.24,105.72 79.88,105.72 79.65,105.95 79.65,108.1 79.83,108.28 80.9,108.28
+1P2V_DUAL_LGR on TOP (solid shape): 84.15,109.91 84.15,108.79 83.59,108.23 83.59,106.86 83.49,106.76 82.52,106.76 82.32,106.96 82.32,108.13 82.52,108.33 82.52,109.98 82.75,110.21 83.85,110.21
+1P2V_DUAL_PHASE on BOTTOM (solid shape): 88.27,112.04 88.27,110.54 87.05,109.32 87.05,104.37 86.71,104.03 85.22,104.03 85.22,104.05 85.2,104.03 85.11,104.03 85.11,103.14 84.96,103 84.33,103 83.9,103.43 83.9,106.3 83.82,106.38 83.82,106.94 83.69,107.06 83.67,107.06 83.67,107.21 83.54,107.21 83.52,107.23 81.07,107.23 81.05,107.21 80.98,107.21 80.98,107.13 80.97,107.12 80.94,107.06 80.75,107.06 80.75,108.49 82.35,108.49 82.43,108.49 82.87,108.49 82.88,108.5 83.65,108.5 83.65,108.5 84.05,108.5 84.28,108.73 84.28,108.89 84.28,109.19 84.09,109.37 83.44,109.37 83.37,109.44 83.38,109.53 83.67,109.82 83.67,110.34 83.8,110.47 84.33,110.47 84.48,110.31 85.8,110.31 85.9,110.42 85.9,112.09 86.03,112.22 88.09,112.22
+1P2V_DUAL_SUR on BOTTOM (solid shape): 85.65,112.25 85.65,110.59 85.57,110.52 84.73,110.52 84.46,110.8 84,110.8 83.92,110.87 83.92,112.19 84.01,112.28 85.61,112.28
+1P2V_DUAL_VIN on BOTTOM (solid shape): 83.48,107.08 83.54,107.08 83.54,106.94 83.64,106.94 83.69,106.88 83.69,106.52 82.87,106.52 82.87,105.86 82.05,105.86 81.76,105.57 81.76,105.11 82.19,104.68 82.29,104.68 82.75,104.22 82.75,101.78 82.61,101.64 80.4,101.64 80.26,101.78 80.26,105.62 80.58,105.96 80.48,106.42 81,106.94 81.04,106.98 81.07,107.05 81.12,107.1 83.46,107.1
+1P8V on TOP (solid shape): 32.33,73.69 32.33,72.19 32.17,72.02 31.97,72.02 31.09,71.15 30.79,71.15 30.61,71.33 30.61,72.09 30.79,72.27 30.79,73.79 31.14,74.15 31.88,74.15
+1P8V_EMMC on TOP (solid shape): 98.65,15.12 98.65,15.1 98.63,14.99 98.64,14.87 98.37,14.61 98.37,12.7 98.27,12.6 97.89,12.6 97.71,12.78 97.71,14.91 97.99,15.19 98.58,15.19
+1P8VSB on TOP (solid shape): 37.36,73.71 37.36,73.59 37.22,73.38 37.24,73.12 37.25,73.11 37.25,72.12 37.36,72.01 37.36,70.94 37.26,70.84 36.6,70.84 36.53,70.92 36.53,72.77 36.09,73.21 35.71,73.21 35.66,73.26 35.66,73.59 35.76,73.69 36.8,73.69 37.03,73.92 37.16,73.92
+1P8VSB on BOTTOM (solid shape): 78.54,99.7 78.54,98.94 78.28,98.68 77.32,98.68 77.01,98.99 77.01,99.85 77.22,100.05 78.18,100.05
+1P8VSB on BOTTOM (solid shape): 97.07,112.66 97.07,111.5 96.96,111.39 96.56,111.39 96.32,111.64 95.12,111.64 95.12,111.63 95.1,111.63 95.1,110.78 95.05,110.72 94.44,110.72 94.13,111.03 94.13,112.73 94.36,112.96 96.77,112.96
+1P8VSB on VCC (solid shape): 96.35,112.21 96.4,112.18 96.44,112.17 96.93,112.17 96.93,108.79 94.59,106.45 38,106.45 37.95,106.44 37.91,106.42 37.53,106.04 37.5,105.99 37.49,105.95 37.49,85.93 36.51,84.95 36.48,84.91 36.47,84.86 36.47,79.53 36.48,79.48 36.51,79.44 37.49,78.46 37.49,71.07 34.39,67.97 28.88,67.97 28.88,71.27 29.33,71.72 29.35,71.76 29.36,71.81 29.36,74.32 29.35,74.37 29.33,74.41 28.04,75.7 28.04,76.99 28.03,77.04 28,77.08 27.71,77.37 27.71,79.1 29.11,80.5 29.15,80.51 29.17,80.53 29.22,80.58 29.25,80.62 29.26,80.67 29.26,81.1 30.21,82.06 30.24,82.1 30.25,82.15 30.25,86.54 30.24,86.59 30.21,86.63 29.95,86.9 29.95,87.66 30.19,87.9 30.22,87.94 30.23,87.99 30.23,89.66 30.22,89.71 30.19,89.75 30.02,89.92 30.02,90.27 30.6,90.84 30.62,90.89 30.63,90.93 30.63,105.69 30.62,105.74 30.6,105.78 30.25,106.13 30.25,110.03 30.66,110.44 92.66,110.44 92.71,110.45 92.75,110.48 94.79,112.52 96.04,112.52
+1P8VSB on IN2 (solid shape): 78.89,100.26 78.89,99.52 78.74,99.37 77.17,99.37 77.06,99.47 77.06,100.23 77.19,100.36 78.79,100.36
+1P8VSB on IN2 (solid shape): outline of 672 points within 31.72,58.24 38.1,74.25
+1P8VSB_OUT on BOTTOM (solid shape): 102.59,113.44 102.59,110.98 102.31,110.69 100.86,110.69 100.53,111.02 100.53,112.07 100.43,112.17 99.92,112.17 99.85,112.09 99.85,111.43 99.77,111.36 99.34,111.36 98.07,111.36 97.92,111.51 97.92,112.42 97.59,112.75 97.59,113.67 97.81,113.89 102.14,113.89
+1P8VSB_SW on BOTTOM (solid shape): 106,113.17 106,112.6 106.33,112.26 106.64,112.26 106.94,111.96 107.53,111.96 107.56,111.94 107.56,111.66 106.97,111.66 106.97,111.46 107.56,111.46 107.56,111.16 106.97,111.16 106.97,110.96 107.56,110.96 107.56,110.47 107.43,110.35 104.11,110.35 103.84,110.62 103.84,113.11 104.02,113.3 105.87,113.3
+1P8VSB_VIN on BOTTOM (solid shape): 111.48,112.39 111.48,110.29 111.35,110.16 111.35,108.82 111.27,108.73 110.48,108.73 109.67,109.54 109.67,110.96 110.28,110.96 110.28,111.16 109.67,111.16 109.67,111.46 110.28,111.46 110.28,111.66 109.67,111.66 109.67,111.89 109.72,111.95 110.32,111.95 110.87,112.5 111.37,112.5
+2P5_VPP_FB1_A on BOTTOM (solid shape): 49.53,19.23 49.53,18.37 49.48,18.32 49.37,18.32 49.37,18.33 48.73,18.33 48.73,18.32 48.62,18.32 48.54,18.39 48.54,19.23 48.67,19.36 49.4,19.36
+2P5_VPP_SW on BOTTOM (solid shape): 47.14,16.66 47.14,15.5 47.09,15.47 47.04,15.44 47,15.4 46.95,15.4 46.94,15.4 46.71,15.4 46.61,15.5 45.94,15.5 45.94,15.48 45.85,15.57 45.85,15.8 46.53,15.8 46.53,16 45.94,16 45.94,15.8 45.85,15.8 45.85,16.3 46.53,16.3 46.53,16.5 45.94,16.5 45.94,16.3 45.85,16.3 45.85,16.74 45.92,16.82 46.99,16.82
+2P5_VPP_VIN on BOTTOM (solid shape): 43.89,17.07 43.89,15.55 43.87,15.52 43.23,15.52 43.13,15.42 42.72,15.42 42.42,15.73 42.42,15.8 43.83,15.8 43.83,16 43.24,16 43.24,15.8 42.42,15.8 42.42,16.3 43.83,16.3 43.83,16.5 43.24,16.5 43.24,16.3 42.42,16.3 42.42,17.05 42.57,17.2 43.76,17.2
+2P5V_VPP on BOTTOM (solid shape): 58.65,27.38 58.65,26.24 58.58,26.17 58.52,26.22 58.47,26.25 58.42,26.27 58.37,26.29 58.31,26.29 58.25,26.29 58.2,26.28 58.14,26.26 58.09,26.24 58.05,26.2 58.01,26.17 57.97,26.12 57.95,26.07 57.92,26.01 56.06,26.01 55.98,26.09 55.98,26.8 56.17,26.99 58.4,26.99 58.4,27.16 56.67,27.16 56.67,26.99 56.17,26.99 56.67,27.49 58.4,27.49 58.4,27.54 58.5,27.54
+2P5V_VPP on BOTTOM (solid shape): outline of 82 points within 68.61,24.16 72.29,26.55
+3P3V on TOP (solid shape): 154.28,27.16 154.28,25.63 154.2,25.55 152.81,25.55 152.6,25.35 152.22,25.35 152.1,25.48 152.1,26.16 153.21,27.28 154.15,27.28
+3P3V on TOP (solid shape): 55.53,99.93 55.57,99.9 55.62,99.88 55.78,99.72 55.78,99.72 56.08,99.42 56.26,99.42 56.41,99.27 56.41,98.58 55.17,98.58 54.99,98.76 54.99,98.97 54.75,99.2 54.76,99.23 54.75,99.44 54.64,99.61 54.64,99.82 54.74,99.93
+3P3V on TOP (solid shape): 90.12,25.68 90.19,25.65 90.22,25.58 90.33,25.32 90.65,25.17 90.68,25.1 90.68,24.69 90.6,24.62 89.97,24.62 89.56,25.02 89.56,25.58 89.66,25.68
+3P3V on TOP (solid shape): 215.57,28.27 215.57,26.54 215.56,26.53 215.56,25.08 215.54,24.93 215.53,24.77 216,23.69 217.08,23.25 217.29,23.25 217.58,22.96 217.58,20.5 217.52,20.45 217.12,20.45 217.09,20.42 215.57,20.42 212.8,23.19 212.8,25.75 212.81,25.75 212.81,27.87 212.81,27.88 212.81,28.39 213.18,28.76 215.09,28.76
+3P3V on BOTTOM (solid shape): 185.6,19.36 185.6,18.09 185.46,17.95 184.01,17.95 184,17.93 182.12,17.93 181.92,18.14 180.59,18.14 180.59,18.7 180.87,18.98 184.02,18.98 184.63,19.59 185.37,19.59
+3P3V on BOTTOM (solid shape): 206.4,44.35 206.4,44.17 206.38,44.15 205.51,44.15 205.46,44.1 205.46,43.89 205.49,43.87 206.35,43.87 206.38,43.84 206.38,43.67 206.35,43.64 205.49,43.64 205.41,43.56 205.41,43.49 204.98,43.06 204.44,43.06 204.29,43.21 204.29,43.44 205.23,44.38 206.38,44.38
+3P3V on BOTTOM (solid shape): 98.7,27.18 100.76,27.18 100.84,27.1 100.84,26.65 100.65,26.46 100.57,26.46 100.56,26.44 99.87,26.44 99.49,26.06 99.49,25.58 99.39,25.48 98.43,25.48 98.32,25.58 97.92,25.58 97.79,25.71 97.79,26.52 97.54,26.77 97.54,26.8 97.46,26.88 96.8,26.88 96.7,26.98 96.7,27.31 96.75,27.36 97.69,27.36 97.79,27.46 97.79,27.71 97.89,27.82 98.07,27.82
+3P3V on VCC (solid shape): 213.77,27.41 213.77,21.67 212.83,20.73 205.89,20.73 205.84,20.72 205.8,20.69 200.25,15.14 182.07,15.14 181.89,15.32 181.89,20.17 182.45,20.73 197,20.73 197.05,20.74 197.09,20.77 204.29,27.97 213.21,27.97
+3P3V on IN2 (solid shape): 186.03,19.84 186.03,18.21 185.85,18.04 182.14,18.04 181.61,18.57 181.64,18.6 181.64,19.48 182.17,20.02 185.85,20.02
+3P3V on IN2 (solid shape): 215.01,28.12 215.01,26.44 214.6,26.04 214.6,24.06 214.05,23.5 212.73,23.5 212.12,24.11 212.12,27.56 213.23,28.68 214.45,28.68
+3P3V on IN2 (solid shape): 159.11,20.55 159.11,18.07 159.02,17.92 159.01,17.76 158.93,17.68 158.52,17.68 158.12,18.09 158.12,20.22 157.45,20.88 157.45,21.41 157.66,21.62 158.04,21.62
+3P3V on IN2 (solid shape): 214.78,43.33 214.78,42.19 214.58,41.99 213.92,41.99 212.55,43.36 205.23,43.36 205.13,43.26 204.88,43.26 204.63,43.01 204.6,43.02 204.5,43.03 204.39,43.02 204.36,43.01 204.04,43.33 204.04,43.89 204.72,44.58 213.54,44.58
+3P3V on IN2 (solid shape): 55.58,99.9 55.74,99.86 55.9,99.9 55.91,99.9 56.01,99.9 56.19,99.72 56.19,99.09 55.83,98.73 54.74,98.73 54.61,98.86 54.58,98.94 54.62,99.01 54.77,99.34 54.58,99.64 54.54,99.72 54.56,99.8 54.64,99.88 55.41,99.88 55.44,99.9 55.57,99.9
+3P3V_EMMC on IN1 (solid shape): 103.07,23.11 103.07,21.31 102.77,21.01 101.35,21.01 101.19,21.16 101.19,21.85 101.58,22.23 101.59,22.82 101.01,22.87 100.88,22.91 100.75,22.9 100.41,22.82 100.28,22.49 100.26,22.41 100.18,22.38 99.75,22.38 99.54,22.58 99.54,23.25 99.58,23.33 99.67,23.35 99.85,23.36 100.01,23.45 100.07,23.48 100.14,23.45 100.43,23.37 100.69,23.52 102.66,23.52
+3P3V_PANEL on TOP (solid shape): 65.99,103.02 65.99,102.61 65.49,102.11 65.49,101.82 64.34,100.66 64.34,98.63 64.24,98.53 63.63,98.53 63.53,98.63 63.53,102.14 63.88,102.49 63.9,102.49 64.06,102.55 64.19,102.68 64.24,102.73 64.24,102.97 64.41,103.15 65.86,103.15
+3P3V_PANEL on BOTTOM (solid shape): 70.71,102.27 70.71,101.34 70.66,101.3 69.52,101.3 69.42,101.4 69.42,102.26 69.52,102.36 70.61,102.36
+3P3V_PANEL on IN2 (solid shape): 66.01,103.25 66.01,102.85 66.01,102.8 66.03,102.75 66.04,102.7 66.07,102.65 66.1,102.61 66.13,102.57 66.18,102.54 66.22,102.51 66.27,102.49 66.32,102.47 66.37,102.47 66.43,102.47 66.48,102.48 66.51,102.48 66.62,102.36 66.62,102.34 66.63,102.28 66.64,102.23 66.66,102.18 66.69,102.13 66.72,102.09 66.76,102.05 66.8,102.02 66.85,101.99 66.9,101.97 66.95,101.96 67.02,101.96 67.07,101.96 67.13,101.98 67.18,102 67.22,102.03 67.27,102.06 67.3,102.1 67.33,102.14 67.36,102.19 67.38,102.25 67.39,102.3 67.39,102.35 67.38,102.41 67.37,102.46 67.35,102.51 67.32,102.56 67.3,102.58 68.37,102.58 68.39,102.56 68.44,102.54 68.5,102.52 68.55,102.52 68.61,102.52 68.66,102.52 68.72,102.54 68.77,102.56 68.79,102.58 70.75,102.58 71.55,101.78 71.55,100.51 71.27,100.23 71.13,100.23 67.34,100.23 67.31,100.24 67.26,100.26 67.21,100.28 67.15,100.28 67.1,100.28 67.05,100.26 66.99,100.24 66.97,100.23 64.67,100.23 64.29,100.61 64.29,102.35 66.6,102.35 66.6,102.35 64.29,102.35 64.29,103.33 64.49,103.53 65.74,103.53
+3P3V_PANEL_O on TOP (solid shape): 63.47,102.95 63.47,102.62 62.89,102.03 62.89,101.73 62.71,101.55 62.71,98.68 62.66,98.63 61.98,98.63 61.87,98.73 61.87,100.76 61.77,100.87 61.77,103 61.87,103.1 63.32,103.1
+3P3V_PANEL_O on BOTTOM (solid shape): 52.4,100.76 52.4,99.75 51.71,99.06 51.63,99.06 51.15,98.58 50.47,98.58 50.39,98.66 50.39,98.96 50.6,99.16 50.6,99.98 50.44,100.13 48.46,100.13 48.36,100.23 48.36,100.87 48.49,100.99 52.17,100.99
+3P3V_PANEL_O on IN2 (solid shape): outline of 234 points within 50.67,100.03 63.53,103.63
+3P3V_SENSOR on TOP (solid shape): 155.46,25.97 155.46,23.43 156.06,22.84 156.06,21.75 155.89,21.58 155.33,21.58 155.22,21.69 155.22,22.56 155.21,22.57 155.21,22.8 155.17,22.84 155.02,22.84 154.97,22.89 154.97,23.24 154.74,23.46 154.74,26.02 154.81,26.09 155.35,26.09
+3P3V_SSD on TOP (solid shape): 224.13,22.58 224.13,15.93 224.03,15.83 223.42,15.83 223.09,16.16 223.09,16.49 219.51,20.07 218.85,20.07 218.64,20.27 218.64,22.1 218.87,22.33 220.35,22.33 220.47,22.46 220.66,22.46 220.75,22.39 220.72,22.27 221.23,20.75 221.74,22.27 221.71,22.39 221.81,22.46 222.16,22.81 223.9,22.81
+3P3V_SSD on BOTTOM (solid shape): outline of 125 points within 219.2,16.49 224.18,22.94
+3P3V_SSD on IN1 (solid shape): 223.98,3.7 224.03,3.7 224.33,3.41 224.33,2.42 224.03,2.11 222.33,2.11 221.97,2.47 221.97,3.61 222.17,3.81 223.88,3.81
+3P3VSB on TOP (solid shape): 152.73,105.16 152.73,104.22 152.58,104.07 151.56,104.07 151.44,104.19 151.44,105.29 151.51,105.36 152.53,105.36
+3P3VSB on TOP (solid shape): 167.82,108.94 167.82,107.98 167.67,107.83 165.94,107.83 165.63,108.13 165.63,108.82 165.89,109.07 167.69,109.07
+3P3VSB on TOP (solid shape): 184.33,111.41 184.33,110.75 184.15,110.57 182.91,110.57 182.84,110.63 182.76,110.76 182.68,110.89 182.68,111.84 182.78,111.94 183.79,111.94
+3P3VSB on TOP (solid shape): 143.24,92.61 143.57,92.39 143.96,92.48 144,92.5 144.04,92.46 144.04,91.44 143.89,91.29 142.16,91.29 142.01,91.44 142.01,92.46 142.16,92.61
+3P3VSB on TOP (solid shape): 176.66,64.26 176.66,60.2 176.28,59.82 166.95,59.82 166.19,60.58 166.19,63.71 166.5,64.01 167.94,64.01 171.86,61.56 175.22,64.75 176.17,64.75
+3P3VSB on TOP (solid shape): outline of 418 points within 206.15,18.87 219.66,53.29
+3P3VSB on BOTTOM (solid shape): 113.67,109.4 113.67,109.12 113.39,108.84 112.34,108.84 112.27,108.92 112.27,109.91 113.16,109.91
+3P3VSB on BOTTOM (solid shape): 184.58,113.97 184.58,112.68 184.86,112.4 184.86,111.09 184.53,110.76 184.4,110.76 184.14,110.49 183.16,110.49 182.7,110.95 182.7,112.88 182.83,113.01 182.83,114.3 184.25,114.3
