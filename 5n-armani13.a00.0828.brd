# Allegro board 5n-armani13.a00.0828.brd (continued)
## Library data of the parts (continued)
C0400 C0500 C0600 C0601 C0602 C0603 C0604 C0605 C0606 C0607 C0608 C0609 C0610 C0611 C0612 C0613 C0614 C0615 C0616 C0617 C0618 C0619 C0620 C0621 C0622 C0700 C0701 C0702 C0703 C0704 C0705 C0706 C0707 C0708 C0709 C0710 C0711 C0712 C0713 C0714 C0715 C0716 C0717 C0718 C0719 C0720 C0721 C0722 C0723 C0724 C0725 C0726 C0727 C0728 C0729 C0730 C0731 C0732 C0733 C0734 C0735 C0736 C0737 C0738 C0739 C0740 C0741 C0742 C0743 C0744 C0745 C0746 C0747 C0748 C0749 C0900 C0901 C1000-C1006 C1100-C1105 C1600-C1613 C1615 C1616 C1619-C1634 C1901-C1906 C2000-C2012 C2100-C2111 C2200-C2243 C2310-C2314 C2316-C2319 C2321 C2400 C2500 C2501 C2503-C2506 C2600 C2601 C2908 C2909 C3000 C3003 C3010 C3011 C3100-C3103 C3108-C3110 C3115-C3119 C3124 C3127 C3600 C3602 C3603 C3605 C3701-C3706 C3800-C3809 C3815-C3817 C3819 C3820 C3822-C3829 C3832-C3843 C3901-C3911 C3913 C3914 C5100-C5125 C5127-C5130 C5132 C5300 C5301 C5700-C5704 C5723 C5724 C5800-C5807 C5809 C5811-C5814 C5900 C5903 C5905-C5913 C6016 C6200-C6203 C6300-C6305 C6600-C6637 C6700-C6754 C6800-C6803 C6900 C6901 C6907 C6908 C7001 C7005 C7006 C7008 C7100-C7103 PC7600-PC7603 PC7605-PC7612 PC7700-PC7707 PC7709 PC7710 PC7712-PC7714 PC7716 PC7717 PC7719-PC7723 PC7800-PC7815 PC7817-PC7819 PC7821-PC7841 PC7900-PC7915 PC8000-PC8013 PC8100-PC8187 PC8600 PC8602-PC8622 PC8700 PC8713-PC8715 PC8800-PC8814 PC8900-PC8925 PC9000-PC9004 PC9007 PC9100-PC9105 PC9107-PC9114 PC9200-PC9206 PC9402-PC9406 PC9410-PC9412 PC9414-PC9420 PC9424 PC9425 PC9503 PC9504 PC9512 PC9513 PC9518 PC9600-PC9627 PC9800-PC9808 PC9811 = C
C0623 C1200-C1207 C1614 C1617 C1618 C1800 C1900 C2300-C2309 C2315 C2901 C2904 C2905 C2907 C3001 C3002 C3120-C3123 C3125 C3604 C3700 C5126 C5131 C5133-C5136 PC7604 PC9005 = C: signal model: DEFAULT_CAPACITOR_100000pF_2_1
C2401 C3707 = C: signal model: DEFAULT_CAPACITOR_10000pF_2_1
C2502 = C: signal model: DEFAULT_CAPACITOR_1e+07pF_2_1
C2900 C2902 C2903 C2906 = C: signal model: C_VX_C0402_SMALL_0.1UF/16V_0.1UF/16V
C3004-C3009 = C: signal model: C_VX_C0201_0.1UF/6.3V_0.1UF/6.3V
C3104-C3107 C3111-C3114 = C: signal model: C_VX_C0402_SMALL_0.22UF/16V_0.22UF/16V
C3601 = C: signal model: DEFAULT_CAPACITOR_2.2e+06pF_2_1
C3810-C3813 = C: signal model: DEFAULT_CAPACITOR_100.000000pF_2_1
C3814 = C: signal model: DEFAULT_CAPACITOR_22.000000pF_2_1
C3818 C3821 C5808 C5810 = C: signal model: DEFAULT_CAPACITOR_1e+06pF_2_1
C3830 C3831 = C: signal model: DEFAULT_CAPACITOR_330.000000pF_2_1
C5705-C5718 = C: signal model: C_C0402_0.1UF/6.3V_0.1UF/6.3V
C5719-C5722 C6008-C6015 = C: signal model: C_VX_C0402_SMALL_0.22UF/10V_0.22UF/10V
C6000-C6007 = C: signal model: C_MX_C0402_SMALL_T01_0.22UF/10V_0.22UF/10V
C7007 PC9413 PC9515 PC9809 = C: room: AUD
CE2200 CE2201 PCE7900 PCE8000 PCE8100 PCE8600 PCE8900-PCE8902 PCE9600-PCE9602 = CAP
CON2000 CON2100 = DDR4_260P_4HD_FOX
CON2600 = HDMI_CON_19P_4HOD_STD
CON3000 CON5102 = ZIF_CON_30P_2HOLD
CON3100 = NGFF_67P_4HOLD_ARG
CON3101 J5300 J5301 = FPC_CON_12P_2HOLD_KEC
CON3600 = ZIF_CON_4P_6905
CON3601 = FPC_CON_10P_2HOLD
CON3602 = WtoB_CON_2P_2HOLD
CON3800 = BATT_CON_6P_2HOLD
CON5100 = FPC_CON_8P_2HOLD_MOLEX
CON5101 = FPC_4P_2HOLD
CON5103 = WTOB_CON_50P_4HOLD
CON5104 = WTOB_CON_20P_4H_STAR
CON5700 = USB_24P_12HD_FOX_STD
CON7600 = FPC_CON_7P_2HOLD_SUNCAGEY
D1800 D2300 D2400 D2500 D3003 D3004 D3600 D3604 D3605 D3700 PCE8601 PD7600 PD8800 = SCHOTTKY_DIODE
D2401 = Dual_Diode_3anode
D2600 D2900 D2901 D3001 D3002 D3601-D3603 D3800-D3804 D3806 D5100-D5103 D5700-D5707 PD7602 = VPORT_0603
D2902 D3807 = SCHOTTKY_DIODE_3ANODE
D3000 D3805 D5800 = BAT54C
D5708 D5709 = Zener_Diode
F2600 F3000 F5100 = POLY_FUSE
H5200 H5203 = HOLE_NPTH
H5201 H5202 H5204 H5205 H5207-H5216 = HOLE_PTH
J3800 = AUDIO_JACK_6P_TECHNIK
L2600-L2603 L3000 L5700-L5702 = Common_Choke_12_43_WE
L3601-L3603 L3800-L3806 L6700-L6702 PL7600-PL7606 = BEAD
L5703-L5705 = Common_Choke_12_43_WE: signal model: COMMON_CHOKE_12_43_WE_CHOKE_4P__90ohm
LED5000 = LED_3P_HAR
PC7708 PC7718 = C: signal model: DEFAULT_CAPACITOR_4.7e+06pF_2_1
PC7711 PC7715 = C: signal model: DEFAULT_CAPACITOR_220000pF_2_1
PC7816 = C: signal model: DEFAULT_CAPACITOR_22000pF_2_1
PC7820 = C: signal model: DEFAULT_CAPACITOR_1000pF_2_1
PC8601 PC9407 PC9409 = C: room: VGP
PC8701-PC8712 = C: room: 1.0VSUS
PC9421-PC9423 PC9507 = C: room: 1.35VS_VGA
PC9500-PC9502 PC9505 PC9506 PC9508-PC9511 PC9514 PC9516 PC9517 = C: room: +1.8VO_VGA
PD7601 = Dual_Diode_Convert_1anode
PD7700 PD7701 = DIODE
PD9400 = DIODE: room: VGP
PD9800 = DIODE: room: 1.35VS_VGA
PJP7700-PJP7703 PJP7900-PJP7904 PJP8000-PJP8003 PJP8600 PJP8800 PJP8801 PJP8900 PJP8901 = SHORT_PIN_RECTANGLE
PJP8601 PJP8902 PJP8903 PJP9800 = 3MMO_S: room: SYS
PJP8602 PR7801 PR7802 PR8603 PR8612 PR8613 PR8700 PR8702 PR8801 PR8806 PR8808 PR8811 PR8901 PR8913 PR8916 PR9002-PR9004 PR9102 PR9108 PR9111 PR9202-PR9204 PR9206 PR9208 PR9209 PR9414 PR9456 PR9600-PR9602 PR9800 PR9815 R1600-R1602 R1604 R1606 R1609-R1614 R1620-R1625 R1901 R1907 R1908 R2301 R2308 R2321 R2336 R2346 R2510 R2511 R3004 R3006-R3008 R3600 R3702 R3706 R3901 R5109 R5712 R5714 R5721 R5722 R5801 R5805 R5814 SR3100 = SHORT_PIN_SR_S
PJP8700 = SHORT_PIN_RECTANGLE: room: 1.0VSUS
PJP8701 PJP9504 = 3MMO_S: room: 1.0VSUS
PJP8802 = 3MMO_S: room: DDR
PJP9500 PJP9501 PJP9503 = 3MMO_S: room: +1.8VO_VGA
PJP9502 PJP9505 PJP9600-PJP9603 PJP9801 = SHORT_PIN_RECTANGLE: room: +1.8VO_VGA
PL7700 = INDUCTOR: signal model: DEFAULT_INDUCTOR_2200nH_2_1
PL7900 PL7901 PL8000 PL8001 PL8600 PL8700 PL8800 PL8801 PL8900 PL9500 PL9501 PL9600 PL9601 PL9800 = INDUCTOR
PL8901 = INDUCTOR: signal model: DEFAULT_INDUCTOR_3300nH_2_1
PQ7600 PQ7607 PQ7613 PQ7614 PQ7701 = SI7411DN
PQ7601 PQ7603 PQ7608 PQ7612 Q1900-Q1902 Q2400 Q2401 Q2900 Q2901 Q3101 Q3701 Q5000 Q5002 Q5102-Q5104 Q6900 = UM6K1N_NB
PQ7602 Q3700 = NPN_SOT23
PQ7605 PQ7609 PQ7610 = NPN_PNP_SOT363
PQ7606 PQ7611 = XP4401
PQ7700 PQ7702-PQ7704 = SI7840DP
PQ7900 PQ7901 PQ8001 PQ9600 PQ9601 = FDPC5018SG_8V
PQ8000 PQ8600 PQ8900 PQ8901 = SIZ300DT_T1_GE3
PR7600-PR7604 PR7607-PR7613 PR7615-PR7623 PR7625-PR7629 PR7633-PR7639 PR7641 PR7643-PR7646 PR7700 PR7702 PR7705-PR7707 PR7709-PR7717 PR7726 PR7800 PR7803-PR7811 PR7813 PR7815 PR7817 PR7819 PR7821-PR7824 PR7826-PR7828 PR7831-PR7833 PR7835 PR7838 PR7842 PR7844 PR7846-PR7848 PR7850 PR7851 PR7853-PR7856 PR7900 PR7902-PR7922 PR8000-PR8016 PR8600-PR8602 PR8604-PR8611 PR8616-PR8618 PR8701 PR8705 PR8707-PR8712 PR8800 PR8802-PR8805 PR8807 PR8809 PR8810 PR8812 PR8900 PR8902-PR8912 PR8914 PR8915 PR8917-PR8923 PR9001 PR9005 PR9101 PR9104 PR9105 PR9107 PR9110 PR9201 PR9207 PR9401-PR9403 PR9410 PR9412 PR9415-PR9417 PR9419-PR9429 PR9431-PR9435 PR9437-PR9455 PR9457-PR9460 PR9500 PR9503 PR9505 PR9508 PR9509 PR9603-PR9610 PR9801-PR9812 PR9814 R0400 R0401 R0402 R0403 R0404 R0405 R0406 R0407 R0411 R0413 R0414 R0415 R0416 R0417 R0418 R0420 R0500 R0501 R0502 R0503 R0504 R0600 R0601 R0602 R0606 R0607 R0608 R0609 R0702 R0703 R0900 R0901 R0902 R0903 R1000 R1002-R1006 R1009-R1012 R1016-R1019 R1021-R1030 R1100-R1107 R1109 R1114 R1200 R1202-R1210 R1212-R1214 R1218 R1220 R1222 R1224-R1226 R1300 R1301 R1400-R1405 R1409-R1411 R1500 R1503-R1520 R1607 R1608 R1615 R1802 R1804 R1806 R1807 R1902-R1904 R1911-R1913 R1915 R1917-R1921 R2000 R2002-R2006 R2100-R2104 R2306 R2309 R2310 R2312-R2320 R2322 R2324-R2326 R2328 R2331-R2335 R2337-R2339 R2341-R2344 R2347-R2349 R2351 R2405-R2408 R2411-R2416 R2423-R2425 R2428 R2501-R2509 R2512-R2514 R2600-R2602 R2607-R2610 R2900 R2901 R2903-R2913 R3003 R3005 R3009 R3102 R3105 R3107-R3110 R3114 R3116 R3601 R3602 R3606-R3609 R3611 R3612 R3700 R3701 R3703 R3707-R3715 R3800 R3801 R3804 R3815-R3819 R3821-R3829 R3903 R3909-R3918 R5000-R5002 R5004 R5100-R5108 R5110 R5700-R5707 R5709-R5711 R5716-R5718 R5720 R5723-R5725 R5800 R5802-R5804 R5806-R5813 R5815-R5827 R5900 R5902-R5907 R6006-R6008 R6200-R6207 R6300 R6301 R6303-R6309 R6800-R6811 R6813-R6819 R6907 R6908 R6910-R6914 R6934-R6943 R7003-R7005 R7200-R7205 = R
PR7614 PR7701 PR8615 PR9103 R0700 R0701 R0904 R0905 R1001 R1020 R1201 R1217 R1221 R1227 R1229 R2329 R2330 R2404 R2500 R3002 R3111-R3113 R3115 R3610 R3806 R3807 R3812 R3813 R3904 = R: signal model: DEFAULT_RESISTOR_0.001OHM_2_1
PR7624 PR7640 = R: room: PD_SW
PR7703 PR7704 PR7708 = R: signal model: R0402_1OHM
PR7718-PR7725 R1008 = R: signal model: MX_R0402_0OHM
PR7812 = R: signal model: DEFAULT_RESISTOR_4220OHM_2_1
PR7814 = R: signal model: DEFAULT_RESISTOR_301.000000OHM_2_1
PR7816 PR7845 = R: signal model: DEFAULT_RESISTOR_2150OHM_2_1
PR7820 = R: signal model: DEFAULT_RESISTOR_3480OHM_2_1
PR7825 = R: signal model: DEFAULT_RESISTOR_95300OHM_2_1
PR7829 PR7830 PRT7800-PRT7802 PRT9400 PRT9401 TR3700 = THERMISTOR
PR7834 = R: signal model: R_VX_R0402_SMALL_100OHM_100Ohm
PR7836 PR7840 R3103 R3104 = SHORT_PIN_SR_S: signal model: VX_R0402_0OHM_SMALL_0OHM
PR7837 R3106 R3820 = R: signal model: VX_R0402_0OHM_SMALL_0OHM
PR7839 = R: signal model: MX_R0402_SMALL_T01_10_OHM
PR7843 = R: signal model: R_VX_R0402_SMALL_51OHM_51Ohm
PR7849 = R: signal model: DEFAULT_RESISTOR_102000OHM_2_1
PR8614 PR9000 PR9100 PR9106 PR9109 PR9200 PR9205 R0408 R1211 R1216 R1223 R1228 R1406-R1408 R1800 R1801 R1803 R1805 R1914 R1916 R2302 R2307 R2323 R2345 R2400-R2403 R2409 R2410 R3000 R3001 R3704 R3705 R3902 R5719 = SHORT_PIN_SR_S: signal model: DEFAULT_RESISTOR_0.001OHM_2_1
PR8703 PR8704 PR8706 PR9408 PR9413 = R: room: 1.0VSUS
PR8813 PR8814 = R: signal model: DEFAULT_RESISTOR_330000OHM_2_1
PR9409 PR9430 PR9436 R6302 = R: room: VGP
PR9501 PR9502 PR9504 PR9506 PR9507 = R: room: +1.8VO_VGA
PT7700-PT7702 T0400 T0401 T0402 T0403 T0404 T0405 T0406 T0407 T0408 T0409 T0410 T0411 T0412 T0900 T0901 T0902 T0903 T0904 T0905 T0906 T0907 T0908 T0909 T0910 T0911 T0912 T0913 T0914 T0915 T0916 T0917 T0918 T0919 T0920 T0921 T1000 T1002-T1006 T1100 T1101 T1103-T1107 T1200-T1207 T1400-T1402 T1500-T1513 T2300-T2310 T3600 T5802-T5804 T6302 T6303 T6900-T6941 T6943-T6948 = test_point
PT8700-PT8704 = test_point: room: 1.0VSUS
PT9400-PT9403 = test_point: room: VGP
PT9500-PT9515 = test_point: room: +1.8VO_VGA
PT9800 = test_point: room: CTL
PU7600 = R3118K161A_TR
PU7700 = ISL9238HRZ_T_5V
PU7800 = ISL95859HRTZ_8V_INT
PU7900 PU7901 PU8000 PU8001 = ISL6208BCRZ_1VIA
PU8600 = RT8231AGQW_4VIA
PU8700 = NB685GQ_Z
PU8800 PU8801 PU9501 = RT8068AZQW_4VIA
PU8900 = RT6575BGQW_4VIA
PU9000 U1200-U1203 U1800 U6001 U6903 = NL17SZ08
PU9001 PU9100 PU9101 PU9200 = TX_APL3523AQB_ITRG
PU9400 = RT3662ACGQW_4V
PU9500 = SY8003DFC_VIA
PU9800 = NB681AGD
Q0400 Q1000 Q2403 Q2601 Q3100 Q3102 Q3600-Q3602 Q5100 Q5800 Q5801 Q6901 Q7200-Q7204 = NX3008NBKT
Q2406 Q2600 Q5101 = P_MOS_SOT23
R0410 = R: signal model: R_VX_R0402_SMALL_499OHM_499Ohm
R0603 = R: signal model: R_VX_R0402_SMALL_220OHM_220Ohm
R0604 R0605 = R: signal model: R_VX_R0201_0OHM_H10_0OHM_0Ohm
R1007 = R: signal model: DEFAULT_RESISTOR_0.01OHM_2_1
R1013-R1015 R3805 R3808 = R: signal model: R_R0201_H10_DISCRETE_33OHM_33Ohm
R1108 = R: signal model: R_R0201_H10_22OHM_22Ohm
R1110-R1113 = R: signal model: DEFAULT_RESISTOR_15.000000OHM_2_1
R1115 = R: signal model: R_TX_R0402_15OHM_15Ohm
R1900 R3907 = R: signal model: DEFAULT_RESISTOR_33.000000OHM_2_1
R1905 R1906 = R: signal model: R_VX_R0402_SMALL_15OHM_15Ohm
R1909 R1910 = SHORT_PIN_SR_S: signal model: R_VX_R0402_0OHM_SMALL_0OHM_0Ohm
R2001 R6812 = R: signal model: MX_R0402_SMALL_T01_0_OHM
R2300 = R: signal model: R_R0201_43OHM_43ohm
R2305 R2311 R6900 = R: signal model: DEFAULT_RESISTOR_330.000000OHM_2_1
R3613 = R: signal model: DEFAULT_RESISTOR_1500OHM_2_1
R3614 = R: signal model: DEFAULT_RESISTOR_45300OHM_2_1
R3802 R3803 = R: signal model: VX_R0402_SMALL_10OHM
R3809 R3814 = R: signal model: DEFAULT_RESISTOR_100000OHM_2_1
R3810 = R: signal model: DEFAULT_RESISTOR_200000OHM_2_1
R3811 = R: signal model: DEFAULT_RESISTOR_10000OHM_2_1
R3905 R3908 = SHORT_PIN_SR_S: signal model: DEFAULT_RESISTOR_33.000000OHM_2_1
RN2603-RN2606 = 2R4Ps: signal model: DEFAULT_RESISTOR_PACK_2_0.001OHM
RN3000 = 2R4Ps: signal model: 2R4PS_VX_2R4P1234_CHOKE_4P_COLA_0Ohm
RN5100 RN5101 = 4R8Ps
RN5700 RN5701 = 2R4Ps: signal model: 2R4PS_VX_2R4P0402_0OHM_0Ohm
RN5702 = 2R4Ps: signal model: 2R4PS_TX_2R4P0402_47X55_COLAY_0_0Ohm
RN5703-RN5705 = 2R4Ps
T5700 T5701 T5801 T5805 T6300 T6301 = MX_TP
U0400 = SKYLAKE_U_1356P_INT
U0500 U1204 = SN74LVC1G07DCKR
U1900 = W25Q32FVSSIG
U2300 = MEC1418_NU
U2500 = H26M88002AMR
U2600 U2601 U5700 U5701 = PUSB3F96
U3000 = G5244T11U
U3100 = G524D1T11U
U3700 = NCT7718W
U3701 = LNG2DMTR
U3702 = BU52061NVX_TR_1VIA
U3800 = ALC3254_CG_9V
U3901 = NPCT650JBAYX
U5100 = RN4904_2_2J1A
U5101 U5801 = G517C2T11U
U5702 = TS3DS10224RUKR_5V
U5703 = TUSB546_DCIRNQR_8V
U5800 = CYPD4125_40LQXIT_4VIA_CYP
U5802 = APL5156_BI_TRL
U5900 = DPS1113FIA_13_F_8VIA
U6000 = R16M_M2_50
U6800-U6803 = K4G80325FB_HC03
U7000 = G5016KD1U
X0900 X1000 X6900 = CRYSTAL_SMD_24GND
X1001 X2300 = CRYSTAL

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
1MM_OPEN_5MIL_M1M2
  custom 0.254x0.254 smd: 1(0.036,-0.472) 2(0.043,0.533)
2MM_OPEN_5MIL_M1M2
  custom 0.508x0.508 smd: 1(0,-0.699) 2(0,0.699)
3MM_OPEN_5MIL_M1M2
  custom 0.572x0.572 smd: 1(0,0.5) 2(0,-1.8)
A_BGA_153P_20_516X457_H39
  round 0.254 smd: A1(-3.25,-3.25) A2(-3.25,-2.75) A3(-3.25,-2.25) A4(-3.25,-1.75) A5(-3.25,-1.25) A6(-3.25,-0.75) A7(-3.25,-0.25) A8(-3.25,0.25) A9(-3.25,0.75) A10(-3.25,1.25) A11(-3.25,1.75) A12(-3.25,2.25) A13(-3.25,2.75) A14(-3.25,3.25) B1(-2.75,-3.25) B2(-2.75,-2.75) B3(-2.75,-2.25) B4(-2.75,-1.75) B5(-2.75,-1.25) B6(-2.75,-0.75) B7(-2.75,-0.25) B8(-2.75,0.25) B9(-2.75,0.75) B10(-2.75,1.25) B11(-2.75,1.75) B12(-2.75,2.25) B13(-2.75,2.75) B14(-2.75,3.25) C1(-2.25,-3.25) C2(-2.25,-2.75) C3(-2.25,-2.25) C4(-2.25,-1.75) C5(-2.25,-1.25) C6(-2.25,-0.75) C7(-2.25,-0.25) C8(-2.25,0.25) C9(-2.25,0.75) C10(-2.25,1.25) C11(-2.25,1.75) C12(-2.25,2.25) C13(-2.25,2.75) C14(-2.25,3.25) D1(-1.75,-3.25) D2(-1.75,-2.75) D3(-1.75,-2.25) D4(-1.75,-1.75) D12(-1.75,2.25) D13(-1.75,2.75) D14(-1.75,3.25) E1(-1.25,-3.25) E2(-1.25,-2.75) E3(-1.25,-2.25) E5(-1.25,-1.25) E6(-1.25,-0.75) E7(-1.25,-0.25) E8(-1.25,0.25) E9(-1.25,0.75) E10(-1.25,1.25) E12(-1.25,2.25) E13(-1.25,2.75) E14(-1.25,3.25) F1(-0.75,-3.25) F2(-0.75,-2.75) F3(-0.75,-2.25) F5(-0.75,-1.25) F10(-0.75,1.25) F12(-0.75,2.25) F13(-0.75,2.75) F14(-0.75,3.25) G1(-0.25,-3.25) G2(-0.25,-2.75) G3(-0.25,-2.25) G5(-0.25,-1.25) G10(-0.25,1.25) G12(-0.25,2.25) G13(-0.25,2.75) G14(-0.25,3.25) H1(0.25,-3.25) H2(0.25,-2.75) H3(0.25,-2.25) H5(0.25,-1.25) H10(0.25,1.25) H12(0.25,2.25) H13(0.25,2.75) H14(0.25,3.25) J1(0.75,-3.25) J2(0.75,-2.75) J3(0.75,-2.25) J5(0.75,-1.25) J10(0.75,1.25) J12(0.75,2.25) J13(0.75,2.75) J14(0.75,3.25) K1(1.25,-3.25) K2(1.25,-2.75) K3(1.25,-2.25) K5(1.25,-1.25) K6(1.25,-0.75) K7(1.25,-0.25) K8(1.25,0.25) K9(1.25,0.75) K10(1.25,1.25) K12(1.25,2.25) K13(1.25,2.75) K14(1.25,3.25) L1(1.75,-3.25) L2(1.75,-2.75) L3(1.75,-2.25) L12(1.75,2.25) L13(1.75,2.75) L14(1.75,3.25) M1(2.25,-3.25) M2(2.25,-2.75) M3(2.25,-2.25) M4(2.25,-1.75) M5(2.25,-1.25) M6(2.25,-0.75) M7(2.25,-0.25) M8(2.25,0.25) M9(2.25,0.75) M10(2.25,1.25) M11(2.25,1.75) M12(2.25,2.25) M13(2.25,2.75) M14(2.25,3.25) N1(2.75,-3.25) N2(2.75,-2.75) N3(2.75,-2.25) N4(2.75,-1.75) N5(2.75,-1.25) N6(2.75,-0.75) N7(2.75,-0.25) N8(2.75,0.25) N9(2.75,0.75) N10(2.75,1.25) N11(2.75,1.75) N12(2.75,2.25) N13(2.75,2.75) N14(2.75,3.25) P1(3.25,-3.25) P2(3.25,-2.75) P3(3.25,-2.25) P4(3.25,-1.75) P5(3.25,-1.25) P6(3.25,-0.75) P7(3.25,-0.25) P8(3.25,0.25) P9(3.25,0.75) P10(3.25,1.25) P11(3.25,1.75) P12(3.25,2.25) P13(3.25,2.75) P14(3.25,3.25)
A_DDR4_260P_20_4H_REV_FOX
  round 1.092 hole 1.092 unplated: (-34.4,0)
  round 1.6 hole 1.6 unplated: (34.4,0)
  rect 0.305x1.753 smd: 1(33.375,4.1) 2(33.125,-4.1) 3(32.875,4.1) 4(32.625,-4.1) 5(32.375,4.1) 6(32.125,-4.1) 7(31.875,4.1) 8(31.625,-4.1) 9(31.375,4.1) 10(31.125,-4.1) 11(30.875,4.1) 12(30.625,-4.1) 13(30.375,4.1) 14(30.125,-4.1) 15(29.875,4.1) 16(29.625,-4.1) 17(29.375,4.1) 18(29.125,-4.1) 19(28.875,4.1) 20(28.625,-4.1) 21(28.375,4.1) 22(28.125,-4.1) 23(27.875,4.1) 24(27.625,-4.1) 25(27.375,4.1) 26(27.125,-4.1) 27(26.875,4.1) 28(26.625,-4.1) 29(26.375,4.1) 30(26.125,-4.1) 31(25.875,4.1) 32(25.625,-4.1) 33(25.375,4.1) 34(25.125,-4.1) 35(24.875,4.1) 36(24.625,-4.1) 37(24.375,4.1) 38(24.125,-4.1) 39(23.875,4.1) 40(23.625,-4.1) 41(23.375,4.1) 42(23.125,-4.1) 43(22.875,4.1) 44(22.625,-4.1) 45(22.375,4.1) 46(22.125,-4.1) 47(21.875,4.1) 48(21.625,-4.1) 49(21.375,4.1) 50(21.125,-4.1) 51(20.875,4.1) 52(20.625,-4.1) 53(20.375,4.1) 54(20.125,-4.1) 55(19.875,4.1) 56(19.625,-4.1) 57(19.375,4.1) 58(19.125,-4.1) 59(18.875,4.1) 60(18.625,-4.1) 61(18.375,4.1) 62(18.125,-4.1) 63(17.875,4.1) 64(17.625,-4.1) 65(17.375,4.1) 66(17.125,-4.1) 67(16.875,4.1) 68(16.625,-4.1) 69(16.375,4.1) 70(16.125,-4.1) 71(15.875,4.1) 72(15.625,-4.1) 73(15.375,4.1) 74(15.125,-4.1) 75(14.875,4.1) 76(14.625,-4.1) 77(14.375,4.1) 78(14.125,-4.1) 79(13.875,4.1) 80(13.625,-4.1) 81(13.375,4.1) 82(13.125,-4.1) 83(12.875,4.1) 84(12.625,-4.1) 85(12.375,4.1) 86(12.125,-4.1) 87(11.875,4.1) 88(11.625,-4.1) 89(11.375,4.1) 90(11.125,-4.1) 91(10.875,4.1) 92(10.625,-4.1) 93(10.375,4.1) 94(10.125,-4.1) 95(9.875,4.1) 96(9.625,-4.1) 97(9.375,4.1) 98(9.125,-4.1) 99(8.875,4.1) 100(8.625,-4.1) 101(8.375,4.1) 102(8.125,-4.1) 103(7.875,4.1) 104(7.625,-4.1) 105(7.375,4.1) 106(7.125,-4.1) 107(6.875,4.1) 108(6.625,-4.1) 109(6.375,4.1) 110(6.125,-4.1) 111(5.875,4.1) 112(5.625,-4.1) 113(5.375,4.1) 114(5.125,-4.1) 115(4.875,4.1) 116(4.625,-4.1) 117(4.375,4.1) 118(4.125,-4.1) 119(3.875,4.1) 120(3.625,-4.1) 121(3.375,4.1) 122(3.125,-4.1) 123(2.875,4.1) 124(2.625,-4.1) 125(2.375,4.1) 126(2.125,-4.1) 127(1.875,4.1) 128(1.625,-4.1) 129(1.375,4.1) 130(1.125,-4.1) 131(0.875,4.1) 132(0.625,-4.1) 133(0.375,4.1) 134(0.125,-4.1) 135(-0.125,4.1) 136(-0.375,-4.1) 137(-0.625,4.1) 138(-0.875,-4.1) 139(-1.125,4.1) 140(-1.375,-4.1) 141(-1.625,4.1) 142(-1.875,-4.1) 143(-2.125,4.1) 144(-2.375,-4.1) 145(-4.625,4.1) 146(-4.875,-4.1) 147(-5.125,4.1) 148(-5.375,-4.1) 149(-5.625,4.1) 150(-5.875,-4.1) 151(-6.125,4.1) 152(-6.375,-4.1) 153(-6.625,4.1) 154(-6.875,-4.1) 155(-7.125,4.1) 156(-7.375,-4.1) 157(-7.625,4.1) 158(-7.875,-4.1) 159(-8.125,4.1) 160(-8.375,-4.1) 161(-8.625,4.1) 162(-8.875,-4.1) 163(-9.125,4.1) 164(-9.375,-4.1) 165(-9.625,4.1) 166(-9.875,-4.1) 167(-10.125,4.1) 168(-10.375,-4.1) 169(-10.625,4.1) 170(-10.875,-4.1) 171(-11.125,4.1) 172(-11.375,-4.1) 173(-11.625,4.1) 174(-11.875,-4.1) 175(-12.125,4.1) 176(-12.375,-4.1) 177(-12.625,4.1) 178(-12.875,-4.1) 179(-13.125,4.1) 180(-13.375,-4.1) 181(-13.625,4.1) 182(-13.875,-4.1) 183(-14.125,4.1) 184(-14.375,-4.1) 185(-14.625,4.1) 186(-14.875,-4.1) 187(-15.125,4.1) 188(-15.375,-4.1) 189(-15.625,4.1) 190(-15.875,-4.1) 191(-16.125,4.1) 192(-16.375,-4.1) 193(-16.625,4.1) 194(-16.875,-4.1) 195(-17.125,4.1) 196(-17.375,-4.1) 197(-17.625,4.1) 198(-17.875,-4.1) 199(-18.125,4.1) 200(-18.375,-4.1) 201(-18.625,4.1) 202(-18.875,-4.1) 203(-19.125,4.1) 204(-19.375,-4.1) 205(-19.625,4.1) 206(-19.875,-4.1) 207(-20.125,4.1) 208(-20.375,-4.1) 209(-20.625,4.1) 210(-20.875,-4.1) 211(-21.125,4.1) 212(-21.375,-4.1) 213(-21.625,4.1) 214(-21.875,-4.1) 215(-22.125,4.1) 216(-22.375,-4.1) 217(-22.625,4.1) 218(-22.875,-4.1) 219(-23.125,4.1) 220(-23.375,-4.1) 221(-23.625,4.1) 222(-23.875,-4.1) 223(-24.125,4.1) 224(-24.375,-4.1) 225(-24.625,4.1) 226(-24.875,-4.1) 227(-25.125,4.1) 228(-25.375,-4.1) 229(-25.625,4.1) 230(-25.875,-4.1) 231(-26.125,4.1) 232(-26.375,-4.1) 233(-26.625,4.1) 234(-26.875,-4.1) 235(-27.125,4.1) 236(-27.375,-4.1) 237(-27.625,4.1) 238(-27.875,-4.1) 239(-28.125,4.1) 240(-28.375,-4.1) 241(-28.625,4.1) 242(-28.875,-4.1) 243(-29.125,4.1) 244(-29.375,-4.1) 245(-29.625,4.1) 246(-29.875,-4.1) 247(-30.125,4.1) 248(-30.375,-4.1) 249(-30.625,4.1) 250(-30.875,-4.1) 251(-31.125,4.1) 252(-31.375,-4.1) 253(-31.625,4.1) 254(-31.875,-4.1) 255(-32.125,4.1) 256(-32.375,-4.1) 257(-32.625,4.1) 258(-32.875,-4.1) 259(-33.125,4.1) 260(-33.375,-4.1)
  rect 3.505x4.597 smd: 263(-33.8,12) 264(33.8,12)
A_DDR4_260P_20_4HOLD_FOX
  round 1.6 hole 1.6 unplated: (-34.4,0)
  round 1.092 hole 1.092 unplated: (34.4,0)
  rect 0.305x1.753 smd: 1(-33.375,-4.1) 2(-33.125,4.1) 3(-32.875,-4.1) 4(-32.625,4.1) 5(-32.375,-4.1) 6(-32.125,4.1) 7(-31.875,-4.1) 8(-31.625,4.1) 9(-31.375,-4.1) 10(-31.125,4.1) 11(-30.875,-4.1) 12(-30.625,4.1) 13(-30.375,-4.1) 14(-30.125,4.1) 15(-29.875,-4.1) 16(-29.625,4.1) 17(-29.375,-4.1) 18(-29.125,4.1) 19(-28.875,-4.1) 20(-28.625,4.1) 21(-28.375,-4.1) 22(-28.125,4.1) 23(-27.875,-4.1) 24(-27.625,4.1) 25(-27.375,-4.1) 26(-27.125,4.1) 27(-26.875,-4.1) 28(-26.625,4.1) 29(-26.375,-4.1) 30(-26.125,4.1) 31(-25.875,-4.1) 32(-25.625,4.1) 33(-25.375,-4.1) 34(-25.125,4.1) 35(-24.875,-4.1) 36(-24.625,4.1) 37(-24.375,-4.1) 38(-24.125,4.1) 39(-23.875,-4.1) 40(-23.625,4.1) 41(-23.375,-4.1) 42(-23.125,4.1) 43(-22.875,-4.1) 44(-22.625,4.1) 45(-22.375,-4.1) 46(-22.125,4.1) 47(-21.875,-4.1) 48(-21.625,4.1) 49(-21.375,-4.1) 50(-21.125,4.1) 51(-20.875,-4.1) 52(-20.625,4.1) 53(-20.375,-4.1) 54(-20.125,4.1) 55(-19.875,-4.1) 56(-19.625,4.1) 57(-19.375,-4.1) 58(-19.125,4.1) 59(-18.875,-4.1) 60(-18.625,4.1) 61(-18.375,-4.1) 62(-18.125,4.1) 63(-17.875,-4.1) 64(-17.625,4.1) 65(-17.375,-4.1) 66(-17.125,4.1) 67(-16.875,-4.1) 68(-16.625,4.1) 69(-16.375,-4.1) 70(-16.125,4.1) 71(-15.875,-4.1) 72(-15.625,4.1) 73(-15.375,-4.1) 74(-15.125,4.1) 75(-14.875,-4.1) 76(-14.625,4.1) 77(-14.375,-4.1) 78(-14.125,4.1) 79(-13.875,-4.1) 80(-13.625,4.1) 81(-13.375,-4.1) 82(-13.125,4.1) 83(-12.875,-4.1) 84(-12.625,4.1) 85(-12.375,-4.1) 86(-12.125,4.1) 87(-11.875,-4.1) 88(-11.625,4.1) 89(-11.375,-4.1) 90(-11.125,4.1) 91(-10.875,-4.1) 92(-10.625,4.1) 93(-10.375,-4.1) 94(-10.125,4.1) 95(-9.875,-4.1) 96(-9.625,4.1) 97(-9.375,-4.1) 98(-9.125,4.1) 99(-8.875,-4.1) 100(-8.625,4.1) 101(-8.375,-4.1) 102(-8.125,4.1) 103(-7.875,-4.1) 104(-7.625,4.1) 105(-7.375,-4.1) 106(-7.125,4.1) 107(-6.875,-4.1) 108(-6.625,4.1) 109(-6.375,-4.1) 110(-6.125,4.1) 111(-5.875,-4.1) 112(-5.625,4.1) 113(-5.375,-4.1) 114(-5.125,4.1) 115(-4.875,-4.1) 116(-4.625,4.1) 117(-4.375,-4.1) 118(-4.125,4.1) 119(-3.875,-4.1) 120(-3.625,4.1) 121(-3.375,-4.1) 122(-3.125,4.1) 123(-2.875,-4.1) 124(-2.625,4.1) 125(-2.375,-4.1) 126(-2.125,4.1) 127(-1.875,-4.1) 128(-1.625,4.1) 129(-1.375,-4.1) 130(-1.125,4.1) 131(-0.875,-4.1) 132(-0.625,4.1) 133(-0.375,-4.1) 134(-0.125,4.1) 135(0.125,-4.1) 136(0.375,4.1) 137(0.625,-4.1) 138(0.875,4.1) 139(1.125,-4.1) 140(1.375,4.1) 141(1.625,-4.1) 142(1.875,4.1) 143(2.125,-4.1) 144(2.375,4.1) 145(4.625,-4.1) 146(4.875,4.1) 147(5.125,-4.1) 148(5.375,4.1) 149(5.625,-4.1) 150(5.875,4.1) 151(6.125,-4.1) 152(6.375,4.1) 153(6.625,-4.1) 154(6.875,4.1) 155(7.125,-4.1) 156(7.375,4.1) 157(7.625,-4.1) 158(7.875,4.1) 159(8.125,-4.1) 160(8.375,4.1) 161(8.625,-4.1) 162(8.875,4.1) 163(9.125,-4.1) 164(9.375,4.1) 165(9.625,-4.1) 166(9.875,4.1) 167(10.125,-4.1) 168(10.375,4.1) 169(10.625,-4.1) 170(10.875,4.1) 171(11.125,-4.1) 172(11.375,4.1) 173(11.625,-4.1) 174(11.875,4.1) 175(12.125,-4.1) 176(12.375,4.1) 177(12.625,-4.1) 178(12.875,4.1) 179(13.125,-4.1) 180(13.375,4.1) 181(13.625,-4.1) 182(13.875,4.1) 183(14.125,-4.1) 184(14.375,4.1) 185(14.625,-4.1) 186(14.875,4.1) 187(15.125,-4.1) 188(15.375,4.1) 189(15.625,-4.1) 190(15.875,4.1) 191(16.125,-4.1) 192(16.375,4.1) 193(16.625,-4.1) 194(16.875,4.1) 195(17.125,-4.1) 196(17.375,4.1) 197(17.625,-4.1) 198(17.875,4.1) 199(18.125,-4.1) 200(18.375,4.1) 201(18.625,-4.1) 202(18.875,4.1) 203(19.125,-4.1) 204(19.375,4.1) 205(19.625,-4.1) 206(19.875,4.1) 207(20.125,-4.1) 208(20.375,4.1) 209(20.625,-4.1) 210(20.875,4.1) 211(21.125,-4.1) 212(21.375,4.1) 213(21.625,-4.1) 214(21.875,4.1) 215(22.125,-4.1) 216(22.375,4.1) 217(22.625,-4.1) 218(22.875,4.1) 219(23.125,-4.1) 220(23.375,4.1) 221(23.625,-4.1) 222(23.875,4.1) 223(24.125,-4.1) 224(24.375,4.1) 225(24.625,-4.1) 226(24.875,4.1) 227(25.125,-4.1) 228(25.375,4.1) 229(25.625,-4.1) 230(25.875,4.1) 231(26.125,-4.1) 232(26.375,4.1) 233(26.625,-4.1) 234(26.875,4.1) 235(27.125,-4.1) 236(27.375,4.1) 237(27.625,-4.1) 238(27.875,4.1) 239(28.125,-4.1) 240(28.375,4.1) 241(28.625,-4.1) 242(28.875,4.1) 243(29.125,-4.1) 244(29.375,4.1) 245(29.625,-4.1) 246(29.875,4.1) 247(30.125,-4.1) 248(30.375,4.1) 249(30.625,-4.1) 250(30.875,4.1) 251(31.125,-4.1) 252(31.375,4.1) 253(31.625,-4.1) 254(31.875,4.1) 255(32.125,-4.1) 256(32.375,4.1) 257(32.625,-4.1) 258(32.875,4.1) 259(33.125,-4.1) 260(33.375,4.1)
  rect 3.505x4.597 smd: 263(-33.8,12) 264(33.8,12)
A_HDMI_19P_4H_RA_SMT_ACON
  rect 0.813x0.813 hole 0.559: 1(-4.5,6.5)
  round 0.813 hole 0.559: 2(-4,8.05) 3(-3.5,6.5) 4(-3,8.05) 5(-2.5,6.5) 6(-2,8.05) 7(-1.5,6.5) 8(-1,8.05) 9(-0.5,6.5) 10(0,8.05) 11(0.5,6.5) 12(1,8.05) 13(1.5,6.5) 14(2,8.05) 15(2.5,6.5) 16(3,8.05) 17(3.5,6.5) 18(4,8.05) 19(4.5,6.5)
  oval 1.168x2.159 hole 0.762x1.753: 20(-9.15,0) 21(9.15,0)
  oval 1.295x2.007 hole 0.889x1.6: 22(-7.25,8.2) 23(7.25,8.2)
A_HOLE_C98D98N
  round 2.489 hole 2.489 unplated: (0,0)
A_QFN_17P_20_S161_P_8V
  rect 1.346x0.61 smd: 1(-1,-1.85) 17(-1,1.85)
  rect 0.305x0.61 smd: 4(0,-1.85) 5(0.5,-1.85) 6(1,-1.85) 12(1,1.85) 13(0.5,1.85) 14(0,1.85)
  rect 0.61x0.305 smd: 7(1.85,-1) 8(1.85,-0.5) 9(1.85,0) 10(1.85,0.5) 11(1.85,1)
  rect 2.972x2.591 smd: 18(-0.187,0)
  round 0.61 hole 0.305: 19(-1.187,0.75) 20(-0.187,0.75) 21(0.813,0.75) 22(-0.688,0) 23(0.312,0) 24(-1.187,-0.75) 25(-0.187,-0.75) 26(0.813,-0.75)
A_QFN_20P_16_122X122_P_5V
  rect 0.229x0.61 smd: 1(-0.8,-1.35) 2(-0.4,-1.35) 3(0,-1.35) 4(0.4,-1.35) 5(0.8,-1.35) 11(0.8,1.35) 12(0.4,1.35) 13(0,1.35) 14(-0.4,1.35) 15(-0.8,1.35)
  rect 0.61x0.229 smd: 6(1.35,-0.8) 7(1.35,-0.4) 8(1.35,0) 9(1.35,0.4) 10(1.35,0.8) 16(-1.35,0.8) 17(-1.35,0.4) 18(-1.35,0) 19(-1.35,-0.4) 20(-1.35,-0.8)
  rect 1.676x1.676 smd: 21(0,0)
  round 0.61 hole 0.305: 22(-0.5,0.5) 23(0.5,0.5) 24(0,0) 25(-0.5,-0.5) 26(0.5,-0.5)
A_QFN_20P_16_S122_P_4V
  rect 0.229x0.61 smd: 1(-0.8,-1.345) 2(-0.4,-1.345) 3(0,-1.345) 4(0.4,-1.345) 5(0.8,-1.345) 11(0.8,1.345) 12(0.4,1.345) 13(0,1.345) 14(-0.4,1.345) 15(-0.8,1.345)
  rect 0.61x0.229 smd: 6(1.345,-0.8) 7(1.345,-0.4) 8(1.345,0) 9(1.345,0.4) 10(1.345,0.8) 16(-1.345,0.8) 17(-1.345,0.4) 18(-1.345,0) 19(-1.345,-0.4) 20(-1.345,-0.8)
  rect 1.651x1.651 smd: 21(0,0)
  round 0.61 hole 0.305: 22(-0.5,0.5) 23(0.5,0.5) 24(-0.5,-0.5) 25(0.5,-0.5)
A_QFN_32P_20_S197_PAD_T01
  rect 0.279x0.61 smd: 1(-1.75,-2.345) 2(-1.25,-2.345) 3(-0.75,-2.345) 4(-0.25,-2.345) 5(0.25,-2.345) 6(0.75,-2.345) 7(1.25,-2.345) 8(1.75,-2.345) 17(1.75,2.345) 18(1.25,2.345) 19(0.75,2.345) 20(0.25,2.345) 21(-0.25,2.345) 22(-0.75,2.345) 23(-1.25,2.345) 24(-1.75,2.345)
  rect 0.61x0.279 smd: 9(2.345,-1.75) 10(2.345,-1.25) 11(2.345,-0.75) 12(2.345,-0.25) 13(2.345,0.25) 14(2.345,0.75) 15(2.345,1.25) 16(2.345,1.75) 25(-2.345,1.75) 26(-2.345,1.25) 27(-2.345,0.75) 28(-2.345,0.25) 29(-2.345,-0.25) 30(-2.345,-0.75) 31(-2.345,-1.25) 32(-2.345,-1.75)
  rect 3.607x3.607 smd: 33(0,0)
A_QFN_40P_16_201X201_PAD_8V
  rect 0.229x0.61 smd: 1(-1.8,-2.345) 2(-1.4,-2.345) 3(-1,-2.345) 4(-0.6,-2.345) 5(-0.2,-2.345) 6(0.2,-2.345) 7(0.6,-2.345) 8(1,-2.345) 9(1.4,-2.345) 10(1.8,-2.345) 21(1.8,2.345) 22(1.4,2.345) 23(1,2.345) 24(0.6,2.345) 25(0.2,2.345) 26(-0.2,2.345) 27(-0.6,2.345) 28(-1,2.345) 29(-1.4,2.345) 30(-1.8,2.345)
  rect 0.61x0.229 smd: 11(2.345,-1.8) 12(2.345,-1.4) 13(2.345,-1) 14(2.345,-0.6) 15(2.345,-0.2) 16(2.345,0.2) 17(2.345,0.6) 18(2.345,1) 19(2.345,1.4) 20(2.345,1.8) 31(-2.345,1.8) 32(-2.345,1.4) 33(-2.345,1) 34(-2.345,0.6) 35(-2.345,0.2) 36(-2.345,-0.2) 37(-2.345,-0.6) 38(-2.345,-1) 39(-2.345,-1.4) 40(-2.345,-1.8)
  rect 3.505x3.505 smd: 41(0,0)
  round 0.61 hole 0.305: 42(-1.448,1.448) 43(-0.94,1.448) 44(0.94,1.448) 45(1.448,1.448) 46(-1.448,-1.448) 47(-0.94,-1.448) 48(0.94,-1.448) 49(1.448,-1.448)
A_USB_24P_12HOLD_RA_FOX
  round 0.762 hole 0.762 unplated: (-3.45,0) (3.45,0)
  oval 0.864x2.057 hole 0.457x1.651: 13(-6.075,-5.8) 14(-6.075,-1.935) 21(6.075,-1.935) 22(6.075,-5.8)
  oval 0.864x1.651 hole 0.457x1.245: 15(-4.475,0.4) 20(4.475,0.4)
  custom 0.076x0.076 smd: 16(-3.2,0.69) 19(3.2,0.69) A1(-2.75,-0.06) A12(2.75,-0.06)
  rect 0.508x0.305 smd: 17(-1,0.69) 18(1,0.69)
  rect 0.305x0.61 smd: A2(-2.25,-0.06) A3(-1.75,-0.06) A4(-1.25,-0.06) A5(-0.75,-0.06) A6(-0.25,-0.06) A7(0.25,-0.06) A8(0.75,-0.06) A9(1.25,-0.06) A10(1.75,-0.06) A11(2.25,-0.06)
  oval 1.295x0.813 hole 0.889x0.406: B1(3.2,-1.135) B12(-3.2,-1.135)
  round 0.699 hole 0.406: B2(2.5,-2.035) B3(1.7,-2.035) B6(0.4,-1.135) B7(-0.4,-1.135) B10(-1.7,-2.035) B11(-2.5,-2.035)
  round 0.66 hole 0.406: B4(1.3,-1.135) B5(0.85,-2.035) B8(-0.85,-2.035) B9(-1.3,-1.135)
A_WTOB_50P_20_4HD_IEX
  rect 0.254x0.889 smd: 1(12.25,2.82) 2(11.75,2.82) 3(11.25,2.82) 4(10.75,2.82) 5(10.25,2.82) 6(9.75,2.82) 7(9.25,2.82) 8(8.75,2.82) 9(8.25,2.82) 10(7.75,2.82) 11(7.25,2.82) 12(6.75,2.82) 13(6.25,2.82) 14(5.75,2.82) 15(5.25,2.82) 16(4.75,2.82) 17(4.25,2.82) 18(3.75,2.82) 19(3.25,2.82) 20(2.75,2.82) 21(2.25,2.82) 22(1.75,2.82) 23(1.25,2.82) 24(0.75,2.82) 25(0.25,2.82) 26(-0.25,2.82) 27(-0.75,2.82) 28(-1.25,2.82) 29(-1.75,2.82) 30(-2.25,2.82) 31(-2.75,2.82) 32(-3.25,2.82) 33(-3.75,2.82) 34(-4.25,2.82) 35(-4.75,2.82) 36(-5.25,2.82) 37(-5.75,2.82) 38(-6.25,2.82) 39(-6.75,2.82) 40(-7.25,2.82) 41(-7.75,2.82) 42(-8.25,2.82) 43(-8.75,2.82) 44(-9.25,2.82) 45(-9.75,2.82) 46(-10.25,2.82) 47(-10.75,2.82) 48(-11.25,2.82) 49(-11.75,2.82) 50(-12.25,2.82)
  rect 0.559x0.889 smd: 51(13.15,2.82) 52(-13.15,2.82)
  rect 1.397x1.905 smd: 53(15.35,0) 54(-15.35,0)
BGA_1356P_1654X945_INTEL
  round 0.356 smd: A3(19.349,-11.314) A70(-19.852,-11.314) B2(19.832,-10.832) B71(-20.314,-10.852) BA1(20.314,10.852) BA71(-20.314,10.852) BB2(19.852,11.314) BB70(-19.852,11.314) C1(20.314,-10.349)
  round 0.33 smd: A4(18.699,-11.314) A69(-19.202,-11.314) AY1(20.314,10.202) AY71(-20.314,10.202) B3(19.197,-10.679) B70(-19.685,-10.685) BA2(19.685,10.685) BA70(-19.685,10.685) BB3(19.202,11.314) BB69(-19.202,11.314) C2(19.679,-10.197) C71(-20.314,-10.202) D1(20.314,-9.699)
  round 0.305 smd: A5(18.048,-11.314) A68(-18.552,-11.314) AA2(19.339,-0.511) AA4(18.363,-0.511) AA63(-15.112,-0.596) AA64(-15.763,-0.596) AA65(-16.413,-0.596) AA66(-17.063,-0.596) AA67(-17.713,-0.596) AA68(-18.364,-0.596) AA69(-19.014,-0.596) AA70(-19.664,-0.596) AA71(-20.314,-0.596) AB4(18.363,0.152) AB6(17.585,-0.133) AB7(16.935,-0.133) AB8(16.285,-0.133) AB9(15.635,-0.133) AB10(14.984,-0.133) AB11(14.334,-0.133) AB12(13.684,-0.133) AB13(13.034,-0.133) AB15(12.188,-0.009) AB16(11.538,-0.009) AB17(10.888,-0.009) AB18(10.237,-0.009) AB19(9.587,-0.009) AB20(8.937,-0.009) AB21(8.287,-0.009) AB62(-14.644,-0.138) AC3(18.689,0.815) AC63(-15.112,0.319) AC64(-15.763,0.319) AC65(-16.413,0.319) AC66(-17.063,0.319) AC67(-17.713,0.319) AC68(-18.364,0.319) AC69(-19.014,0.319) AC70(-19.664,0.319) AC71(-20.314,0.319) AD4(18.363,1.478) AD6(17.585,0.934) AD7(16.935,0.934) AD8(16.285,0.934) AD9(15.635,0.934) AD10(14.984,0.934) AD11(14.334,0.934) AD12(13.684,0.934) AD13(13.034,0.934) AD15(12.188,0.829) AD16(11.538,0.829) AD17(10.888,0.829) AD18(10.237,0.829) AD19(9.587,0.829) AD20(8.937,0.829) AD21(8.287,0.829) AD62(-14.644,0.776) AE62(-14.644,1.69) AE63(-15.112,1.233) AE64(-15.763,1.233) AE65(-16.413,1.233) AE66(-17.063,1.233) AE67(-17.713,1.233) AE68(-18.364,1.233) AE69(-19.014,1.233) AF2(19.339,2.141) AF4(18.363,2.141) AF6(17.585,2.001) AF7(16.935,2.001) AF8(16.285,2.001) AF9(15.635,2.001) AF10(14.984,2.001) AF11(14.334,2.001) AF12(13.684,2.001) AF13(13.034,2.001) AF15(12.188,1.668) AF16(11.538,1.668) AF17(10.888,1.668) AF18(10.237,1.668) AF19(9.587,1.668) AF20(8.937,1.668) AF21(8.287,1.668) AF63(-15.112,2.148) AF64(-15.763,2.148) AF65(-16.413,2.148) AF66(-17.063,2.148) AF67(-17.713,2.148) AF68(-18.364,1.939) AF69(-19.014,1.939) AG4(18.363,2.804) AG15(12.188,2.506) AG16(11.538,2.506) AG17(10.888,2.506) AG18(10.237,2.506) AG19(9.587,2.506) AG20(8.937,2.506) AG21(8.287,2.506) AG62(-14.644,2.605) AG69(-18.689,2.602) AH3(18.689,3.467) AH6(17.585,3.067) AH7(16.935,3.067) AH8(16.285,3.067) AH9(15.635,3.067) AH10(14.984,3.067) AH11(14.334,3.067) AH12(13.684,3.067) AH13(13.034,3.067) AH63(-15.112,3.062) AH64(-15.763,3.062) AH65(-16.413,3.062) AH66(-17.063,3.062) AH67(-17.713,3.062) AJ4(18.363,4.13) AJ15(12.188,3.344) AJ16(11.538,3.344) AJ17(10.888,3.344) AJ18(10.237,3.344) AJ19(9.587,3.344) AJ20(8.937,3.344) AJ21(8.287,3.344) AJ62(-14.644,3.519) AK6(17.585,4.007) AK7(16.935,4.007) AK8(16.285,4.007) AK9(15.635,4.007) AK10(14.984,4.007) AK11(14.334,4.007) AK12(13.684,4.007) AK13(13.034,4.007) AK15(12.188,4.182) AK16(11.538,4.182) AK17(10.888,4.182) AK18(10.237,4.182) AK19(9.587,4.182) AK20(8.937,4.182) AK21(8.287,4.182) AK22(7.596,4.009) AK23(6.681,4.009) AK25(5.767,4.009) AK27(4.852,4.009) AK28(3.938,4.009) AK30(3.024,4.009) AK32(2.109,4.009) AK33(1.195,4.009) AK35(0.28,4.009) AK37(-0.634,4.009) AK38(-1.548,4.009) AK40(-2.463,4.009) AK42(-3.377,4.009) AK43(-4.292,4.009) AK45(-5.206,4.009) AK46(-6.12,4.009) AK48(-7.035,4.009) AK50(-7.949,4.009) AK52(-8.864,4.009) AK53(-9.778,4.009) AK55(-10.692,4.009) AK56(-11.607,4.009) AK58(-12.521,4.009) AK60(-13.436,4.009) AK62(-14.46,4.144) AK63(-15.112,3.976) AK64(-15.763,3.976) AK65(-16.413,3.976) AK66(-17.063,3.976) AK67(-17.713,3.976) AK68(-18.364,3.829) AK69(-19.339,3.829) AL2(19.339,4.793) AL4(18.363,4.793) AL23(7.138,4.474) AL25(6.224,4.474) AL27(5.31,4.474) AL28(4.395,4.474) AL30(3.481,4.474) AL32(2.566,4.474) AL33(1.652,4.474) AL35(0.738,4.474) AL37(-0.177,4.474) AL38(-1.091,4.474) AL40(-2.006,4.474) AL42(-2.92,4.474) AL43(-3.834,4.474) AL45(-4.749,4.474) AL46(-5.663,4.474) AL48(-6.578,4.474) AL50(-7.492,4.474) AL52(-8.406,4.474) AL53(-9.321,4.474) AL55(-10.235,4.474) AL56(-11.15,4.474) AL58(-12.064,4.474) AL60(-12.978,4.474) AL61(-13.893,4.474) AL63(-15.112,4.845) AL64(-15.763,4.845) AL65(-16.413,4.845) AL66(-17.063,4.845) AM4(18.363,5.456) AM5(17.654,4.946) AM7(16.74,4.946) AM8(15.825,4.946) AM10(14.911,4.946) AM11(13.996,4.946) AM13(13.082,4.946) AM15(12.168,4.946) AM16(11.253,4.946) AM18(10.339,4.946) AM20(9.424,4.946) AM21(8.51,4.946) AM22(7.596,4.946) AM23(6.681,4.946) AM25(5.767,4.946) AM27(4.852,4.946) AM28(3.938,4.946) AM30(3.024,4.946) AM32(2.109,4.946) AM33(1.195,4.946) AM35(0.28,4.946) AM37(-0.634,4.946) AM38(-1.548,4.946) AM40(-2.463,4.946) AM42(-3.377,4.946) AM43(-4.292,4.946) AM45(-5.206,4.946) AM46(-6.12,4.946) AM48(-7.035,4.946) AM50(-7.949,4.946) AM52(-8.864,4.946) AM53(-9.778,4.946) AM55(-10.692,4.946) AM56(-11.607,4.946) AM58(-12.521,4.946) AM60(-13.436,4.946) AM61(-14.35,4.946) AM68(-18.039,5.056) AM69(-18.689,5.056) AN3(18.689,6.119) AN5(17.654,5.597) AN7(16.74,5.597) AN8(15.825,5.597) AN10(14.911,5.597) AN11(13.996,5.597) AN13(13.082,5.597) AN15(12.168,5.597) AN16(11.253,5.597) AN18(10.339,5.597) AN20(9.424,5.597) AN21(8.51,5.597) AN22(7.596,5.597) AN23(6.681,5.597) AN25(5.767,5.597) AN27(4.852,5.597) AN28(3.938,5.597) AN30(3.024,5.597) AN32(2.109,5.597) AN33(1.195,5.597) AN35(0.28,5.597) AN37(-0.634,5.597) AN38(-1.548,5.597) AN40(-2.463,5.597) AN42(-3.377,5.597) AN43(-4.292,5.597) AN45(-5.206,5.597) AN46(-6.12,5.597) AN48(-7.035,5.597) AN50(-7.949,5.597) AN52(-8.864,5.597) AN53(-9.778,5.597) AN55(-10.692,5.597) AN56(-11.607,5.597) AN58(-12.521,5.597) AN60(-13.436,5.597) AN61(-14.35,5.597) AN63(-15.264,5.597) AN65(-16.179,5.597) AN66(-17.093,5.597) AN68(-18.364,5.719) AN69(-19.014,5.719) AP4(18.363,6.782) AP5(17.654,6.247) AP7(16.74,6.247) AP8(15.825,6.247) AP10(14.911,6.247) AP11(13.996,6.247) AP13(13.082,6.247) AP15(12.168,6.247) AP16(11.253,6.247) AP18(10.339,6.247) AP20(9.424,6.247) AP21(8.51,6.247) AP22(7.596,6.247) AP23(6.681,6.247) AP25(5.767,6.247) AP27(4.852,6.247) AP28(3.938,6.247) AP30(3.024,6.247) AP32(2.109,6.247) AP33(1.195,6.247) AP35(0.28,6.247) AP37(-0.634,6.247) AP38(-1.548,6.247) AP40(-2.463,6.247) AP42(-3.377,6.247) AP43(-4.292,6.247) AP45(-5.206,6.247) AP46(-6.12,6.247) AP48(-7.035,6.247) AP50(-7.949,6.247) AP52(-8.864,6.247) AP53(-9.778,6.247) AP55(-10.692,6.247) AP56(-11.607,6.247) AP58(-12.521,6.247) AP60(-13.436,6.247) AP61(-14.35,6.247) AP63(-15.264,6.247) AP65(-16.179,6.247) AP66(-17.093,6.247) AP68(-18.039,6.332) AP70(-19.258,6.332) AR5(17.654,6.897) AR7(16.74,6.897) AR8(15.825,6.897) AR10(14.911,6.897) AR11(13.996,6.897) AR13(13.082,6.897) AR15(12.168,6.897) AR16(11.253,6.897) AR18(10.339,6.897) AR20(9.424,6.897) AR21(8.51,6.897) AR22(7.596,6.897) AR23(6.681,6.897) AR25(5.767,6.897) AR27(4.852,6.897) AR28(3.938,6.897) AR30(3.024,6.897) AR32(2.109,6.897) AR33(1.195,6.897) AR35(0.28,6.897) AR37(-0.634,6.897) AR38(-1.548,6.897) AR40(-2.463,6.897) AR42(-3.377,6.897) AR43(-4.292,6.897) AR45(-5.206,6.897) AR46(-6.12,6.897) AR48(-7.035,6.897) AR50(-7.949,6.897) AR52(-8.864,6.897) AR53(-9.778,6.897) AR55(-10.692,6.897) AR56(-11.607,6.897) AR58(-12.521,6.897) AR60(-13.436,6.897) AR61(-14.35,6.897) AR63(-15.264,6.897) AR65(-16.179,6.897) AR66(-17.093,6.897) AR68(-18.364,6.945) AR69(-19.014,6.945) AT2(19.339,7.445) AT4(18.363,7.445) AT5(17.654,7.547) AT7(16.74,7.547) AT8(15.825,7.547) AT10(14.911,7.547) AT11(13.996,7.547) AT13(13.082,7.547) AT15(12.168,7.547) AT16(11.253,7.547) AT18(10.339,7.547) AT20(9.424,7.547) AT21(8.51,7.547) AT22(7.596,7.547) AT23(6.681,7.547) AT25(5.767,7.547) AT27(4.852,7.547) AT28(3.938,7.547) AT30(3.024,7.547) AT32(2.109,7.547) AT33(1.195,7.547) AT35(0.28,7.547) AT37(-0.634,7.547) AT38(-1.548,7.547) AT40(-2.463,7.547) AT42(-3.377,7.547) AT43(-4.292,7.547) AT45(-5.206,7.547) AT46(-6.12,7.547) AT48(-7.035,7.547) AT50(-7.949,7.547) AT52(-8.864,7.547) AT53(-9.778,7.547) AT55(-10.692,7.547) AT56(-11.607,7.547) AT58(-12.521,7.547) AT60(-13.436,7.547) AT61(-14.35,7.547) AT63(-15.264,7.547) AT65(-16.179,7.547) AT66(-17.093,7.547) AT68(-18.039,7.509) AT69(-18.689,7.509) AU4(18.363,8.108) AU5(17.654,8.198) AU7(16.74,8.198) AU8(15.825,8.198) AU10(14.911,8.198) AU11(13.996,8.198) AU13(13.082,8.198) AU15(12.168,8.198) AU16(11.253,8.198) AU18(10.339,8.198) AU20(9.424,8.198) AU21(8.51,8.198) AU22(7.596,8.198) AU23(6.681,8.198) AU25(5.767,8.198) AU27(4.852,8.198) AU28(3.938,8.198) AU30(3.024,8.198) AU32(2.109,8.198) AU33(1.195,8.198) AU35(0.28,8.198) AU37(-0.634,8.198) AU38(-1.548,8.198) AU40(-2.463,8.198) AU42(-3.377,8.198) AU43(-4.292,8.198) AU45(-5.206,8.198) AU46(-6.12,8.198) AU48(-7.035,8.198) AU50(-7.949,8.198) AU52(-8.864,8.198) AU53(-9.778,8.198) AU55(-10.692,8.198) AU56(-11.607,8.198) AU58(-12.521,8.198) AU60(-13.436,8.198) AU61(-14.35,8.198) AU63(-15.264,8.198) AU65(-16.179,8.198) AU66(-17.093,8.198) AV3(18.689,8.799) AV68(-18.029,8.711) AV69(-19.014,8.901) AV70(-19.664,8.901) AW1(20.314,9.551) AW5(17.781,8.911) AW6(17.13,9.038) AW7(16.564,9.363) AW8(15.986,9.038) AW9(15.416,9.363) AW10(14.753,9.038) AW11(14.143,9.363) AW12(13.565,9.038) AW13(12.995,9.363) AW14(12.332,9.038) AW15(11.723,9.363) AW16(11.145,9.038) AW17(10.575,9.363) AW18(9.912,9.038) AW20(9.302,9.363) AW21(8.724,9.038) AW22(8.154,9.363) AW23(7.466,9.038) AW25(6.828,9.363) AW26(6.264,9.038) AW27(5.601,9.363) AW28(4.988,9.038) AW29(4.374,9.363) AW30(3.711,9.038) AW31(3.148,9.363) AW32(2.485,9.038) AW33(1.847,9.363) AW34(1.283,9.038) AW35(0.62,9.363) AW36(0.007,9.038) AW37(-0.607,9.363) AW38(-1.269,9.038) AW39(-1.833,9.363) AW41(-2.471,9.038) AW42(-3.108,9.363) AW43(-3.672,9.038) AW44(-4.335,9.363) AW45(-4.949,9.038) AW46(-5.562,9.363) AW47(-6.163,9.038) AW48(-6.727,9.363) AW49(-7.355,9.038) AW50(-7.984,9.363) AW51(-8.548,9.038) AW52(-9.149,9.363) AW53(-9.762,9.038) AW54(-10.375,9.363) AW55(-11.038,9.038) AW56(-11.602,9.363) AW57(-12.24,9.038) AW59(-12.877,9.363) AW60(-13.441,9.038) AW61(-14.104,9.363) AW62(-14.718,9.038) AW63(-15.331,9.363) AW64(-15.994,9.038) AW65(-16.558,9.363) AW66(-17.093,8.9) AW67(-18.018,9.371) AW68(-18.622,9.622) AW69(-19.267,9.536) AW70(-19.685,10.035) AW71(-20.314,9.551) AY2(19.685,10.034) AY3(19.028,10.028) AY4(18.274,10.043) AY5(17.665,9.689) AY8(15.986,9.689) AY12(13.565,9.689) AY16(11.145,9.689) AY21(8.724,9.689) AY26(6.264,9.689) AY27(5.601,10.014) AY29(4.374,10.014) AY30(3.711,9.689) AY34(1.283,9.689) AY35(0.62,10.014) AY37(-0.607,10.014) AY38(-1.269,9.689) AY43(-3.672,9.689) AY44(-4.335,10.014) AY46(-5.562,10.014) AY47(-6.163,9.689) AY51(-8.548,9.689) AY52(-9.149,10.014) AY54(-10.375,10.014) AY55(-11.038,9.689) AY60(-13.441,9.689) AY61(-14.104,10.014) AY63(-15.331,10.014) AY64(-15.994,9.689) AY66(-17.221,9.689) AY68(-18.535,10.267) B5(18.048,-10.664) B6(17.467,-10.339) B10(14.989,-10.339) B14(12.511,-10.339) B18(10.033,-10.339) B22(7.555,-10.339) B26(5.077,-10.339) B30(2.599,-10.339) B34(0.121,-10.339) B39(-2.357,-10.339) B44(-4.835,-10.339) B48(-7.313,-10.339) B53(-9.791,-10.339) B58(-12.269,-10.339) B62(-14.747,-10.339) B66(-17.226,-10.339) B69(-19.035,-10.685) BA3(19.035,10.685) BA5(17.715,10.626) BA8(15.986,10.339) BA12(13.565,10.339) BA16(11.145,10.339) BA21(8.724,10.339) BA23(7.466,10.258) BA28(4.988,10.258) BA32(2.485,10.258) BA36(0.007,10.258) BA41(-2.471,10.258) BA45(-4.949,10.258) BA49(-7.355,10.339) BA53(-9.762,10.258) BA57(-12.24,10.258) BA62(-14.718,10.258) BA68(-19.035,10.685) BB4(18.551,11.314) BB68(-18.552,11.314) C4(18.615,-10.336) C5(18.048,-10.014) C7(16.791,-10.014) C8(16.228,-10.339) C9(15.664,-10.014) C11(14.313,-10.014) C12(13.75,-10.339) C13(13.186,-10.014) C15(11.835,-10.014) C16(11.272,-10.339) C17(10.708,-10.014) C19(9.357,-10.014) C20(8.794,-10.339) C21(8.23,-10.014) C23(6.879,-10.014) C24(6.316,-10.339) C25(5.752,-10.014) C27(4.401,-10.014) C28(3.838,-10.339) C29(3.274,-10.014) C31(1.923,-10.014) C32(1.36,-10.339) C33(0.796,-10.014) C36(-0.555,-10.014) C37(-1.118,-10.339) C38(-1.682,-10.014) C40(-3.033,-10.014) C41(-3.596,-10.339) C42(-4.16,-10.014) C45(-5.511,-10.014) C46(-6.074,-10.339) C47(-6.638,-10.014) C50(-7.989,-10.014) C51(-8.552,-10.339) C52(-9.116,-10.014) C54(-10.467,-10.014) C55(-11.03,-10.339) C56(-11.594,-10.014) C59(-12.945,-10.014) C60(-13.508,-10.339) C61(-14.072,-10.014) C63(-15.423,-10.014) C64(-15.987,-10.339) C65(-16.55,-10.014) C67(-18.485,-10.299) C68(-18.622,-9.622) C70(-19.685,-10.034) D3(19.339,-9.608) D4(18.691,-9.669) D5(18.09,-9.363) D6(17.441,-9.323) D7(16.791,-9.363) D8(16.228,-9.689) D9(15.664,-9.363) D10(14.989,-9.323) D11(14.313,-9.363) D12(13.75,-9.689) D13(13.186,-9.363) D14(12.511,-9.323) D15(11.835,-9.363) D16(11.272,-9.689) D17(10.708,-9.363) D18(10.033,-9.323) D19(9.357,-9.363) D20(8.794,-9.689) D21(8.23,-9.363) D22(7.555,-9.323) D23(6.879,-9.363) D24(6.316,-9.689) D25(5.752,-9.363) D26(5.077,-9.323) D27(4.401,-9.363) D28(3.838,-9.689) D29(3.274,-9.363) D30(2.599,-9.323) D31(1.923,-9.363) D32(1.36,-9.689) D33(0.796,-9.363) D34(0.121,-9.323) D36(-0.555,-9.363) D37(-1.118,-9.689) D38(-1.682,-9.363) D39(-2.357,-9.323) D40(-3.033,-9.363) D41(-3.596,-9.689) D42(-4.16,-9.363) D44(-4.835,-9.323) D45(-5.511,-9.363) D46(-6.074,-9.689) D47(-6.638,-9.363) D48(-7.313,-9.323) D50(-7.989,-9.363) D51(-8.552,-9.689) D52(-9.116,-9.363) D53(-9.791,-9.323) D54(-10.467,-9.363) D55(-11.03,-9.689) D56(-11.594,-9.363) D58(-12.269,-9.323) D59(-12.945,-9.363) D60(-13.508,-9.689) D61(-14.072,-9.363) D62(-14.747,-9.323) D63(-15.423,-9.363) D64(-15.987,-9.689) D65(-16.55,-9.363) D66(-17.226,-9.323) D67(-17.899,-10.014) D68(-19.267,-9.535) D69(-18.562,-8.971) D71(-20.314,-9.551) E1(20.314,-9.04) E2(19.664,-9.04) E3(19.014,-9.04) E5(17.654,-8.591) E6(16.74,-8.591) E8(15.825,-8.591) E10(14.911,-8.591) E11(13.996,-8.591) E13(13.082,-8.591) E15(12.168,-8.591) E16(11.253,-8.591) E18(10.339,-8.591) E20(9.424,-8.591) E21(8.51,-8.591) E22(7.596,-8.591) E23(6.681,-8.591) E25(5.767,-8.591) E27(4.852,-8.591) E28(3.938,-8.591) E30(3.024,-8.591) E32(2.109,-8.591) E33(1.195,-8.591) E35(0.28,-8.591) E37(-0.634,-8.591) E38(-1.548,-8.591) E40(-2.463,-8.591) E42(-3.377,-8.591) E43(-4.292,-8.591) E45(-5.206,-8.591) E46(-6.12,-8.591) E48(-7.035,-8.591) E50(-7.949,-8.591) E52(-8.864,-8.591) E53(-9.778,-8.591) E55(-10.692,-8.591) E56(-11.607,-8.591) E58(-12.521,-8.591) E60(-13.436,-8.591) E61(-14.35,-8.591) E63(-15.315,-8.655) E65(-16.331,-8.655) E66(-17.347,-8.655) E68(-17.899,-9.363) F2(19.339,-8.466) F4(18.363,-8.466) F5(17.654,-7.941) F6(16.74,-7.941) F8(15.825,-7.941) F10(14.911,-7.941) F11(13.996,-7.941) F13(13.082,-7.941) F15(12.168,-7.941) F16(11.253,-7.941) F18(10.339,-7.941) F20(9.424,-7.941) F21(8.51,-7.941) F22(7.596,-7.941) F23(6.681,-7.941) F25(5.767,-7.941) F27(4.852,-7.941) F28(3.938,-7.941) F30(3.024,-7.941) F32(2.109,-7.941) F33(1.195,-7.941) F35(0.28,-7.941) F37(-0.634,-7.941) F38(-1.548,-7.941) F40(-2.463,-7.941) F42(-3.377,-7.941) F43(-4.292,-7.941) F45(-5.206,-7.941) F46(-6.12,-7.941) F48(-7.035,-7.941) F50(-7.949,-7.941) F52(-8.864,-7.941) F53(-9.778,-7.941) F55(-10.692,-7.941) F56(-11.607,-7.941) F58(-12.521,-7.941) F60(-13.436,-7.941) F61(-14.35,-7.941) F63(-15.315,-8.005) F65(-16.331,-8.005) F66(-17.347,-8.005) F68(-18.562,-8.32) G4(18.363,-7.803) G5(17.654,-7.291) G6(16.74,-7.291) G8(15.825,-7.291) G10(14.911,-7.291) G11(13.996,-7.291) G13(13.082,-7.291) G15(12.168,-7.291) G16(11.253,-7.291) G18(10.339,-7.291) G20(9.424,-7.291) G21(8.51,-7.291) G22(7.596,-7.291) G23(6.681,-7.291) G25(5.767,-7.291) G27(4.852,-7.291) G28(3.938,-7.291) G30(3.024,-7.291) G32(2.109,-7.291) G33(1.195,-7.291) G35(0.28,-7.291) G37(-0.634,-7.291) G38(-1.548,-7.291) G40(-2.463,-7.291) G42(-3.377,-7.291) G43(-4.292,-7.291) G45(-5.206,-7.291) G46(-6.12,-7.291) G48(-7.035,-7.291) G50(-7.949,-7.291) G52(-8.864,-7.291) G53(-9.778,-7.291) G55(-10.692,-7.291) G56(-11.607,-7.291) G58(-12.521,-7.291) G60(-13.436,-7.291) G61(-14.35,-7.291) G63(-15.315,-7.354) G65(-16.331,-7.354) G66(-17.347,-7.354) G68(-18.364,-7.66) G69(-19.014,-7.66) H3(18.689,-7.14) H5(17.654,-6.641) H6(16.74,-6.641) H8(15.825,-6.641) H10(14.911,-6.641) H11(13.996,-6.641) H13(13.082,-6.641) H15(12.168,-6.641) H16(11.253,-6.641) H18(10.339,-6.641) H20(9.424,-6.641) H21(8.51,-6.641) H63(-15.315,-6.704) H65(-16.331,-6.704) H66(-17.347,-6.704) H69(-18.689,-7.096) J4(18.363,-6.477) J5(17.654,-5.99) J6(16.74,-5.99) J8(15.825,-5.99) J10(14.911,-5.99) J11(13.996,-5.99) J13(13.082,-5.99) J22(7.138,-6.827) J23(6.224,-6.827) J25(5.31,-6.827) J27(4.395,-6.827) J28(3.481,-6.827) J30(2.566,-6.827) J32(1.652,-6.827) J33(0.738,-6.827) J35(-0.177,-6.827) J37(-1.091,-6.827) J38(-2.006,-6.827) J40(-2.92,-6.827) J42(-3.834,-6.827) J43(-4.749,-6.827) J45(-5.663,-6.827) J46(-6.578,-6.827) J48(-7.492,-6.827) J50(-8.406,-6.827) J52(-9.321,-6.827) J53(-10.235,-6.827) J55(-11.15,-6.827) J56(-12.064,-6.827) J58(-12.978,-6.827) J60(-13.893,-6.827) J68(-18.362,-6.52) K15(12.188,-5.876) K16(11.538,-5.876) K17(10.888,-5.876) K18(10.237,-5.876) K19(9.587,-5.876) K20(8.937,-5.876) K21(8.287,-5.876) K22(7.596,-6.362) K23(6.681,-6.362) K25(5.767,-6.362) K27(4.852,-6.362) K28(3.938,-6.362) K30(3.024,-6.362) K32(2.109,-6.362) K33(1.195,-6.362) K35(0.28,-6.362) K37(-0.634,-6.362) K38(-1.548,-6.362) K40(-2.463,-6.362) K42(-3.377,-6.362) K43(-4.292,-6.362) K45(-5.206,-6.362) K46(-6.12,-6.362) K48(-7.035,-6.362) K50(-7.949,-6.362) K52(-8.864,-6.362) K53(-9.778,-6.362) K55(-10.692,-6.362) K56(-11.607,-6.362) K58(-12.521,-6.362) K60(-13.436,-6.362) K61(-14.35,-6.362) K63(-15.133,-6.054) K64(-15.783,-6.054) K65(-16.433,-6.054) K66(-17.084,-6.054) K67(-17.734,-6.054) K68(-18.352,-5.846) K70(-19.339,-5.744) L2(19.339,-5.814) L4(18.363,-5.814) L6(17.585,-5.34) L7(16.935,-5.34) L8(16.285,-5.34) L9(15.635,-5.34) L10(14.984,-5.34) L11(14.334,-5.34) L12(13.684,-5.34) L13(13.034,-5.34) L15(12.188,-5.038) L16(11.538,-5.038) L17(10.888,-5.038) L18(10.237,-5.038) L19(9.587,-5.038) L20(8.937,-5.038) L21(8.287,-5.038) L62(-14.644,-5.625) L63(-15.112,-5.168) L64(-15.763,-5.168) L65(-16.413,-5.168) L66(-17.063,-5.168) L67(-17.713,-5.168) L68(-18.364,-5.168) L69(-19.014,-5.168) L70(-19.664,-5.168) L71(-20.314,-5.168) M4(18.363,-5.151) M62(-14.644,-4.71) N3(18.689,-4.488) N6(17.585,-4.4) N7(16.935,-4.4) N8(16.285,-4.4) N9(15.635,-4.4) N10(14.984,-4.4) N11(14.334,-4.4) N12(13.684,-4.4) N13(13.034,-4.4) N15(12.188,-4.2) N16(11.538,-4.2) N17(10.888,-4.2) N18(10.237,-4.2) N19(9.587,-4.2) N20(8.937,-4.2) N21(8.287,-4.2) N63(-15.112,-4.253) N64(-15.763,-4.253) N65(-16.413,-4.253) N66(-17.063,-4.253) N67(-17.713,-4.253) N68(-18.364,-4.253) N69(-19.014,-4.253) N70(-19.664,-4.253) N71(-20.314,-4.253) P4(18.363,-3.825) P15(12.188,-3.362) P16(11.538,-3.362) P17(10.888,-3.362) P18(10.237,-3.362) P19(9.587,-3.362) P20(8.937,-3.362) P21(8.287,-3.362) P62(-14.644,-3.796) R6(17.585,-3.333) R7(16.935,-3.333) R8(16.285,-3.333) R9(15.635,-3.333) R10(14.984,-3.333) R11(14.334,-3.333) R12(13.684,-3.333) R13(13.034,-3.333) R63(-15.112,-3.339) R64(-15.763,-3.339) R65(-16.413,-3.339) R66(-17.063,-3.339) R67(-17.713,-3.339) R68(-18.364,-3.339) R69(-19.014,-3.339) R70(-19.664,-3.339) R71(-20.314,-3.339) T2(19.339,-3.162) T4(18.363,-3.162) T15(12.188,-2.523) T16(11.538,-2.523) T17(10.888,-2.523) T18(10.237,-2.523) T19(9.587,-2.523) T20(8.937,-2.523) T21(8.287,-2.523) T62(-14.644,-2.882) U4(18.363,-2.499) U6(17.585,-2.267) U7(16.935,-2.267) U8(16.285,-2.267) U9(15.635,-2.267) U10(14.984,-2.267) U11(14.334,-2.267) U12(13.684,-2.267) U13(13.034,-2.267) U63(-15.112,-2.424) U64(-15.763,-2.424) U65(-16.413,-2.424) U66(-17.063,-2.424) U67(-17.713,-2.424) U68(-18.364,-2.424) U69(-19.014,-2.424) U70(-19.664,-2.424) U71(-20.314,-2.424) V3(18.689,-1.836) V15(12.188,-1.685) V16(11.538,-1.685) V17(10.888,-1.685) V18(10.237,-1.685) V19(9.587,-1.685) V20(8.937,-1.685) V21(8.287,-1.685) V62(-14.644,-1.967) W4(18.363,-1.173) W6(17.585,-1.2) W7(16.935,-1.2) W8(16.285,-1.2) W9(15.635,-1.2) W10(14.984,-1.2) W11(14.334,-1.2) W12(13.684,-1.2) W13(13.034,-1.2) W63(-15.112,-1.51) W64(-15.763,-1.51) W65(-16.413,-1.51) W66(-17.063,-1.51) W67(-17.713,-1.51) W68(-18.364,-1.51) W69(-19.014,-1.51) W70(-19.664,-1.51) W71(-20.314,-1.51) Y15(12.188,-0.847) Y16(11.538,-0.847) Y17(10.888,-0.847) Y18(10.237,-0.847) Y19(9.587,-0.847) Y20(8.937,-0.847) Y21(8.287,-0.847) Y62(-14.644,-1.053)
  oval 0.254x0.343 smd: A6(17.467,-10.989) A7(16.791,-11.314) A9(15.664,-11.314) A10(14.989,-10.989) A11(14.313,-11.314) A13(13.186,-11.314) A14(12.511,-10.989) A15(11.835,-11.314) A17(10.708,-11.314) A18(10.033,-10.989) A19(9.357,-11.314) A21(8.23,-11.314) A22(7.555,-10.989) A23(6.879,-11.314) A25(5.752,-11.314) A26(5.077,-10.989) A27(4.401,-11.314) A29(3.274,-11.314) A30(2.599,-10.989) A31(1.923,-11.314) A33(0.796,-11.314) A34(0.121,-10.989) A36(-0.555,-11.314) A38(-1.682,-11.314) A39(-2.357,-10.989) A40(-3.033,-11.314) A42(-4.16,-11.314) A44(-4.835,-10.989) A45(-5.511,-11.314) A47(-6.638,-11.314) A48(-7.313,-10.989) A50(-7.989,-11.314) A52(-9.116,-11.314) A53(-9.791,-10.989) A54(-10.467,-11.314) A56(-11.594,-11.314) A58(-12.269,-10.989) A59(-12.945,-11.314) A61(-14.072,-11.314) A62(-14.747,-10.989) A63(-15.423,-11.314) A65(-16.55,-11.314) A66(-17.226,-10.989) A67(-17.901,-11.314) AY7(16.551,10.014) AY9(15.416,10.014) AY11(14.131,10.014) AY13(12.995,10.014) AY15(11.71,10.014) AY17(10.575,10.014) AY20(9.289,10.014) AY22(8.154,10.014) AY25(6.828,10.014) AY31(3.148,10.014) AY33(1.847,10.014) AY39(-1.833,10.014) AY42(-3.108,10.014) AY48(-6.789,10.014) AY50(-7.922,10.014) AY56(-11.602,10.014) AY59(-12.877,10.014) AY65(-16.558,10.014) AY67(-17.901,10.014) B7(16.791,-10.664) B9(15.664,-10.664) B11(14.313,-10.664) B13(13.186,-10.664) B15(11.835,-10.664) B17(10.708,-10.664) B19(9.357,-10.664) B21(8.23,-10.664) B23(6.879,-10.664) B25(5.752,-10.664) B27(4.401,-10.664) B29(3.274,-10.664) B31(1.923,-10.664) B33(0.796,-10.664) B36(-0.555,-10.664) B38(-1.682,-10.664) B40(-3.033,-10.664) B42(-4.16,-10.664) B45(-5.511,-10.664) B47(-6.638,-10.664) B50(-7.989,-10.664) B52(-9.116,-10.664) B54(-10.467,-10.664) B56(-11.594,-10.664) B59(-12.945,-10.664) B61(-14.072,-10.664) B63(-15.423,-10.664) B65(-16.55,-10.664) B67(-17.901,-10.664) BA4(18.366,10.689) BA6(17.173,10.258) BA7(16.61,10.664) BA9(15.416,10.664) BA10(14.753,10.258) BA11(14.189,10.664) BA13(12.995,10.664) BA14(12.332,10.258) BA15(11.768,10.664) BA17(10.575,10.664) BA18(9.912,10.258) BA20(9.348,10.664) BA22(8.154,10.664) BA25(6.828,10.664) BA26(6.165,10.339) BA27(5.502,10.664) BA29(4.473,10.664) BA30(3.811,10.339) BA31(3.148,10.664) BA33(1.847,10.664) BA34(1.184,10.339) BA35(0.521,10.664) BA37(-0.507,10.664) BA38(-1.17,10.339) BA39(-1.833,10.664) BA42(-3.108,10.664) BA43(-3.771,10.339) BA44(-4.434,10.664) BA46(-5.463,10.664) BA47(-6.126,10.339) BA48(-6.789,10.664) BA50(-7.922,10.664) BA51(-8.585,10.339) BA52(-9.248,10.664) BA54(-10.276,10.664) BA55(-10.939,10.339) BA56(-11.602,10.664) BA59(-12.877,10.664) BA60(-13.54,10.339) BA61(-14.203,10.664) BA63(-15.232,10.664) BA64(-15.895,10.339) BA65(-16.558,10.664) BA66(-17.221,10.339) BA67(-17.901,10.664) BB5(17.786,11.314) BB6(17.173,10.989) BB7(16.61,11.314) BB9(15.416,11.314) BB10(14.753,10.989) BB11(14.189,11.314) BB13(12.995,11.314) BB14(12.332,10.989) BB15(11.768,11.314) BB17(10.575,11.314) BB18(9.912,10.989) BB20(9.348,11.314) BB22(8.154,11.314) BB23(7.466,10.908) BB25(6.828,11.314) BB26(6.165,10.989) BB27(5.502,11.314) BB29(4.473,11.314) BB30(3.811,10.989) BB31(3.148,11.314) BB32(2.485,10.908) BB33(1.847,11.314) BB34(1.184,10.989) BB35(0.521,11.314) BB37(-0.507,11.314) BB38(-1.17,10.989) BB39(-1.833,11.314) BB41(-2.471,10.908) BB42(-3.108,11.314) BB43(-3.771,10.989) BB44(-4.434,11.314) BB46(-5.463,11.314) BB47(-6.126,10.989) BB48(-6.789,11.314) BB50(-7.922,11.314) BB51(-8.585,10.989) BB52(-9.248,11.314) BB54(-10.276,11.314) BB55(-10.939,10.989) BB56(-11.602,11.314) BB57(-12.24,10.908) BB59(-12.877,11.314) BB60(-13.54,10.989) BB61(-14.203,11.314) BB63(-15.232,11.314) BB64(-15.895,10.989) BB65(-16.558,11.314) BB66(-17.221,10.989) BB67(-17.901,11.314)
  oval 0.343x0.254 smd: AA1(19.989,-0.511) AB1(20.314,0.152) AB2(19.664,0.152) AB3(19.014,0.152) AC1(19.989,0.815) AC2(19.339,0.815) AD1(20.314,1.478) AD2(19.664,1.478) AD3(19.014,1.478) AF1(19.989,2.141) AF70(-19.664,1.84) AF71(-20.314,1.84) AG1(20.314,2.804) AG2(19.664,2.804) AG3(19.014,2.804) AG70(-19.339,2.503) AG71(-19.989,2.503) AH1(19.989,3.467) AH2(19.339,3.467) AH68(-18.364,3.166) AH69(-19.014,3.166) AH70(-19.664,3.166) AH71(-20.314,3.166) AJ1(20.314,4.13) AJ2(19.664,4.13) AJ3(19.014,4.13) AK70(-19.989,3.829) AL1(19.989,4.793) AL68(-18.364,4.492) AL69(-19.014,4.492) AL70(-19.664,4.492) AL71(-20.314,4.492) AM1(20.314,5.456) AM2(19.664,5.456) AM3(19.014,5.456) AM70(-19.339,5.155) AM71(-19.989,5.155) AN1(19.989,6.119) AN2(19.339,6.119) AN70(-19.664,5.818) AN71(-20.314,5.818) AP1(20.314,6.782) AP2(19.664,6.782) AP3(19.014,6.782) AR70(-19.664,6.846) AR71(-20.314,6.846) AT1(19.989,7.445) AT70(-19.339,7.509) AT71(-19.989,7.509) AU1(20.314,8.108) AU2(19.664,8.108) AU3(19.014,8.108) AU68(-18.364,8.147) AU69(-19.014,8.172) AU70(-19.664,8.172) AU71(-20.314,8.172) AV1(20.314,8.828) AV2(19.364,8.799) AV71(-20.314,8.901) AW2(19.689,9.362) AW3(19.039,9.362) E70(-19.664,-9.009) E71(-20.314,-8.901) F1(19.989,-8.466) F70(-19.212,-8.32) F71(-19.862,-8.384) G1(20.314,-7.803) G2(19.664,-7.803) G3(19.014,-7.803) G70(-19.664,-7.759) G71(-20.314,-7.759) H1(19.989,-7.14) H2(19.339,-7.14) H70(-19.339,-7.096) H71(-19.989,-7.096) J1(20.314,-6.477) J2(19.664,-6.477) J3(19.014,-6.477) J69(-19.014,-6.433) J70(-19.664,-6.433) J71(-20.314,-6.433) K71(-19.989,-5.744) L1(19.989,-5.814) M1(20.314,-5.151) M2(19.664,-5.151) M3(19.014,-5.151) N1(19.989,-4.488) N2(19.339,-4.488) P1(20.314,-3.825) P2(19.664,-3.825) P3(19.014,-3.825) T1(19.989,-3.162) U1(20.314,-2.499) U2(19.664,-2.499) U3(19.014,-2.499) V1(19.989,-1.836) V2(19.339,-1.836) W1(20.314,-1.173) W2(19.664,-1.173) W3(19.014,-1.173)
