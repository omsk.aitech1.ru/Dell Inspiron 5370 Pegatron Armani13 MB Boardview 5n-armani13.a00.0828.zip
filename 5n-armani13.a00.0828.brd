# Allegro board 5n-armani13.a00.0828.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
CHOKE_4P_49X39_MURA
  rect 0.965x0.305 smd: 1(-0.75,0.275) 2(0.75,0.275) 3(0.75,-0.275) 4(-0.75,-0.275)
HOLE_O118X98DO118X98N
  oval 2.997x2.489 hole 2.997x2.489 unplated: (0,0)
MX_TPC26T_S4_68
  round 0.66 smd: 1(0,0)
NB_H_C315D169_P2_S
  round 4.801 hole 4.293: 1(0,0)
NB_H_CT236CB173D157_P2_S
  round 4.496 hole 3.988: 1(0,0)
NB_H_S209D98_P2_S
  round 2.997 hole 2.489: 1(0,0)
NB_H_S232D87_P2_S
  round 2.718 hole 2.21: 1(0,0)
NB_H_ST252CB315D205_P2_S
  round 5.715 hole 5.207: 1(0,0)
NB_H_ST295CB315D169_P2_S
  round 4.801 hole 4.293: 1(0,0)
NB_PWR_FB_SHORT_PT
  rect 0.229x0.635 smd: 1(-0.203,0) 2(0.203,0)
NB_TPC26T_50
  round 0.66 smd: 1(0,0)
NB_TPC28T_68
  round 0.711 smd: 1(0,0)
QFN_16P_20_118X118_MPS
  rect 0.254x2.108 smd: 1(-0.5,-0.75) 2(0.5,-0.75) 9(0,0.75)
  rect 0.711x0.254 smd: 3(1.45,-1.25) 4(1.45,-0.75) 5(1.45,-0.25) 6(1.45,0.25) 7(1.45,0.75) 8(1.45,1.25) 11(-1.45,1.25) 12(-1.45,0.75) 13(-1.45,0.25) 14(-1.45,-0.25) 15(-1.45,-0.75) 16(-1.45,-1.25)
  rect 0.254x0.889 smd: 10(-0.5,1.35)
R0402
  rect 0.635x0.635 smd: 1(-0.445,0) 2(0.445,0)
R0402_H14
  rect 0.635x0.635 smd: 1(-0.445,0) 2(0.445,0)
TPC40T_68
  round 1.016 smd: 1(0,0)
TV_RTC_SHORT_6X20
  rect 0.152x0.508 smd: 1(-0.152,0) 2(0.152,0)
TX_2R4P0402_47X55_COLAY
  rect 0.356x0.559 smd: 1(-0.305,-0.533) 2(-0.305,0.533) 3(0.305,-0.533) 4(0.305,0.533)
TX_4R8P0402_H22_T01
  rect 0.498x0.61 smd: 1(-0.852,-0.495) 2(-0.852,0.495) 7(0.852,-0.495) 8(0.852,0.495)
  rect 0.295x0.61 smd: 3(-0.25,-0.495) 4(-0.25,0.495) 5(0.25,-0.495) 6(0.25,0.495)
TX_AUDIO_JACK_6P_TECHK
  oval 0.864x1.651 hole 0.457x1.245: 1(4.4,2) 3(-4.4,3.2) 4(4.4,4.4) 5(-4.4,6.7) 6(-4.4,9.4)
  oval 0.914x1.702 hole 0.508x1.295: 2(4.4,9.4)
TX_BGA_170P_31_555X476
  round 0.356 smd: A1(-6.4,-5.2) A2(-6.4,-4.4) A3(-6.4,-3.6) A4(-6.4,-2.8) A5(-6.4,-2) A10(-6.4,2) A11(-6.4,2.8) A12(-6.4,3.6) A13(-6.4,4.4) A14(-6.4,5.2) B1(-5.6,-5.2) B2(-5.6,-4.4) B3(-5.6,-3.6) B4(-5.6,-2.8) B5(-5.6,-2) B10(-5.6,2) B11(-5.6,2.8) B12(-5.6,3.6) B13(-5.6,4.4) B14(-5.6,5.2) C1(-4.8,-5.2) C2(-4.8,-4.4) C3(-4.8,-3.6) C4(-4.8,-2.8) C5(-4.8,-2) C10(-4.8,2) C11(-4.8,2.8) C12(-4.8,3.6) C13(-4.8,4.4) C14(-4.8,5.2) D1(-4,-5.2) D2(-4,-4.4) D3(-4,-3.6) D4(-4,-2.8) D5(-4,-2) D10(-4,2) D11(-4,2.8) D12(-4,3.6) D13(-4,4.4) D14(-4,5.2) E1(-3.2,-5.2) E2(-3.2,-4.4) E3(-3.2,-3.6) E4(-3.2,-2.8) E5(-3.2,-2) E10(-3.2,2) E11(-3.2,2.8) E12(-3.2,3.6) E13(-3.2,4.4) E14(-3.2,5.2) F1(-2.4,-5.2) F2(-2.4,-4.4) F3(-2.4,-3.6) F4(-2.4,-2.8) F5(-2.4,-2) F10(-2.4,2) F11(-2.4,2.8) F12(-2.4,3.6) F13(-2.4,4.4) F14(-2.4,5.2) G1(-1.6,-5.2) G2(-1.6,-4.4) G3(-1.6,-3.6) G4(-1.6,-2.8) G5(-1.6,-2) G10(-1.6,2) G11(-1.6,2.8) G12(-1.6,3.6) G13(-1.6,4.4) G14(-1.6,5.2) H1(-0.8,-5.2) H2(-0.8,-4.4) H3(-0.8,-3.6) H4(-0.8,-2.8) H5(-0.8,-2) H10(-0.8,2) H11(-0.8,2.8) H12(-0.8,3.6) H13(-0.8,4.4) H14(-0.8,5.2) J1(0,-5.2) J2(0,-4.4) J3(0,-3.6) J4(0,-2.8) J5(0,-2) J10(0,2) J11(0,2.8) J12(0,3.6) J13(0,4.4) J14(0,5.2) K1(0.8,-5.2) K2(0.8,-4.4) K3(0.8,-3.6) K4(0.8,-2.8) K5(0.8,-2) K10(0.8,2) K11(0.8,2.8) K12(0.8,3.6) K13(0.8,4.4) K14(0.8,5.2) L1(1.6,-5.2) L2(1.6,-4.4) L3(1.6,-3.6) L4(1.6,-2.8) L5(1.6,-2) L10(1.6,2) L11(1.6,2.8) L12(1.6,3.6) L13(1.6,4.4) L14(1.6,5.2) M1(2.4,-5.2) M2(2.4,-4.4) M3(2.4,-3.6) M4(2.4,-2.8) M5(2.4,-2) M10(2.4,2) M11(2.4,2.8) M12(2.4,3.6) M13(2.4,4.4) M14(2.4,5.2) N1(3.2,-5.2) N2(3.2,-4.4) N3(3.2,-3.6) N4(3.2,-2.8) N5(3.2,-2) N10(3.2,2) N11(3.2,2.8) N12(3.2,3.6) N13(3.2,4.4) N14(3.2,5.2) P1(4,-5.2) P2(4,-4.4) P3(4,-3.6) P4(4,-2.8) P5(4,-2) P10(4,2) P11(4,2.8) P12(4,3.6) P13(4,4.4) P14(4,5.2) R1(4.8,-5.2) R2(4.8,-4.4) R3(4.8,-3.6) R4(4.8,-2.8) R5(4.8,-2) R10(4.8,2) R11(4.8,2.8) R12(4.8,3.6) R13(4.8,4.4) R14(4.8,5.2) T1(5.6,-5.2) T2(5.6,-4.4) T3(5.6,-3.6) T4(5.6,-2.8) T5(5.6,-2) T10(5.6,2) T11(5.6,2.8) T12(5.6,3.6) T13(5.6,4.4) T14(5.6,5.2) U1(6.4,-5.2) U2(6.4,-4.4) U3(6.4,-3.6) U4(6.4,-2.8) U5(6.4,-2) U10(6.4,2) U11(6.4,2.8) U12(6.4,3.6) U13(6.4,4.4) U14(6.4,5.2)
TX_BGA_631P_909X909_AMD
  round 0.406 smd: A3(-10,10.8) A30(10,10.8) A32(10.8,10.8) AB7(-7.6,-4.2) AB8(-6.8,-4.2) AB9(-6,-4.2) AB10(-5.2,-4.2) AB23(5.2,-4.2) AB24(6,-4.2) AB25(6.8,-4.2) AB26(7.6,-4.2) AC11(-4.2,-5.2) AC13(-3,-5.2) AC14(-1.8,-5.2) AC16(-0.6,-5.2) AC17(0.6,-5.2) AC19(1.8,-5.2) AC20(3,-5.2) AC22(4.2,-5.2) AD11(-4.2,-6) AD13(-3,-6) AD14(-1.8,-6) AD16(-0.6,-6) AD17(0.6,-6) AD19(1.8,-6) AD20(3,-6) AD22(4.2,-6) AE11(-4.2,-6.8) AE13(-3,-6.8) AE14(-1.8,-6.8) AE16(-0.6,-6.8) AE17(0.6,-6.8) AE19(1.8,-6.8) AE20(3,-6.8) AE22(4.2,-6.8) AF11(-4.2,-7.6) AF13(-3,-7.6) AF14(-1.8,-7.6) AF16(-0.6,-7.6) AF17(0.6,-7.6) AF19(1.8,-7.6) AF20(3,-7.6) AF22(4.2,-7.6) AK1(-10.8,-10) AK3(-10,-10) AK30(10,-10) AK32(10.8,-10) AM1(-10.8,-10.8) AM3(-10,-10.8) AM30(10,-10.8) AM32(10.8,-10.8) C1(-10.8,10) C3(-10,10) C30(10,10) C32(10.8,10) G11(-4.2,7.6) G13(-3,7.6) G14(-1.8,7.6) G16(-0.6,7.6) G17(0.6,7.6) G19(1.8,7.6) G20(3,7.6) G22(4.2,7.6) H11(-4.2,6.8) H13(-3,6.8) H14(-1.8,6.8) H16(-0.6,6.8) H17(0.6,6.8) H19(1.8,6.8) H20(3,6.8) H22(4.2,6.8) J11(-4.2,6) J13(-3,6) J14(-1.8,6) J16(-0.6,6) J17(0.6,6) J19(1.8,6) J20(3,6) J22(4.2,6) K11(-4.2,5.2) K13(-3,5.2) K14(-1.8,5.2) K16(-0.6,5.2) K17(0.6,5.2) K19(1.8,5.2) K20(3,5.2) K22(4.2,5.2) L7(-7.6,4.2) L8(-6.8,4.2) L9(-6,4.2) L10(-5.2,4.2) L23(5.2,4.2) L24(6,4.2) L25(6.8,4.2) L26(7.6,4.2) N7(-7.6,3) N8(-6.8,3) N9(-6,3) N10(-5.2,3) N23(5.2,3) N24(6,3) N25(6.8,3) N26(7.6,3) P7(-7.6,1.8) P8(-6.8,1.8) P9(-6,1.8) P10(-5.2,1.8) P23(5.2,1.8) P24(6,1.8) P25(6.8,1.8) P26(7.6,1.8) T7(-7.6,0.6) T8(-6.8,0.6) T9(-6,0.6) T10(-5.2,0.6) T23(5.2,0.6) T24(6,0.6) T25(6.8,0.6) T26(7.6,0.6) U7(-7.6,-0.6) U8(-6.8,-0.6) U9(-6,-0.6) U10(-5.2,-0.6) U23(5.2,-0.6) U24(6,-0.6) U25(6.8,-0.6) U26(7.6,-0.6) W7(-7.6,-1.8) W8(-6.8,-1.8) W9(-6,-1.8) W10(-5.2,-1.8) W23(5.2,-1.8) W24(6,-1.8) W25(6.8,-1.8) W26(7.6,-1.8) Y7(-7.6,-3) Y8(-6.8,-3) Y9(-6,-3) Y10(-5.2,-3) Y23(5.2,-3) Y24(6,-3) Y25(6.8,-3) Y26(7.6,-3)
  round 0.3 smd: A5(-9.2,10.8) A7(-7.6,10.8) A9(-6,10.8) A11(-4.4,10.8) A13(-2.8,10.8) A15(-1.2,10.8) A17(0.4,10.8) A19(2,10.8) A21(3.6,10.8) A23(5.2,10.8) A25(6.8,10.8) A27(8.4,10.8) A28(9.2,10.8) AA1(-10.8,-3.6) AA3(-10,-3.6) AA5(-9.2,-3.6) AA6(-8.4,-3.6) AA27(8.4,-3.6) AA29(9.6,-3.6) AA31(10.4,-3.6) AB2(-10.4,-4.4) AB4(-9.6,-4.4) AB6(-8.4,-4.4) AB27(8.4,-4.4) AB28(9.2,-4.4) AB30(10,-4.4) AB32(10.8,-4.4) AC1(-10.8,-5.2) AC3(-10,-5.2) AC5(-9.2,-5.2) AC6(-8.4,-5.2) AC7(-7.6,-5.2) AC8(-6.8,-5.2) AC9(-6,-5.2) AC10(-5.2,-5.2) AC23(5.2,-5.2) AC24(6,-5.2) AC25(6.8,-5.2) AC26(7.6,-5.2) AC27(8.4,-5.2) AC29(9.6,-5.2) AC31(10.4,-5.2) AD2(-10.4,-6) AD4(-9.6,-6) AD6(-8.4,-6) AD7(-7.6,-6) AD8(-6.8,-6) AD9(-6,-6) AD10(-5.2,-6) AD23(5.2,-6) AD24(6,-6) AD25(6.8,-6) AD26(7.6,-6) AD27(8.4,-6) AD28(9.2,-6) AD30(10,-6) AD32(10.8,-6) AE1(-10.8,-6.8) AE3(-10,-6.8) AE5(-9.2,-6.8) AE6(-8.4,-6.8) AE7(-7.6,-6.8) AE8(-6.8,-6.8) AE9(-6,-6.8) AE10(-5.2,-6.8) AE23(5.2,-6.8) AE24(6,-6.8) AE25(6.8,-6.8) AE26(7.6,-6.8) AE27(8.4,-6.8) AE29(9.6,-6.8) AE31(10.4,-6.8) AF2(-10.4,-7.6) AF4(-9.6,-7.6) AF6(-8.4,-7.6) AF7(-7.6,-7.6) AF8(-6.8,-7.6) AF9(-6,-7.6) AF10(-5.2,-7.6) AF23(5.2,-7.6) AF24(6,-7.6) AF25(6.8,-7.6) AF26(7.6,-7.6) AF27(8.4,-7.6) AF28(9.2,-7.6) AF30(10,-7.6) AF32(10.8,-7.6) AG1(-10.8,-8.4) AG3(-10,-8.4) AG5(-9.2,-8.4) AG6(-8.4,-8.4) AG7(-7.6,-8.4) AG8(-6.8,-8.4) AG9(-6,-8.4) AG10(-5.2,-8.4) AG11(-4.4,-8.4) AG12(-3.6,-8.4) AG13(-2.8,-8.4) AG14(-2,-8.4) AG15(-1.2,-8.4) AG16(-0.4,-8.4) AG17(0.4,-8.4) AG18(1.2,-8.4) AG19(2,-8.4) AG20(2.8,-8.4) AG21(3.6,-8.4) AG22(4.4,-8.4) AG23(5.2,-8.4) AG24(6,-8.4) AG25(6.8,-8.4) AG26(7.6,-8.4) AG27(8.4,-8.4) AG29(9.6,-8.4) AG31(10.4,-8.4) AH1(-10.8,-9.2) AH3(-10,-9.2) AH5(-9.2,-9.2) AH6(-8.4,-9.2) AH8(-6.8,-9.2) AH10(-5.2,-9.2) AH12(-3.6,-9.2) AH14(-2,-9.2) AH16(-0.4,-9.2) AH18(1.2,-9.2) AH20(2.8,-9.2) AH22(4.4,-9.2) AH24(6,-9.2) AH26(7.6,-9.2) AH28(9.2,-9.2) AH30(10,-9.2) AH32(10.8,-9.2) AJ7(-7.6,-9.6) AJ9(-6,-9.6) AJ11(-4.4,-9.6) AJ13(-2.8,-9.6) AJ15(-1.2,-9.6) AJ17(0.4,-9.6) AJ19(2,-9.6) AJ21(3.6,-9.6) AJ23(5.2,-9.6) AJ25(6.8,-9.6) AJ27(8.4,-9.6) AK5(-9.2,-10) AK6(-8.4,-10) AK8(-6.8,-10) AK10(-5.2,-10) AK12(-3.6,-10) AK14(-2,-10) AK16(-0.4,-10) AK18(1.2,-10) AK20(2.8,-10) AK22(4.4,-10) AK24(6,-10) AK26(7.6,-10) AK28(9.2,-10) AL7(-7.6,-10.4) AL9(-6,-10.4) AL11(-4.4,-10.4) AL13(-2.8,-10.4) AL15(-1.2,-10.4) AL17(0.4,-10.4) AL19(2,-10.4) AL21(3.6,-10.4) AL23(5.2,-10.4) AL25(6.8,-10.4) AL27(8.4,-10.4) AM5(-9.2,-10.8) AM6(-8.4,-10.8) AM8(-6.8,-10.8) AM10(-5.2,-10.8) AM12(-3.6,-10.8) AM14(-2,-10.8) AM16(-0.4,-10.8) AM18(1.2,-10.8) AM20(2.8,-10.8) AM22(4.4,-10.8) AM24(6,-10.8) AM26(7.6,-10.8) AM28(9.2,-10.8) B6(-8.4,10.4) B8(-6.8,10.4) B10(-5.2,10.4) B12(-3.6,10.4) B14(-2,10.4) B16(-0.4,10.4) B18(1.2,10.4) B20(2.8,10.4) B22(4.4,10.4) B24(6,10.4) B26(7.6,10.4) C5(-9.2,10) C7(-7.6,10) C9(-6,10) C11(-4.4,10) C13(-2.8,10) C15(-1.2,10) C17(0.4,10) C19(2,10) C21(3.6,10) C23(5.2,10) C25(6.8,10) C27(8.4,10) C28(9.2,10) D6(-8.4,9.6) D8(-6.8,9.6) D10(-5.2,9.6) D12(-3.6,9.6) D14(-2,9.6) D16(-0.4,9.6) D18(1.2,9.6) D20(2.8,9.6) D22(4.4,9.6) D24(6,9.6) D26(7.6,9.6) E1(-10.8,9.2) E3(-10,9.2) E5(-9.2,9.2) E7(-7.6,9.2) E9(-6,9.2) E11(-4.4,9.2) E13(-2.8,9.2) E15(-1.2,9.2) E17(0.4,9.2) E19(2,9.2) E21(3.6,9.2) E23(5.2,9.2) E25(6.8,9.2) E27(8.4,9.2) E28(9.2,9.2) E30(10,9.2) E32(10.8,9.2) F2(-10.4,8.4) F4(-9.6,8.4) F6(-8.4,8.4) F7(-7.6,8.4) F8(-6.8,8.4) F9(-6,8.4) F10(-5.2,8.4) F11(-4.4,8.4) F12(-3.6,8.4) F13(-2.8,8.4) F14(-2,8.4) F15(-1.2,8.4) F16(-0.4,8.4) F17(0.4,8.4) F18(1.2,8.4) F19(2,8.4) F20(2.8,8.4) F21(3.6,8.4) F22(4.4,8.4) F23(5.2,8.4) F24(6,8.4) F25(6.8,8.4) F26(7.6,8.4) F27(8.4,8.4) F28(9.2,8.4) F30(10,8.4) F32(10.8,8.4) G1(-10.8,7.6) G3(-10,7.6) G5(-9.2,7.6) G6(-8.4,7.6) G7(-7.6,7.6) G8(-6.8,7.6) G9(-6,7.6) G10(-5.2,7.6) G23(5.2,7.6) G24(6,7.6) G25(6.8,7.6) G26(7.6,7.6) G27(8.4,7.6) G29(9.6,7.6) G31(10.4,7.6) H2(-10.4,6.8) H4(-9.6,6.8) H6(-8.4,6.8) H7(-7.6,6.8) H8(-6.8,6.8) H9(-6,6.8) H10(-5.2,6.8) H23(5.2,6.8) H24(6,6.8) H25(6.8,6.8) H26(7.6,6.8) H27(8.4,6.8) H28(9.2,6.8) H30(10,6.8) H32(10.8,6.8) J1(-10.8,6) J3(-10,6) J5(-9.2,6) J6(-8.4,6) J7(-7.6,6) J8(-6.8,6) J9(-6,6) J10(-5.2,6) J23(5.2,6) J24(6,6) J25(6.8,6) J26(7.6,6) J27(8.4,6) J29(9.6,6) J31(10.4,6) K2(-10.4,5.2) K4(-9.6,5.2) K6(-8.4,5.2) K7(-7.6,5.2) K8(-6.8,5.2) K9(-6,5.2) K10(-5.2,5.2) K23(5.2,5.2) K24(6,5.2) K25(6.8,5.2) K26(7.6,5.2) K27(8.4,5.2) K28(9.2,5.2) K30(10,5.2) K32(10.8,5.2) L1(-10.8,4.4) L3(-10,4.4) L5(-9.2,4.4) L6(-8.4,4.4) L27(8.4,4.4) L29(9.6,4.4) L31(10.4,4.4) M2(-10.4,3.6) M4(-9.6,3.6) M6(-8.4,3.6) M27(8.4,3.6) M28(9.2,3.6) M30(10,3.6) M32(10.8,3.6) N1(-10.8,2.8) N3(-10,2.8) N5(-9.2,2.8) N6(-8.4,2.8) N27(8.4,2.8) N29(9.6,2.8) N31(10.4,2.8) P2(-10.4,2) P4(-9.6,2) P6(-8.4,2) P27(8.4,2) P28(9.2,2) P30(10,2) P32(10.8,2) R1(-10.8,1.2) R3(-10,1.2) R5(-9.2,1.2) R6(-8.4,1.2) R27(8.4,1.2) R29(9.6,1.2) R31(10.4,1.2) T2(-10.4,0.4) T4(-9.6,0.4) T6(-8.4,0.4) T27(8.4,0.4) T28(9.2,0.4) T30(10,0.4) T32(10.8,0.4) U1(-10.8,-0.4) U3(-10,-0.4) U5(-9.2,-0.4) U6(-8.4,-0.4) U27(8.4,-0.4) U29(9.6,-0.4) U31(10.4,-0.4) V2(-10.4,-1.2) V4(-9.6,-1.2) V6(-8.4,-1.2) V27(8.4,-1.2) V28(9.2,-1.2) V30(10,-1.2) V32(10.8,-1.2) W1(-10.8,-2) W3(-10,-2) W5(-9.2,-2) W6(-8.4,-2) W27(8.4,-2) W29(9.6,-2) W31(10.4,-2) Y2(-10.4,-2.8) Y4(-9.6,-2.8) Y6(-8.4,-2.8) Y27(8.4,-2.8) Y28(9.2,-2.8) Y30(10,-2.8) Y32(10.8,-2.8)
  round 0.5 smd: AA11(-4.4,-3.4) AA12(-3.4,-3.4) AA13(-2.4,-3.4) AA15(-1.4,-3.4) AA16(-0.4,-3.4) AA17(0.4,-3.4) AA18(1.4,-3.4) AA20(2.4,-3.4) AA21(3.4,-3.4) AA22(4.4,-3.4) AB11(-4.4,-4.4) AB12(-3.4,-4.4) AB13(-2.4,-4.4) AB15(-1.4,-4.4) AB16(-0.4,-4.4) AB17(0.4,-4.4) AB18(1.4,-4.4) AB20(2.4,-4.4) AB21(3.4,-4.4) AB22(4.4,-4.4) L11(-4.4,4.4) L12(-3.4,4.4) L13(-2.4,4.4) L15(-1.4,4.4) L16(-0.4,4.4) L17(0.4,4.4) L18(1.4,4.4) L20(2.4,4.4) L21(3.4,4.4) L22(4.4,4.4) M11(-4.4,3.4) M12(-3.4,3.4) M13(-2.4,3.4) M15(-1.4,3.4) M16(-0.4,3.4) M17(0.4,3.4) M18(1.4,3.4) M20(2.4,3.4) M21(3.4,3.4) M22(4.4,3.4) N11(-4.4,2.4) N12(-3.4,2.4) N13(-2.4,2.4) N15(-1.4,2.4) N16(-0.4,2.4) N17(0.4,2.4) N18(1.4,2.4) N20(2.4,2.4) N21(3.4,2.4) N22(4.4,2.4) R11(-4.4,1.4) R12(-3.4,1.4) R13(-2.4,1.4) R15(-1.4,1.4) R16(-0.4,1.4) R17(0.4,1.4) R18(1.4,1.4) R20(2.4,1.4) R21(3.4,1.4) R22(4.4,1.4) T11(-4.4,0.4) T12(-3.4,0.4) T13(-2.4,0.4) T15(-1.4,0.4) T16(-0.4,0.4) T17(0.4,0.4) T18(1.4,0.4) T20(2.4,0.4) T21(3.4,0.4) T22(4.4,0.4) U11(-4.4,-0.4) U12(-3.4,-0.4) U13(-2.4,-0.4) U15(-1.4,-0.4) U16(-0.4,-0.4) U17(0.4,-0.4) U18(1.4,-0.4) U20(2.4,-0.4) U21(3.4,-0.4) U22(4.4,-0.4) V11(-4.4,-1.4) V12(-3.4,-1.4) V13(-2.4,-1.4) V15(-1.4,-1.4) V16(-0.4,-1.4) V17(0.4,-1.4) V18(1.4,-1.4) V20(2.4,-1.4) V21(3.4,-1.4) V22(4.4,-1.4) Y11(-4.4,-2.4) Y12(-3.4,-2.4) Y13(-2.4,-2.4) Y15(-1.4,-2.4) Y16(-0.4,-2.4) Y17(0.4,-2.4) Y18(1.4,-2.4) Y20(2.4,-2.4) Y21(3.4,-2.4) Y22(4.4,-2.4)
TX_C0402
  rect 0.432x0.61 smd: 1(-0.432,0) 2(0.432,0)
TX_C0402_H20
  rect 0.432x0.61 smd: 1(-0.432,0) 2(0.432,0)
TX_C0402_H22
  rect 0.432x0.61 smd: 1(-0.432,0) 2(0.432,0)
TX_C0402_T02_H26
  rect 0.432x0.711 smd: 1(-0.432,0) 2(0.432,0)
TX_C0402_T02_H28
  rect 0.432x0.711 smd: 1(-0.432,0) 2(0.432,0)
TX_C0603
  rect 0.587x0.914 smd: 1(-0.684,0) 2(0.684,0)
TX_C0603_T02_H39
  rect 0.587x1.016 smd: 1(-0.684,0) 2(0.684,0)
TX_C0603_T015_H37
  rect 0.587x0.965 smd: 1(-0.684,0) 2(0.684,0)
TX_C0805_T02_H55
  rect 0.726x1.473 smd: 1(-0.856,0) 2(0.856,0)
TX_C0805_T02_H57
  rect 0.726x1.422 smd: 1(-0.856,0) 2(0.856,0)
TX_C3528_T02_H79
  rect 1.905x2.21 smd: 1(1.816,0) 2(-1.816,0)
TX_C7343D_299X177
  rect 2.032x2.616 smd: 1(3.265,0) 2(-3.265,0)
TX_C7343D_T02_H83
  rect 2.032x2.616 smd: 1(3.265,0) 2(-3.265,0)
TX_CHOKE_4P_49X39_MURA
  rect 0.965x0.305 smd: 1(-0.75,0.275) 2(0.75,0.275) 3(0.75,-0.275) 4(-0.75,-0.275)
TX_DFN1006_2P_43X28_WIL
  rect 0.559x0.61 smd: 1(-0.425,0) 2(0.425,0)
TX_DFN_4P_26_51X67_P_1V
  rect 0.381x0.457 smd: 1(-0.325,-0.721) 2(0.325,-0.721) 3(0.325,0.721) 4(-0.325,0.721)
  rect 0.94x0.559 smd: 5(0,0)
  round 0.61 hole 0.305: 6(0,0)
TX_DFN_6P_16_51X51
  rect 0.229x0.635 smd: 1(-0.4,-0.403) 2(0,-0.403) 3(0.4,-0.403) 4(0.4,0.403) 5(0,0.403) 6(-0.4,0.403)
TX_DFN_8P_20_87X87_PAD_1V
  rect 0.279x0.508 smd: 1(-0.75,-0.9) 2(-0.25,-0.9) 3(0.25,-0.9) 4(0.75,-0.9) 5(0.75,0.9) 6(0.25,0.9) 7(-0.25,0.9) 8(-0.75,0.9)
  rect 1.6x0.864 smd: 9(0,0)
  round 0.61 hole 0.305: 10(0,0)
TX_DFN_8P_20_S83_PAD_1V
  rect 0.279x0.508 smd: 1(-0.75,-0.9) 2(-0.25,-0.9) 3(0.25,-0.9) 4(0.75,-0.9) 5(0.75,0.9) 6(0.25,0.9) 7(-0.25,0.9) 8(-0.75,0.9)
  rect 1.702x0.864 smd: 9(0,0)
  round 0.61 hole 0.305: 10(0.546,-0.127)
TX_DFN_10P_16_122X83_P_COLA
  custom 0.157x0.157 smd: 1(-1.2,-0.89) 7(0.8,-0.89) 8(0.8,0.89) 14(-1.2,0.89)
  rect 0.229x0.711 smd: 3(-0.4,-1.004) 4(0,-1.004) 5(0.4,-1.004) 10(0.4,1.004) 11(0,1.004) 12(-0.4,1.004)
  rect 2.591x0.889 smd: 15(0,0)
TX_DFN_10P_16_122X83_PAD
  custom 0.15x0.15 smd: 1(-1.2,-1) 7(0.8,-1) 8(0.8,1) 14(-1.2,1)
  rect 0.203x0.711 smd: 3(-0.4,-1) 4(0,-1) 5(0.4,-1) 10(0.4,1) 11(0,1) 12(-0.4,1)
  rect 2.54x0.838 smd: 15(0,0)
TX_DFN_10P_20_102X43_COLAY
  rect 0.279x0.686 smd: 1(-1,-0.435) 2(-0.5,-0.435) 4(0.5,-0.435) 5(1,-0.435) 6(1,0.435) 7(0.5,0.435) 9(-0.5,0.435) 10(-1,0.435)
  rect 0.356x1.549 smd: 3(0,0)
TX_DFN_10P_20_S122_P_4V
  rect 0.279x0.61 smd: 1(-1,-1.35) 2(-0.5,-1.35) 3(0,-1.35) 4(0.5,-1.35) 5(1,-1.35) 6(1,1.35) 7(0.5,1.35) 8(0,1.35) 9(-0.5,1.35) 10(-1,1.35)
  rect 2.642x1.676 smd: 11(0,0)
  round 0.61 hole 0.305: 12(-1.016,0.533) 13(1.016,0.533) 14(-1.016,-0.533) 15(1.016,-0.533)
TX_ESD_2P_33_39X24_COLAY
  rect 0.559x0.61 smd: 1(-0.425,0) 2(0.425,0)
TX_ESD_2P_33_39X24_H24
  rect 0.559x0.61 smd: 1(-0.425,0) 2(0.425,0)
TX_FPC_4P_39_2HOLD_RA_AC_B
  rect 0.406x0.838 smd: 1(-1.5,3.175) 2(-0.5,3.175) 3(0.5,3.175) 4(1.5,3.175)
  rect 0.787x2.007 smd: 5(-3.7,0) 6(3.7,0)
TX_FPC_8P_39_2HOLD_ACES_B
  rect 0.406x0.838 smd: 1(-3.5,3.175) 2(-2.5,3.175) 3(-1.5,3.175) 4(-0.5,3.175) 5(0.5,3.175) 6(1.5,3.175) 7(2.5,3.175) 8(3.5,3.175)
  rect 0.787x2.007 smd: 9(-5.7,0) 10(5.7,0)
TX_FPC_12P_20_2H_RA_ACES_B
  rect 0.305x1.092 smd: 1(-2.75,3.6) 2(-2.25,3.6) 3(-1.75,3.6) 4(-1.25,3.6) 5(-0.75,3.6) 6(-0.25,3.6) 7(0.25,3.6) 8(0.75,3.6) 9(1.25,3.6) 10(1.75,3.6) 11(2.25,3.6) 12(2.75,3.6)
  rect 0.991x2.489 smd: 13(-4.55,0) 14(4.55,0)
TX_FPC_12P_20_2HD_RA_PANA
  rect 0.305x0.787 smd: 1(-2.75,2.5) 2(-2.25,2.5) 3(-1.75,2.5) 4(-1.25,2.5) 5(-0.75,2.5) 6(-0.25,2.5) 7(0.25,2.5) 8(0.75,2.5) 9(1.25,2.5) 10(1.75,2.5) 11(2.25,2.5) 12(2.75,2.5)
  rect 0.406x0.787 smd: 13(-3.75,0) 14(3.75,0)
TX_FPC_30P_20_2H_RA_ACES_B
  rect 0.305x0.838 smd: 1(-7.25,3.175) 2(-6.75,3.175) 3(-6.25,3.175) 4(-5.75,3.175) 5(-5.25,3.175) 6(-4.75,3.175) 7(-4.25,3.175) 8(-3.75,3.175) 9(-3.25,3.175) 10(-2.75,3.175) 11(-2.25,3.175) 12(-1.75,3.175) 13(-1.25,3.175) 14(-0.75,3.175) 15(-0.25,3.175) 16(0.25,3.175) 17(0.75,3.175) 18(1.25,3.175) 19(1.75,3.175) 20(2.25,3.175) 21(2.75,3.175) 22(3.25,3.175) 23(3.75,3.175) 24(4.25,3.175) 25(4.75,3.175) 26(5.25,3.175) 27(5.75,3.175) 28(6.25,3.175) 29(6.75,3.175) 30(7.25,3.175)
  rect 0.787x2.007 smd: 31(-8.95,0) 32(8.95,0)
TX_FPC_30P_31_2HOLD_RA_ACE
  rect 0.229x0.787 smd: 1(-11.6,3.3) 2(-10.8,3.3) 3(-10,3.3) 4(-9.2,3.3) 5(-8.4,3.3) 6(-7.6,3.3) 7(-6.8,3.3) 8(-6,3.3) 9(-5.2,3.3) 10(-4.4,3.3) 11(-3.6,3.3) 12(-2.8,3.3) 13(-2,3.3) 14(-1.2,3.3) 15(-0.4,3.3) 16(0.4,3.3) 17(1.2,3.3) 18(2,3.3) 19(2.8,3.3) 20(3.6,3.3) 21(4.4,3.3) 22(5.2,3.3) 23(6,3.3) 24(6.8,3.3) 25(7.6,3.3) 26(8.4,3.3) 27(9.2,3.3) 28(10,3.3) 29(10.8,3.3) 30(11.6,3.3)
  rect 0.559x1.295 smd: 31(-13.225,0) 32(13.225,0)
TX_INDUCTO_2P_287X268_COLAY
  custom 0.711x0.711 smd: 1(-2.942,0) 2(2.942,0)
TX_INDUCTOR_2P_98X79_TA_H47
  rect 0.787x2.007 smd: 1(-1,0) 2(1,0)
TX_INDUCTOR_2P_106X87
  rect 0.787x2.007 smd: 1(-1,0) 2(1,0)
TX_INDUCTOR_2P_274X260_CYN
  rect 2.362x3.505 smd: 1(-3.025,0) 2(3.025,0)
TX_INDUCTOR_2P_278X260_H118
  rect 2.362x3.505 smd: 1(-3.025,0) 2(3.025,0)
TX_INDUCTOR_2P_S260_CYN_T02
  rect 2.845x2.997 smd: 1(-3.025,0) 2(3.025,0)
TX_INDUCTOR_2P_S268_MI_COLA
  rect 2.845x3.505 smd: 1(-3.025,0) 2(3.025,0)
TX_INDUCTOR_2P_S406
  rect 3.327x2.997 smd: 1(-4.563,0) 2(4.563,0)
TX_L0402
  rect 0.432x0.61 smd: 1(-0.432,0) 2(0.432,0)
TX_L0402_H24
  rect 0.432x0.61 smd: 1(-0.432,0) 2(0.432,0)
TX_L0402_T02
  rect 0.432x0.711 smd: 1(-0.432,0) 2(0.432,0)
TX_L0603_T02_H37
  rect 0.587x1.016 smd: 1(-0.684,0) 2(0.684,0)
TX_L0603_T015
  rect 0.587x0.965 smd: 1(-0.684,0) 2(0.684,0)
TX_LED_3P_126X59_CO
  rect 0.889x0.94 smd: 1(0,0.519)
  rect 1.194x0.787 smd: 2(-1.5,0) 3(1.5,0)
TX_LGA_12P_20_87X87_ST
  rect 0.254x0.279 smd: 1(-0.75,-0.763) 2(-0.25,-0.763) 3(0.25,-0.763) 4(0.75,-0.763) 7(0.75,0.763) 8(0.25,0.763) 9(-0.25,0.763) 10(-0.75,0.763)
  rect 0.279x0.254 smd: 5(0.763,-0.25) 6(0.763,0.25) 11(-0.763,0.25) 12(-0.763,-0.25)
TX_NGFF_67P_20_4HOLD_ARG
  round 1.092 hole 1.092 unplated: (-10,0)
  round 1.6 hole 1.6 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 24(-3.5,-2.275) 25(-3.25,5.275) 26(-3,-2.275) 27(-2.75,5.275) 28(-2.5,-2.275) 29(-2.25,5.275) 30(-2,-2.275) 31(-1.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
TX_POLYSWITCH_2P_87X59
  rect 0.991x1.499 smd: 1(-1.1,0) 2(1.1,0)
TX_POLYSWITCH_2P_1812_H71
  rect 1.778x3.15 smd: 1(-2.289,0) 2(2.289,0)
TX_POLYSWITCH_0603_71X39
  rect 0.991x0.991 smd: 1(-0.9,0) 2(0.9,0)
TX_POWER_8P_50_2PAD_8V
  rect 0.762x0.813 smd: 1(-1.905,-2.89) 2(-0.635,-2.89) 3(0.635,-2.89) 4(1.905,-2.89) 5(1.905,2.89) 6(0.635,2.89) 7(-0.635,2.89)
  rect 0.813x1.88 smd: 8(-1.885,2.365)
  custom 0.663x0.663 smd: 9(0,0.655)
  rect 4.191x1.016 smd: 10(0,-1.575)
  round 0.61 hole 0.305: 11(1.975,1.675) 12(1.975,0.655) 13(1.975,-0.365) 14(0.448,1.675) 15(0.448,0.655) 16(0.448,-0.365) 17(-1.08,0.525) 18(-1.08,-0.365)
TX_POWERPAIR_8P_2PAD_VISHAY
  rect 0.457x0.457 smd: 1(-0.975,-1.386) 2(-0.325,-1.386) 3(0.325,-1.386) 4(0.975,-1.386) 5(0.975,1.386) 6(0.325,1.386) 7(-0.325,1.386) 8(-0.975,1.386)
  rect 2.438x1.041 smd: 9(0,0.434)
  rect 2.438x0.559 smd: 10(0,-0.671)
TX_QFN_13P_122X83
  rect 0.254x1.499 smd: 1(-0.5,-0.55) 2(0.5,-0.55) 8(0,0.55)
  rect 0.711x0.254 smd: 3(1.45,-0.75) 4(1.45,-0.25) 5(1.45,0.25) 6(1.45,0.75) 10(-1.45,0.75) 11(-1.45,0.25) 12(-1.45,-0.25) 13(-1.45,-0.75)
  rect 0.254x0.711 smd: 7(0.5,0.95) 9(-0.5,0.95)
TX_QFN_20P_16_S118_P_H31_4V
  rect 0.229x0.61 smd: 1(-0.8,-1.35) 2(-0.4,-1.35) 3(0,-1.35) 4(0.4,-1.35) 5(0.8,-1.35) 11(0.8,1.35) 12(0.4,1.35) 13(0,1.35) 14(-0.4,1.35) 15(-0.8,1.35)
  rect 0.61x0.229 smd: 6(1.35,-0.8) 7(1.35,-0.4) 8(1.35,0) 9(1.35,0.4) 10(1.35,0.8) 16(-1.35,0.8) 17(-1.35,0.4) 18(-1.35,0) 19(-1.35,-0.4) 20(-1.35,-0.8)
  rect 1.651x1.651 smd: 21(0,0)
  round 0.61 hole 0.305: 22(-0.521,0.521) 23(0.521,0.521) 24(-0.521,-0.521) 25(0.521,-0.521)
TX_QFN_32P_16_S161_PAD_5V
  rect 0.229x0.508 smd: 1(-1.4,-1.896) 2(-1,-1.896) 3(-0.6,-1.896) 4(-0.2,-1.896) 5(0.2,-1.896) 6(0.6,-1.896) 7(1,-1.896) 8(1.4,-1.896) 17(1.4,1.896) 18(1,1.896) 19(0.6,1.896) 20(0.2,1.896) 21(-0.2,1.896) 22(-0.6,1.896) 23(-1,1.896) 24(-1.4,1.896)
  rect 0.508x0.229 smd: 9(1.896,-1.4) 10(1.896,-1) 11(1.896,-0.6) 12(1.896,-0.2) 13(1.896,0.2) 14(1.896,0.6) 15(1.896,1) 16(1.896,1.4) 25(-1.896,1.4) 26(-1.896,1) 27(-1.896,0.6) 28(-1.896,0.2) 29(-1.896,-0.2) 30(-1.896,-0.6) 31(-1.896,-1) 32(-1.896,-1.4)
  rect 2.794x2.794 smd: 33(0,0)
  round 0.61 hole 0.305: 34(-1.09,1.09) 35(1.09,1.09) 36(-1.09,-1.09) 37(1.09,-1.09) 38(0,0)
TX_QFN_40P_16_161X240_PD_8V
  rect 0.229x0.61 smd: 1(-1.4,-2.845) 2(-1,-2.845) 3(-0.6,-2.845) 4(-0.2,-2.845) 5(0.2,-2.845) 6(0.6,-2.845) 7(1,-2.845) 8(1.4,-2.845) 21(1.4,2.845) 22(1,2.845) 23(0.6,2.845) 24(0.2,2.845) 25(-0.2,2.845) 26(-0.6,2.845) 27(-1,2.845) 28(-1.4,2.845)
  rect 0.61x0.229 smd: 9(1.845,-2.2) 10(1.845,-1.8) 11(1.845,-1.4) 12(1.845,-1) 13(1.845,-0.6) 14(1.845,-0.2) 15(1.845,0.2) 16(1.845,0.6) 17(1.845,1) 18(1.845,1.4) 19(1.845,1.8) 20(1.845,2.2) 29(-1.845,2.2) 30(-1.845,1.8) 31(-1.845,1.4) 32(-1.845,1) 33(-1.845,0.6) 34(-1.845,0.2) 35(-1.845,-0.2) 36(-1.845,-0.6) 37(-1.845,-1) 38(-1.845,-1.4) 39(-1.845,-1.8) 40(-1.845,-2.2)
  rect 2.667x4.674 smd: 41(0,0)
  round 0.61 hole 0.305: 42(0,2.031) 43(-1.029,0.75) 44(0,0.75) 45(1.029,0.75) 46(-1.029,-0.75) 47(0,-0.75) 48(1.029,-0.75) 49(0,-2.031)
TX_QFN_40P_16_S201_P_4V_H31
  rect 0.229x0.61 smd: 1(-1.8,-2.345) 2(-1.4,-2.345) 3(-1,-2.345) 4(-0.6,-2.345) 5(-0.2,-2.345) 6(0.2,-2.345) 7(0.6,-2.345) 8(1,-2.345) 9(1.4,-2.345) 10(1.8,-2.345) 21(1.8,2.345) 22(1.4,2.345) 23(1,2.345) 24(0.6,2.345) 25(0.2,2.345) 26(-0.2,2.345) 27(-0.6,2.345) 28(-1,2.345) 29(-1.4,2.345) 30(-1.8,2.345)
  rect 0.61x0.229 smd: 11(2.345,-1.8) 12(2.345,-1.4) 13(2.345,-1) 14(2.345,-0.6) 15(2.345,-0.2) 16(2.345,0.2) 17(2.345,0.6) 18(2.345,1) 19(2.345,1.4) 20(2.345,1.8) 31(-2.345,1.8) 32(-2.345,1.4) 33(-2.345,1) 34(-2.345,0.6) 35(-2.345,0.2) 36(-2.345,-0.2) 37(-2.345,-0.6) 38(-2.345,-1) 39(-2.345,-1.4) 40(-2.345,-1.8)
  rect 3.505x3.505 smd: 41(0,0)
  round 0.61 hole 0.305: 42(-1.448,1.448) 43(1.448,1.448) 44(-1.448,-1.448) 45(1.448,-1.448)
TX_QFN_40P_20_S240_P_4V
  rect 0.279x0.61 smd: 1(-2.25,-2.845) 2(-1.75,-2.845) 3(-1.25,-2.845) 4(-0.75,-2.845) 5(-0.25,-2.845) 6(0.25,-2.845) 7(0.75,-2.845) 8(1.25,-2.845) 9(1.75,-2.845) 10(2.25,-2.845) 21(2.25,2.845) 22(1.75,2.845) 23(1.25,2.845) 24(0.75,2.845) 25(0.25,2.845) 26(-0.25,2.845) 27(-0.75,2.845) 28(-1.25,2.845) 29(-1.75,2.845) 30(-2.25,2.845)
  rect 0.61x0.279 smd: 11(2.845,-2.25) 12(2.845,-1.75) 13(2.845,-1.25) 14(2.845,-0.75) 15(2.845,-0.25) 16(2.845,0.25) 17(2.845,0.75) 18(2.845,1.25) 19(2.845,1.75) 20(2.845,2.25) 31(-2.845,2.25) 32(-2.845,1.75) 33(-2.845,1.25) 34(-2.845,0.75) 35(-2.845,0.25) 36(-2.845,-0.25) 37(-2.845,-0.75) 38(-2.845,-1.25) 39(-2.845,-1.75) 40(-2.845,-2.25)
  rect 4.674x4.674 smd: 41(0,0)
  round 0.61 hole 0.305: 42(-2.032,2.032) 43(2.032,2.032) 44(-2.032,-2.032) 45(2.032,-2.032)
TX_QFN_48P_16_S240_P_9V_REA
  rect 0.229x0.61 smd: 1(-2.2,-2.845) 2(-1.8,-2.845) 3(-1.4,-2.845) 4(-1,-2.845) 5(-0.6,-2.845) 6(-0.2,-2.845) 7(0.2,-2.845) 8(0.6,-2.845) 9(1,-2.845) 10(1.4,-2.845) 11(1.8,-2.845) 12(2.2,-2.845) 25(2.2,2.845) 26(1.8,2.845) 27(1.4,2.845) 28(1,2.845) 29(0.6,2.845) 30(0.2,2.845) 31(-0.2,2.845) 32(-0.6,2.845) 33(-1,2.845) 34(-1.4,2.845) 35(-1.8,2.845) 36(-2.2,2.845)
  rect 0.61x0.229 smd: 13(2.845,-2.2) 14(2.845,-1.8) 15(2.845,-1.4) 16(2.845,-1) 17(2.845,-0.6) 18(2.845,-0.2) 19(2.845,0.2) 20(2.845,0.6) 21(2.845,1) 22(2.845,1.4) 23(2.845,1.8) 24(2.845,2.2) 37(-2.845,2.2) 38(-2.845,1.8) 39(-2.845,1.4) 40(-2.845,1) 41(-2.845,0.6) 42(-2.845,0.2) 43(-2.845,-0.2) 44(-2.845,-0.6) 45(-2.845,-1) 46(-2.845,-1.4) 47(-2.845,-1.8) 48(-2.845,-2.2)
  rect 4.648x4.648 smd: 49(0,0)
  round 0.61 hole 0.305: 50(-2.019,2.019) 51(0,2.019) 52(2.019,2.019) 53(-2.019,0) 54(0,0) 55(2.019,0) 56(-2.019,-2.019) 57(0,-2.019) 58(2.019,-2.019)
TX_QFP_128P_16_559X559
  rect 0.229x1.499 smd: 1(-6.2,-7.86) 2(-5.8,-7.86) 3(-5.4,-7.86) 4(-5,-7.86) 5(-4.6,-7.86) 6(-4.2,-7.86) 7(-3.8,-7.86) 8(-3.4,-7.86) 9(-3,-7.86) 10(-2.6,-7.86) 11(-2.2,-7.86) 12(-1.8,-7.86) 13(-1.4,-7.86) 14(-1,-7.86) 15(-0.6,-7.86) 16(-0.2,-7.86) 17(0.2,-7.86) 18(0.6,-7.86) 19(1,-7.86) 20(1.4,-7.86) 21(1.8,-7.86) 22(2.2,-7.86) 23(2.6,-7.86) 24(3,-7.86) 25(3.4,-7.86) 26(3.8,-7.86) 27(4.2,-7.86) 28(4.6,-7.86) 29(5,-7.86) 30(5.4,-7.86) 31(5.8,-7.86) 32(6.2,-7.86) 65(6.2,7.86) 66(5.8,7.86) 67(5.4,7.86) 68(5,7.86) 69(4.6,7.86) 70(4.2,7.86) 71(3.8,7.86) 72(3.4,7.86) 73(3,7.86) 74(2.6,7.86) 75(2.2,7.86) 76(1.8,7.86) 77(1.4,7.86) 78(1,7.86) 79(0.6,7.86) 80(0.2,7.86) 81(-0.2,7.86) 82(-0.6,7.86) 83(-1,7.86) 84(-1.4,7.86) 85(-1.8,7.86) 86(-2.2,7.86) 87(-2.6,7.86) 88(-3,7.86) 89(-3.4,7.86) 90(-3.8,7.86) 91(-4.2,7.86) 92(-4.6,7.86) 93(-5,7.86) 94(-5.4,7.86) 95(-5.8,7.86) 96(-6.2,7.86)
  rect 1.499x0.229 smd: 33(7.86,-6.2) 34(7.86,-5.8) 35(7.86,-5.4) 36(7.86,-5) 37(7.86,-4.6) 38(7.86,-4.2) 39(7.86,-3.8) 40(7.86,-3.4) 41(7.86,-3) 42(7.86,-2.6) 43(7.86,-2.2) 44(7.86,-1.8) 45(7.86,-1.4) 46(7.86,-1) 47(7.86,-0.6) 48(7.86,-0.2) 49(7.86,0.2) 50(7.86,0.6) 51(7.86,1) 52(7.86,1.4) 53(7.86,1.8) 54(7.86,2.2) 55(7.86,2.6) 56(7.86,3) 57(7.86,3.4) 58(7.86,3.8) 59(7.86,4.2) 60(7.86,4.6) 61(7.86,5) 62(7.86,5.4) 63(7.86,5.8) 64(7.86,6.2) 97(-7.86,6.2) 98(-7.86,5.8) 99(-7.86,5.4) 100(-7.86,5) 101(-7.86,4.6) 102(-7.86,4.2) 103(-7.86,3.8) 104(-7.86,3.4) 105(-7.86,3) 106(-7.86,2.6) 107(-7.86,2.2) 108(-7.86,1.8) 109(-7.86,1.4) 110(-7.86,1) 111(-7.86,0.6) 112(-7.86,0.2) 113(-7.86,-0.2) 114(-7.86,-0.6) 115(-7.86,-1) 116(-7.86,-1.4) 117(-7.86,-1.8) 118(-7.86,-2.2) 119(-7.86,-2.6) 120(-7.86,-3) 121(-7.86,-3.4) 122(-7.86,-3.8) 123(-7.86,-4.2) 124(-7.86,-4.6) 125(-7.86,-5) 126(-7.86,-5.4) 127(-7.86,-5.8) 128(-7.86,-6.2)
TX_R0402
  rect 0.432x0.61 smd: 1(-0.432,0) 2(0.432,0)
TX_R0402_0OHM
  rect 0.432x0.61 smd: 1(-0.432,0) 2(0.432,0)
TX_R0402_H16
  rect 0.432x0.61 smd: 1(-0.432,0) 2(0.432,0)
TX_R0402_H22
  rect 0.432x0.61 smd: 1(-0.432,0) 2(0.432,0)
TX_R0402_H24
  rect 0.432x0.61 smd: 1(-0.432,0) 2(0.432,0)
TX_R0402_SHORT
  rect 0.432x0.61 smd: 1(-0.432,0) 2(0.432,0)
TX_R0603_0OHM_H24
  rect 0.587x0.914 smd: 1(-0.684,0) 2(0.684,0)
TX_R0603_H22
  rect 0.587x0.914 smd: 1(-0.684,0) 2(0.684,0)
TX_R0603_H24
  rect 0.587x0.914 smd: 1(-0.684,0) 2(0.684,0)
TX_R0603_SHORT
  rect 0.587x0.914 smd: 1(-0.684,0) 2(0.684,0)
TX_R0603_T02_H30
  rect 0.587x1.016 smd: 1(-0.684,0) 2(0.684,0)
TX_R0805_0OHM_H26
  rect 0.726x1.372 smd: 1(-0.856,0) 2(0.856,0)
TX_R0805_0OHM_T02_H20
  rect 0.726x1.473 smd: 1(-0.856,0) 2(0.856,0)
TX_R0805_H26
  rect 0.726x1.372 smd: 1(-0.856,0) 2(0.856,0)
TX_R0805_SHORT
  rect 0.726x1.372 smd: 1(-0.856,0) 2(0.856,0)
TX_R1206_H30
  rect 0.965x1.803 smd: 1(-1.321,0) 2(1.321,0)
TX_R1508_H35
  rect 0.991x3.759 smd: 1(-1,0) 2(1,0)
TX_SC70_S5_TI
  rect 0.94x0.356 smd: 1(1.189,-0.65) 2(1.189,0) 3(1.189,0.65) 4(-1.189,0.65) 5(-1.189,-0.65)
TX_SC70_S6_H47
  rect 0.356x0.94 smd: 1(-0.65,-1.19) 2(0,-1.19) 3(0.65,-1.19) 4(0.65,1.19) 5(0,1.19) 6(-0.65,1.19)
TX_SI7501DN_H44
  rect 0.406x0.991 smd: 1(-0.99,-1.435) 2(-0.33,-1.435) 3(0.33,-1.435) 4(0.99,-1.435)
  custom 0.559x0.559 smd: 5(0,0)
TX_SI7850DP
  rect 0.61x1.27 smd: 1(-1.905,-1.68) 2(-0.635,-1.68) 3(0.635,-1.68) 4(1.905,-1.68)
  custom 1.105x1.105 smd: 5(0,1.68)
TX_SMA_181X110
  rect 1.956x1.499 smd: 1(2.25,0) 2(-2.25,0)
TX_SOD323_H39
  rect 1.092x0.508 smd: 1(1.3,0) 2(-1.3,0)
TX_SOD323F_H49
  rect 0.889x0.33 smd: 1(1.192,0) 2(-1.192,0)
TX_SOD523_1D7_H28
  rect 0.635x0.508 smd: 1(0.87,0) 2(-0.87,0)
TX_SOD523_1D7_T01_H26
  rect 0.635x0.508 smd: 1(0.87,0) 2(-0.87,0)
TX_SOIC_8P_26_122X122
  rect 0.356x1.448 smd: 1(-0.975,-2.336) 2(-0.325,-2.336) 3(0.325,-2.336) 4(0.975,-2.336) 5(0.975,2.336) 6(0.325,2.336) 7(-0.325,2.336) 8(-0.975,2.336)
TX_SOIC_8P_50_213X213
  rect 0.61x1.88 smd: 1(-1.905,-3.62) 2(-0.635,-3.62) 3(0.635,-3.62) 4(1.905,-3.62) 5(1.905,3.62) 6(0.635,3.62) 7(-0.635,3.62) 8(-1.905,3.62)
TX_SOT23_2D4_122X55_H43
  rect 0.711x1.016 smd: 1(-0.95,-1.301) 2(0.95,-1.301) 3(0,1.301)
TX_SOT23_2D4_H43
  rect 0.711x1.016 smd: 1(-0.95,-1.301) 2(0.95,-1.301) 3(0,1.301)
TX_SOT23_2D4_H44
  rect 0.711x1.016 smd: 1(-0.95,-1.301) 2(0.95,-1.301) 3(0,1.301)
TX_SOT23_S5_2D4_122X67_H57
  rect 0.711x1.016 smd: 1(-0.95,-1.301) 2(0,-1.301) 3(0.95,-1.301) 4(0.95,1.301) 5(-0.95,1.301)
TX_SOT23_S5_2D4_H57
  rect 0.711x1.016 smd: 1(-0.95,-1.301) 2(0,-1.301) 3(0.95,-1.301) 4(0.95,1.301) 5(-0.95,1.301)
TX_SOT23_S5_2D4_T02X01_H57
  rect 0.711x1.016 smd: 1(-0.95,-1.301) 2(0,-1.301) 3(0.95,-1.301) 4(0.95,1.301) 5(-0.95,1.301)
TX_SOT23_S5_H57
  rect 1.118x0.61 smd: 1(1.45,-0.95) 2(1.45,0) 3(1.45,0.95) 4(-1.45,0.95) 5(-1.45,-0.95)
TX_SOT323
  rect 0.914x0.813 smd: 1(0.97,-0.65) 2(0.97,0.65) 3(-0.97,0)
TX_SOT323_PAN
  rect 1.168x0.813 smd: 1(1.097,-0.65) 2(1.097,0.65) 3(-1.097,0)
TX_SOT323_T01X02
  rect 0.914x0.813 smd: 1(0.97,-0.65) 2(0.97,0.65) 3(-0.97,0)
TX_SOT363_PHILIPS
  rect 0.356x0.94 smd: 1(-0.65,-1.19) 2(0,-1.19) 3(0.65,-1.19) 4(0.65,1.19) 5(0,1.19) 6(-0.65,1.19)
TX_WTOB_2P_49_2H_ACES_H138
  rect 0.787x1.6 smd: 1(0.625,2.9) 2(-0.625,2.9)
  rect 2.108x2.997 smd: 3(3.175,0) 4(-3.175,0)
TX_WTOB_4P_39_2HD_RA_COLAY
  rect 0.61x1.651 smd: 1(1.5,3.826) 2(0.5,3.826) 3(-0.5,3.826) 4(-1.5,3.826)
  rect 1.194x2.007 smd: 5(-2.8,0) 6(2.8,0)
TX_WTOB_7P_49_2HD_RA_ACES
  rect 0.787x1.905 smd: 1(3.75,4.925) 2(2.5,4.925) 3(1.25,4.925) 4(0,4.925) 5(-1.25,4.925) 6(-2.5,4.925) 7(-3.75,4.925)
  rect 1.295x3.353 smd: 8(6.6,0) 9(-6.6,0)
TX_WTOB_10P_79_2HOLD_ACES
  rect 0.559x1.803 smd: 1(9,5.275) 2(7,5.275) 3(5,5.275) 4(3,5.275) 5(1,5.275) 6(-1,5.275) 7(-3,5.275) 8(-5,5.275) 9(-7,5.275) 10(-9,5.275)
  rect 1.295x2.057 smd: 11(12.1,0) 12(-12.1,0)
TX_WTOB_20P_20_4HOLD
  rect 0.254x1.295 smd: 1(4.75,1.95) 2(4.25,1.95) 3(3.75,1.95) 4(3.25,1.95) 5(2.75,1.95) 6(2.25,1.95) 7(1.75,1.95) 8(1.25,1.95) 9(0.75,1.95) 10(0.25,1.95) 11(-0.25,1.95) 12(-0.75,1.95) 13(-1.25,1.95) 14(-1.75,1.95) 15(-2.25,1.95) 16(-2.75,1.95) 17(-3.25,1.95) 18(-3.75,1.95) 19(-4.25,1.95) 20(-4.75,1.95)
  rect 1.194x3.2 smd: 21(-7.15,0) 22(7.15,0)
  rect 2.311x1.295 smd: 23(-3.9,-1.95) 24(3.9,-1.95)
TX_XTAL_2P_126X59
  rect 0.991x1.803 smd: 1(-1.25,0) 2(1.25,0)
TX_XTAL_4P_126X98_HELE
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)
TX_XTAL_4P_126X98_HELE_H35
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)
unnamed#2
  custom 0.286x0.286 smd: 1(0,0)
VX_R0805_SMALL_SHORT
  rect 0.813x1.397 smd: 1(-0.9,0) 2(0.9,0)
VX_SOD523_1D7
  rect 0.635x0.508 smd: 1(0.87,0) 2(-0.87,0)
WTOB_6P_39_2H_RA_CVI
  rect 0.61x1.549 smd: 1(2.5,3.875) 2(1.5,3.875) 3(0.5,3.875) 4(-0.5,3.875) 5(-1.5,3.875) 6(-2.5,3.875)
  rect 1.194x1.803 smd: 7(3.8,0) 8(-3.8,0)

## Nets
1.0VO_+1P8VSB_EN: PC8713.1 PR8701.2 PR8702.2 PR8712.2 PR8811.1 PT8704.1 PU8700.15(EN2)
1.0VO_BST: PR8703.2 PU8700.10(BST)
1.0VO_BST_R: PC8709.2 PR8703.1
1.0VO_FB: PR8707.2 PR8708.1 PR8709.2 PU8700.13(FB)
1.0VO_FB_R: PJP8700.1 PR8707.1
1.0VO_LX: PC8709.1 PL8700.1 PR8704.2 PR8710.1 PT8700.1 PU8700.9(SW)
1.0VO_RC: PC8706.1 PR8704.1
1.8VO_VGA_EN: PC9507.1 PR9503.2 PU9500.7(EN)
1.8VO_VGA_FB: PC9508.1 PR9502.1 PR9504.1 PU9500.1(FB)
1.8VO_VGA_FB_R: PC9508.2 PJP9502.2 PR9504.2
1.8VO_VGA_LX: PL9500.1 PR9501.2 PT9501.1 PU9500.6(LX)
1.8VO_VGA_RC: PC9506.1 PR9501.1
1.8VO_VGA_VIN: PC9500.1 PC9501.1 PC9502.1 PJP9500.2 PU9500.3(IN)
1.35VO_EN: PC9809.1 PD9800.1(ANODE) PR9814.2 PU9800.5(EN)
5VSB_EN1: PC8917.1 PU8900.20(EN1) R2410.1
+0.95V_GPU: C6723.1 C6735.1 C6736.1 C6737.1 C6738.1 C6739.1 C6741.1 C6754.1 C7101.1 C7103.1 L6701.1 PJP9504.2 R6007.2 R6008.2 R7201.2 U6000.AD14(DP_VDDC) U6000.L23(PCIE_VDDC_1) U6000.L24(PCIE_VDDC_2) U6000.L25(PCIE_VDDC_3) U6000.L26(PCIE_VDDC_4) U6000.M22(PCIE_VDDC_5) U6000.N22(PCIE_VDDC_6) U6000.N23(PCIE_VDDC_7) U6000.N24(PCIE_VDDC_8) U6000.R21(BIF_VDDC_1) U6000.R22(PCIE_VDDC_9) U6000.T22(PCIE_VDDC_10) U6000.U21(BIF_VDDC_2) U6000.U22(PCIE_VDDC_11) U6000.V22(PCIE_VDDC_12)
+0.95V_GPU_DISCH_A: Q7201.3(DRAIN) R7201.1
+0.95VO_VGA_PWRGD: PR9456.1 PR9505.2 PT9508.1 PU9501.4(PGOOD)
+1.0VO: PC8701.1 PC8702.1 PC8703.1 PC8704.1 PC8707.1 PC8708.1 PC8710.1 PC8711.1 PC8712.1 PJP8700.2 PJP8701.1 PL8700.2 PT8701.1 PU8700.6(VDDQ)
+1.8VALW_EC: C2309.1 R2331.1 R2336.2 U2300.54(VTR_33_18)
+1.8VO_VGA: PC9503.1 PC9504.1 PC9505.1 PJP9501.1 PJP9502.1 PL9500.2 PT9502.1 PT9503.1 PT9504.1
+1.8VO_VGA_PWRGD: PR9421.1 PR9500.2 PR9508.1 PT9500.1 PU9500.2(PG)
+1.8VS_VGA: C6700.1 C6722.1 C6740.1 C6908.1 C7100.1 C7102.1 L6700.1 L6702.1 PC9402.1 PJP9501.2 PR9401.1 PR9402.1 PR9403.1 PR9409.1 PR9416.1 R6200.1 R6203.1 R6205.1 R6207.1 R6910.1 R6911.1 R7202.2 U6000.AA20(VDD_GPIO18_1) U6000.AA21(VDD_GPIO18_2) U6000.AB20(VDD_GPIO18_3) U6000.AB21(VDD_GPIO18_4) U6000.AD17(TSVDD) U6000.AF14(DP_VDDR) U6000.AM30(PCIE_PVDD)
+1.8VS_VGA_DISCH_A: Q7202.3(DRAIN) R7202.1
+1VSB: PC9200.1 PC9206.1 PJP8701.2 PR9203.1 PR9204.1 PR9209.1 PT8702.1 PT8703.1 PU9200.1(VIN1) PU9200.7(VIN2) R1600.1 R1601.1 R1609.1 R1612.1 R1613.1 R1620.1
+1VSB_PWRGD: PU8700.12(PG) R1800.1 U1201.1(INB)
+1VSB_VIN: PC8700.1 PC8714.1 PC8715.2 PR8700.2 PU8700.1(VIN)
+1VSUS_ORG: C1605.1 C1627.1 R1602.1 R1613.2 R1621.2 R1625.1 U0400.K17(VCCMPHYAON_1P0_1) U0400.L1(VCCMPHYAON_1P0_2)
+3V_CCG4_TYPEC: D5800.3(CATHODE) R5816.1 R5823.1
+3V_CCG4_TYPEC_LDO: C5810.1 D5800.2(ANODE2) R5819.1 U5802.5(VOUT)
+3V_CCG4_VDDD: C5801.1 C5802.1 C5803.1 R5802.2 R5816.2 U5800.31(VDDD) U5800.32(VDDIO)
+3VALW_EC: C2300.1 C2301.1 C2302.1 C2303.1 C2304.1 C2305.1 C2306.1 C2307.1 C2316.1 R1917.1 R1918.1 R2301.2 R2312.2 R2314.1 R2318.1 R2319.1 R2320.1 R2324.1 R2326.1 R2333.1 R2334.1 R2335.1 R2337.1 R2338.1 R2342.1 R2343.1 R2347.1 R2348.1 R2349.1 R2351.2 R2412.1 R3709.1 T2309.1 U2300.5(VTR_1) U2300.19(VTR_2) U2300.22(DAC_VREF) U2300.43(VTR_3) U2300.65(VTR_4) U2300.82(VTR_5) U2300.103(VTR_6) U2300.115(ADC_VREF)
+3VS_VGA: C6016.1 C6701.1 C6907.1 Q6900.2(GATE) Q6900.5(GATE) R6912.1 R6913.1 R6934.1 R6935.1 R6938.1 R6943.1 R7005.1 U6000.AA17(VDD_GPIO33_1) U6000.AA18(VDD_GPIO33_2) U6000.AB17(VDD_GPIO33_3) U6000.AB18(VDD_GPIO33_4) U6001.5(VCC) U6903.5(VCC)
+3VS_VGA__CT: C7007.1 U7000.10(CT2)
+3VS_VGA_EN: R7003.1 R7004.2 U7000.5(EN2)
+3VS_VGA_OUT: C7008.1 R7005.2 U7000.8(OUT2)
+3VSUS_ORG: C1608.1 C1613.1 C1614.1 C1634.1 PR9105.2 R1402.1 R1403.1 R1404.1 R1405.1 R1503.1 R1506.1 R1513.1 R1514.1 R1519.1 R1604.1 R1615.1 R1622.1 R1624.2 U0400.AJ16(VCCSPI) U0400.AJ21(VCCPRIM_3P3_1) U0400.AK17(VCCRTCPRIM_3P3) U0400.V19(VCCPRIM_3P3_2)
+5V: C3827.1 C3828.1 D3804.1(ANODE) F5100.1 L3805.1 L3806.1 PC7900.1 PC7909.1 PC8002.1 PC8006.1 PR7801.2 PR7808.1 PR7811.1 PR9111.1 PR9413.2 PR9414.1 PU7900.6(VCC) PU7901.6(VCC) PU8000.6(VCC) PU8001.6(VCC) Q2401.2(GATE) Q2600.3(DRAIN) R1913.1 R1920.1 R3108.1 R3600.1 R3611.1 R3714.1 R5824.1 U3100.5(IN) U5100.1
+5V_3V_VCLK: PR8923.2 PU8900.19(VCLK)
+5V_3V_VIN: PC8901.1 PR8900.2 PU8900.12(VIN)
+5V_ANALOG: C3819.1 C3820.1 C3829.1 L3806.2 U3800.40(AVDD1)
+5V_CCG4: C5814.1 R5800.2 R5801.2 U5801.5(IN)
+5V_CCG4_SWITCH: C5811.1 C5812.1 C5813.1 U5800.8(V5V_P1) U5801.1(OUT)
+5V_FAN: C3600.1 C3601.1 CON3600.1 R3600.2
+5V_HDD: C3124.1 C3125.1 C3127.1 CON3101.10 CON3101.11 CON3101.12 R3108.2 U3100.1(OUT)
+5V_HDMI: D2902.3(ANODE) F2600.2 Q2600.2(SOURCE) R2601.1
+5V_KB: C5125.1 CON5101.1 F5100.2
+5V_PVDD: C3804.1 C3805.1 C3806.1 C3832.1 L3805.2 U3800.41(PVDD1) U3800.46(PVDD2)
+5V_USB: CON5103.45 CON5103.46 U5101.1(OUT)
+5VA: C7001.1 PC8902.1 PC9101.1 PC9205.1 PU8900.13(LDO5) PU9101.4(BIAS) PU9200.4(BIAS) U7000.4(VBIAS)
+5VSB: C5124.1 C5907.1 C5908.1 C5909.1 C5910.1 C5911.1 C5913.1 CON5103.47 CON5103.48 CON5103.49 CON5103.50 LED5000.2 PC9001.1 PC9110.1 PC9111.1 PD7601.2(CATHODE) PJP8902.2 PR7609.1 PR8600.1 PR8908.2 PU9001.4(BIAS) PU9100.1(VIN1) PU9100.4(BIAS) R1915.1 R5801.1 U5101.5(IN) U5900.1(IN)
+5VSB&+3P3VSB_IN: PC8905.1 PC8906.1 PC8914.1 PC8915.1 PC8924.1 PC8925.1 PQ8900.2(D1_1) PQ8900.3(D1_2) PQ8900.4(D1_3) PQ8900.10(D1_4) PQ8901.2(D1_1) PQ8901.3(D1_2) PQ8901.4(D1_3) PQ8901.10(D1_4) PR8900.1 PR8901.1 PR8913.1 PR8916.1
+5VSB_BST1_C: PC8904.1 PR8902.2
+5VSB_BST_C: PR8902.1 PU8900.17(BOOT1)
+5VSB_CS1_A: PR8909.2 PU8900.1(CS1)
+5VSB_FB_A: PC8912.2 PR8910.2 PR8911.1 PU8900.2(FB1)
+5VSB_FBR_A: PC8912.1 PC8913.1 PJP8900.2 PR8910.1
+5VSB_HG_D: PR8903.1 PU8900.16(UGATE1)
+5VSB_HGR_D: PC8907.1 PQ8900.1(G1) PR8903.2 PR8904.1
+5VSB_LG_D: PR8905.1 PU8900.15(LGATE1)
+5VSB_LGR_D: PC8910.1 PQ8900.8(G2) PR8905.2 PR8906.1
+5VSB_PHASE1_S: PC8904.2 PC8907.2 PL8900.1 PQ8900.9(S1/D2) PR8904.2 PR8907.1 PU8900.18(PHASE1)
+5VSB_SN_S: PC8908.1 PR8907.2
+5VSB_VO: PC8911.1 PR8908.1 PU8900.14(BYP1)
+19VADC_VIN: CON7600.5 CON7600.6 CON7600.7 PC7605.1 PC7607.1 PL7600.1 PL7601.1 PL7602.1
+VBATT: L3601.1 L3602.1 L3603.1 PQ7701.5(DRAIN) PR7715.2
+VBATT_F: CON3601.1 CON3601.2 CON3601.3 L3601.2 L3602.2 L3603.2
+VCC_RTC: C3605.1 C3807.1 D3604.2(CATHODE) D3605.2(CATHODE) Q2406.2(SOURCE) R2308.1 R2310.1 R2339.1 R2428.2 R3804.1 T3600.1
+VCC_RTC_PCH: Q2406.3(DRAIN) R1009.1 R1011.1 R1206.1 R1623.2 R2415.2 R2428.1
+VCCDSW_3P3: R1200.1 R1203.1 R1204.1 R1209.1 R1214.1 R1622.2 U0400.AD17(VCCDSW_3P3_1) U0400.AD18(VCCDSW_3P3_2) U0400.AJ17(VCCDSW_3P3_3)
+VCCGT: C0720.1 C0721.1 C0722.1 C0723.1 C0724.1 C0725.1 C0726.1 C0727.1 C0728.1 C0729.1 C0730.1 C0731.1 C0732.1 C0733.1 PC8137.1 PC8138.1 PC8139.1 PC8140.1 PC8141.1 PC8142.1 PC8143.1 PC8144.1 PC8145.1 PC8146.1 PC8147.1 PC8148.1 PC8149.1 PC8150.1 PC8151.1 PC8152.1 PC8153.1 PC8154.1 PC8155.1 PC8156.1 PC8163.1 PC8164.1 PC8165.1 PC8166.1 PC8167.1 PC8168.1 PC8169.1 PC8170.1 PC8171.1 PC8172.1 PC8173.1 PC8174.1 PC8175.1 PC8176.1 PC8177.1 PC8183.1 PC8184.1 PC8185.1 PC8186.1 PC8187.1 PJP8003.2 PL8001.2 R0701.1 R0703.2 U0400.A58(VCCGT_3) U0400.A62(VCCGT_4) U0400.A66(VCCGT_5) U0400.AA63(VCCGT_6) U0400.AA64(VCCGT_7) U0400.AA66(VCCGT_8) U0400.AA67(VCCGT_9) U0400.AA69(VCCGT_10) U0400.AA70(VCCGT_11) U0400.AA71(VCCGT_12) U0400.AC64(VCCGT_13) U0400.AC65(VCCGT_14) U0400.AC66(VCCGT_15) U0400.AC67(VCCGT_16) U0400.AC68(VCCGT_17) U0400.AC69(VCCGT_18) U0400.AC70(VCCGT_19) U0400.AC71(VCCGT_20) U0400.J53(VCCGT_27) U0400.J55(VCCGT_28) U0400.J56(VCCGT_29) U0400.J58(VCCGT_30) U0400.J60(VCCGT_31) U0400.K53(VCCGT_35) U0400.K55(VCCGT_36) U0400.K56(VCCGT_37) U0400.K58(VCCGT_38) U0400.K60(VCCGT_39) U0400.L62(VCCGT_40) U0400.L63(VCCGT_41) U0400.L64(VCCGT_42) U0400.L65(VCCGT_43) U0400.L66(VCCGT_44) U0400.L67(VCCGT_45) U0400.L68(VCCGT_46) U0400.L69(VCCGT_47) U0400.L70(VCCGT_48) U0400.L71(VCCGT_49) U0400.M62(VCCGT_50) U0400.N63(VCCGT_51) U0400.N64(VCCGT_52) U0400.N66(VCCGT_53) U0400.N67(VCCGT_54) U0400.N69(VCCGT_55) U0400.N70(VCCGT_56) U0400.N71(VCCGT_57) U0400.R63(VCCGT_58) U0400.R64(VCCGT_59) U0400.R65(VCCGT_60) U0400.R66(VCCGT_61) U0400.R67(VCCGT_62) U0400.R68(VCCGT_63) U0400.R69(VCCGT_64) U0400.R70(VCCGT_65) U0400.R71(VCCGT_66) U0400.T62(VCCGT_67) U0400.U65(VCCGT_68) U0400.U68(VCCGT_69) U0400.U71(VCCGT_70) U0400.W63(VCCGT_71) U0400.W64(VCCGT_72) U0400.W65(VCCGT_73) U0400.W66(VCCGT_74) U0400.W67(VCCGT_75) U0400.W68(VCCGT_76) U0400.W69(VCCGT_77) U0400.W70(VCCGT_78) U0400.W71(VCCGT_79) U0400.Y62(VCCGT_80)
+VCCGT_BT_D: PR8007.1 PU8001.2(BOOT)
+VCCGT_CSN_A: PC7809.2 PC7810.2 PC7811.2 PC7813.1 PR7807.2 PR7810.2 PR8010.2 PRT7801.2
+VCCGT_CSP_A: PC7809.1 PC7810.1 PR7805.1 PR7807.1 PR8009.2 PU7800.19(ISUMP_A)
+VCCGT_FCCM: PR8015.2 PU8001.7(FCCM)
+VCCGT_HG_D: PR8006.1 PU8001.1(UGATE)
+VCCGT_LG_D: PR8012.1 PU8001.5(LGATE)
+VCCGT_PHASE_D: PC8010.2 PC8011.2 PQ8001.2(GR) PR8011.2 PU8001.8(PHASE)
+VCCGT_PWM: PR8016.2 PU8001.3(PWM)
+VCCGT_R_BT_D: PC8011.1 PR8007.2
+VCCGT_R_HG_D: PC8010.1 PQ8001.1(HSG) PR8006.2 PR8011.1
+VCCGT_R_LG_D: PC8013.1 PQ8001.8(LSG) PR8012.2
+VCCGT_SN_C: PC8012.1 PR8008.2
+VCCIO: C0607.1 C0608.1 C0609.1 C0610.1 PR9206.1 R0413.2 U0400.AK28(VCCIO_1) U0400.AK30(VCCIO_2) U0400.AL30(VCCIO_3) U0400.AL42(VCCIO_4) U0400.AM28(VCCIO_5) U0400.AM30(VCCIO_6) U0400.AM42(VCCIO_7)
+VCCPGPP: C1601.1 C1602.1 C1603.1 R1624.1 U0400.AD15(VCCPGPPG) U0400.AG15(VCCPGPPB) U0400.T16(VCCPGPPE) U0400.Y15(VCCPGPPD) U0400.Y16(VCCPGPPC)
+VCCPLL_OC: C0621.1 PR9002.1 U0400.AL23(VCCPLL_OC)
+VCCPRIM_CORE: C1604.1 C1630.1 C1631.1 C1632.1 C1633.1 PR9203.2 PR9204.2 PR9209.2 U0400.AF18(VCCPRIM_CORE_1) U0400.AF19(VCCPRIM_CORE_2) U0400.V20(VCCPRIM_CORE_3) U0400.V21(VCCPRIM_CORE_4)
+VCCSA: C0611.1 C0613.1 C0614.1 C0615.1 C0616.1 C0617.1 C0618.1 PC8111.1 PC8112.1 PC8113.1 PC8114.1 PC8115.1 PC8116.1 PC8117.1 PC8157.1 PC8158.1 PC8159.1 PC8160.1 PC8161.1 PC8162.1 PJP8001.2 PL8000.2 R0608.2 U0400.AK23(VCCSA_1) U0400.AK25(VCCSA_2) U0400.G23(VCCSA_3) U0400.G25(VCCSA_4) U0400.G27(VCCSA_5) U0400.G28(VCCSA_6) U0400.J22(VCCSA_7) U0400.J23(VCCSA_8) U0400.J27(VCCSA_9) U0400.K23(VCCSA_10) U0400.K25(VCCSA_11) U0400.K27(VCCSA_12) U0400.K28(VCCSA_13) U0400.K30(VCCSA_14)
+VCCSA_BT_D: PR8000.1 PU8000.2(BOOT)
+VCCSA_CSN_A: PC7827.2 PC7828.2 PC7829.1 PR7831.2 PR7835.1 PR7838.1 PR8005.2 PRT7802.2
+VCCSA_CSP_A: PC7827.1 PC7828.1 PR7827.1 PR7831.1 PR8004.2 PU7800.27(ISUMP_C)
+VCCSA_FCCM: PR8013.2 PU8000.7(FCCM)
+VCCSA_HG_D: PR8001.1 PU8000.1(UGATE)
+VCCSA_LG_D: PR8003.1 PU8000.5(LGATE)
+VCCSA_PHASE_D: PC8000.2 PC8004.2 PJP8000.2 PL8000.1 PQ8000.9(S1/D2) PR8002.2 PU8000.8(PHASE)
+VCCSA_PWM: PR8014.2 PU8000.3(PWM)
+VCCSA_R_BT_D: PC8000.1 PR8000.2
+VCCSA_R_HG_D: PC8004.1 PQ8000.1(G1) PR8001.2 PR8002.1
+VCCSA_R_LG_D: PC8005.1 PQ8000.8(G2) PR8003.2
+VCCST: C0619.1 C0622.1 C0623.1 PC7836.1 PR7846.2 PR7847.2 PR9202.1 R0417.1 R0601.2 R0602.2 R0902.2 R1224.1 R2321.2 U0400.A18(VCCST) U0400.K20(VCCPLL_1) U0400.K21(VCCPLL_2)
+VCCSTG: C0620.1 PR9208.1 R0400.1 R0401.2 R0402.2 R0403.2 U0400.A22(VCCSTG_2) U0400.G20(VCCSTG_1)
+VDD: PC7713.1 PR7705.1 PR7706.1 PU7700.18(VDD)
+VDDC_COMP_A: PC9415.2 PR9454.1 PU9400.5(COMP)
+VDDC_COMP_FB_R_A: PC9415.1 PC9416.2 PR9432.2 PR9433.1 PU9400.6(FB)
+VDDC_COMP_L_A: PR9432.1 PR9454.2
+VDDC_HG1_2_D: PC9602.1 PQ9600.1(HSG) PR9603.2 PR9604.1
+VDDC_HG2_2_D: PC9624.1 PQ9601.1(HSG) PR9607.2 PR9608.1
+VDDC_IMON_A: PR9447.2 PU9400.14(IMON)
+VDDC_IMON_L_A: PR9445.1 PRT9401.2
+VDDC_IMON_R_A: PR9445.2 PR9446.2 PR9447.1
+VDDC_ISEN1P_R_A: PC9410.1 PC9424.1 PR9419.1 PR9420.1 PR9422.2 PU9400.9(ISEN1P)
+VDDC_ISEN2P_R_A: PC9412.1 PC9425.1 PR9424.1 PR9429.1 PR9431.2 PU9400.7(ISEN2P)
+VDDC_ISEN_A: PR9425.1 PR9428.1 PU9400.10(ISEN1N)
+VDDC_ISN1_A: PC9410.2 PC9411.1 PC9424.2 PJP9601.2 PR9422.1 PR9424.2 PR9425.2
+VDDC_ISN2_A: PC9412.2 PC9414.1 PC9425.2 PJP9603.2 PR9419.2 PR9428.2 PR9431.1
+VDDC_ISP1_A: PJP9600.2 PR9420.2
+VDDC_ISP2_A: PJP9602.2 PR9429.2
+VDDC_LG1_2_D: PC9605.1 PQ9600.8(LSG) PR9605.2
+VDDC_LG2_2_D: PC9627.1 PQ9601.8(LSG) PR9609.2
+VDDC_PWROK: PR9412.2 PR9815.1 U6903.4(OUT_Y)
+VDDC_PWROK_A: PR9412.1 PR9457.2 PU9400.18(PWROK)
+VDDC_SET1: PR9435.2 PR9438.1 PU9400.13(SET1)
+VDDC_SET1_R1_A: PR9434.2 PR9435.1
+VDDC_SET1_R2_A: PR9437.2 PR9438.2
+VDDC_SN1_A: PC9604.2 PR9606.1
+VDDC_SN2_A: PC9625.2 PR9610.1
+VDDC_TS_R1_A: PR9439.2 PR9440.1
+VDDC_TS_R2_A: PR9443.2 PR9444.1
+VDDC_TSEN: PR9442.2 PRT9400.2 PU9400.12(TSEN)
+VDDC_TSEN_A: PR9441.2 PR9442.1
+VDDC_TSEN_P: PR9440.2 PR9441.1 PR9444.2 PRT9400.1
+VDDC_VGA: C6702.1 C6703.1 C6704.1 C6705.1 C6706.1 C6707.1 C6708.1 C6709.1 C6710.1 C6711.1 C6712.1 C6713.1 C6714.1 C6715.1 C6716.1 C6717.1 C6724.1 C6725.1 C6726.1 C6727.1 C6728.1 C6729.1 C6730.1 C6731.1 C6742.1 C6743.1 C6744.1 C6745.1 PC9603.1 PC9606.1 PC9607.1 PC9608.1 PC9609.1 PC9610.1 PC9611.1 PC9612.1 PC9613.1 PC9614.1 PC9617.1 PC9618.1 PC9619.1 PC9620.1 PC9621.1 PC9622.1 PC9623.1 PC9626.1 PCE9600.1 PCE9601.1 PCE9602.1 PJP9601.1 PJP9603.1 PL9600.2 PL9601.2 PR9430.2 R7203.2 U6000.AA12(VDDC_1) U6000.AA15(VDDC_2) U6000.AB11(VDDC_3) U6000.AB12(VDDC_4) U6000.AB13(VDDC_5) U6000.AC11(VDDC_6) U6000.AC13(VDDC_7) U6000.AC14(VDDC_8) U6000.M11(VDDC_9) U6000.M13(VDDCI_1) U6000.M15(VDDCI_2) U6000.M16(VDDCI_3) U6000.M17(VDDCI_4) U6000.M18(VDDCI_5) U6000.M20(VDDCI_6) U6000.M21(VDDCI_7) U6000.N12(VDDC_10) U6000.N15(VDDC_11) U6000.N17(VDDC_12) U6000.N20(VDDCI_8) U6000.R13(VDDC_13) U6000.R16(VDDC_14) U6000.R18(VDDC_15) U6000.T10(VDDC_16) U6000.T12(VDDC_17) U6000.T15(VDDC_18) U6000.T17(VDDC_19) U6000.T20(VDDC_20) U6000.U10(VDDC_21) U6000.U11(VDDC_22) U6000.U13(VDDC_23) U6000.U16(VDDC_24) U6000.U18(VDDC_25) U6000.V15(VDDC_26) U6000.V17(VDDC_27) U6000.V20(VDDC_28) U6000.V21(VDDC_29) U6000.W9(VDDC_31) U6000.W10(VDDC_30) U6000.Y9(VDDC_36) U6000.Y13(VDDC_32) U6000.Y16(VDDC_33) U6000.Y18(VDDC_34) U6000.Y21(VDDC_35)
+VDDC_VGA_DISCH_A: Q7203.3(DRAIN) R7203.1
+VDDC_VIN: PC9600.1 PC9601.1 PC9615.1 PC9616.1 PQ9600.3(V+1) PQ9600.4(V+2) PQ9600.10(V+(HSD)) PQ9601.3(V+1) PQ9601.4(V+2) PQ9601.10(V+(HSD)) PR9408.2 PR9600.1 PR9601.1 PR9602.1
+VDDP: PC7714.1 PR7705.2 PU7700.8(VDDP)
+VDDQ_PWRGD: PC8609.1 PU8600.10(PGOOD) R1803.1
AGND: C3810.2 C3811.2 C3812.2 C3813.2 C3815.2 C3819.2 C3820.2 C3821.1 C3822.2 C3823.1 C3824.2 C3825.2 C3826.2 C3829.2 C3830.2 C3831.2 J3800.5 R3814.1 R3815.2 R3816.2 R3817.2 R3818.2 R3819.2 U3800.22(AVSS2) U3800.37(AVSS1)
