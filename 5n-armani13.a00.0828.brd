# Allegro board 5n-armani13.a00.0828.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_D9: length 58.7
  TOP w0.102: v2(65.99,85.3) 65.84,85.3 v1(65.25,85.88)
  IN1 w0.097: v1(65.25,85.88) 66.2,86.82 78.1,86.82 78.65,86.27 87.84,86.27 89.2,84.91 101.19,84.91 108.43,77.68 108.43,76.73 v1(108.63,76.53)
  BOTTOM w0.076: 109.02,75.26 109.02,74.78 109.38,74.42 109.38,73.92 109.57,73.73 109.57,72.69 109.35,72.48 109.35,71.89 109.25,71.79 109.25,71.6 U0400.AR68
  BOTTOM w0.102: 109.02,75.26 109.02,76.15 v1(108.63,76.53) ; CON2000.28 63.07,85.57 63.2,85.45 64.82,85.45 v1(65.25,85.88)
M_A_D10: length 56.4
  TOP w0.102: v1(65.28,82.51) 65.76,83 v2(65.76,83.16)
  IN1 w0.097: v1(65.28,82.51) 65.85,81.95 69.75,81.95 70.47,82.67 75.8,82.67 75.97,82.5 76.21,82.5 76.38,82.67 76.58,82.67 76.67,82.58 76.67,81.98 76.77,81.88 76.96,81.88 77.06,81.98 77.06,82.58 77.16,82.67 77.35,82.67 77.44,82.58 77.44,81.98 77.54,81.88 77.73,81.88 77.83,81.98 77.83,82.58 77.93,82.67 78.12,82.67 78.22,82.58 78.22,81.98 78.31,81.88 97.6,81.88 101.14,78.34 v1(104.37,78.34)
  BOTTOM w0.076: 106.45,75.26 106.45,75.22 106.95,74.72 106.95,74.42 107.68,73.69 107.68,73.47 U0400.AU71
  BOTTOM w0.102: CON2000.42 63.19,82.07 63.27,81.99 64.76,81.99 v1(65.28,82.51) ; v1(104.37,78.34) 106.1,78.34 106.22,78.21 106.22,76.46 106.39,76.3 106.39,75.33 106.45,75.26
M_A_D11: length 58.3
  TOP w0.102: v2(67.54,83.37) 67.54,83.05 v1(67.03,82.54)
  IN1 w0.097: v1(102.87,79.33) 99.69,82.51 87.93,82.51 87.15,82.51 87.02,82.63 87.02,83.19 86.89,83.31 86.63,83.31 86.53,83.22 86.53,82.6 86.43,82.51 86.24,82.51 86.14,82.6 86.14,83.22 86.05,83.31 85.86,83.31 85.76,83.22 85.76,82.6 85.66,82.51 85.47,82.51 85.37,82.6 85.37,83.22 85.28,83.31 85.08,83.31 84.99,83.22 84.99,82.6 84.89,82.51 84.7,82.51 84.6,82.6 84.6,83.22 84.5,83.31 84.31,83.31 84.21,83.22 84.21,82.75 84.12,82.65 83.92,82.65 83.83,82.75 83.83,83.22 83.73,83.31 67.8,83.31 v1(67.03,82.54)
  BOTTOM w0.076: 105.03,75.26 105.03,75.15 106.55,73.63 106.74,73.44 106.74,71.96 106.98,71.72 107.5,71.72 U0400.AU68
  BOTTOM w0.102: 105.03,75.26 105.03,76.13 102.87,78.29 v1(102.87,79.33) ; v1(67.03,82.54) 67.52,82.04 69.09,82.04 69.37,82.32 CON2000.41
M_A_D12: length 56.3
  TOP w0.102: v2(69.18,86.6) 68.45,85.88 v1(68.43,85.88)
  IN1 w0.097: v1(68.43,85.88) 68.43,85.52 68.55,85.4 69.14,85.4 69.39,85.65 72.17,85.65 72.27,85.74 72.27,86.06 72.37,86.16 72.56,86.16 72.66,86.06 72.66,85.74 72.75,85.65 72.95,85.65 73.04,85.74 73.04,86.1 73.14,86.2 73.33,86.2 73.43,86.1 73.43,85.74 73.52,85.65 73.72,85.65 73.81,85.74 73.81,86.1 73.91,86.2 74.1,86.2 74.2,86.1 74.2,85.74 74.3,85.65 74.49,85.65 74.59,85.74 74.59,86.1 74.68,86.2 74.88,86.2 74.97,86.1 74.97,85.74 75.07,85.65 75.26,85.65 75.36,85.74 75.36,86.1 75.45,86.2 75.65,86.2 75.74,86.1 75.74,85.74 75.84,85.65 76.03,85.65 76.13,85.74 76.13,86.1 76.23,86.2 76.42,86.2 76.52,86.1 76.52,85.74 76.61,85.65 87.59,85.65 88.94,84.29 100.93,84.29 107.61,77.61 107.61,75.45 v3(107.99,75.07)
  BOTTOM w0.076: U0400.AR71 109.14,73.67 109.05,73.75 109.05,74.21 108.56,74.7
  BOTTOM w0.102: v3(107.99,75.07) 108.36,74.7 108.56,74.7 ; CON2000.25 68.9,86.32 68.45,85.88 v1(68.43,85.88)
M_A_D13: length 58.5
  TOP w0.102: v2(62.66,85.3) 63.4,85.3 v1(63.98,85.88)
  IN1 w0.097: v1(63.98,85.88) 63.98,85.37 64.14,85.22 65.31,85.22 65.62,84.92 65.62,84.91 65.74,84.78 69.06,84.78 69.57,85.3 73.56,85.3 73.66,85.2 73.66,85.01 73.76,84.91 73.95,84.91 74.05,85.01 74.05,85.2 74.14,85.3 87.49,85.3 88.81,83.98 89.07,83.98 100.81,83.98 107.3,77.48 107.3,74.74 107.57,74.48 v3(107.95,74.48)
  BOTTOM w0.076: v3(107.95,74.48) 108.54,74.48 108.87,74.14 108.87,72.52 109.04,72.35 U0400.AR69
  BOTTOM w0.102: CON2000.24 63.29,86.57 v1(63.98,85.88)
M_A_D14: length 56.9
  TOP w0.102: v2(63.14,83.19) 63.31,83.19 v1(63.98,82.51)
  IN1 w0.097: v1(105.26,77.45) 101.5,77.45 97.38,81.57 75.34,81.57 75.25,81.67 75.25,82.26 75.15,82.36 74.96,82.36 74.86,82.26 74.86,81.67 74.77,81.57 74.57,81.57 74.48,81.67 74.48,82.26 74.38,82.36 74.19,82.36 74.09,82.26 74.09,81.67 73.99,81.57 73.8,81.57 73.7,81.67 73.7,82.26 73.61,82.36 73.41,82.36 73.32,82.26 73.32,81.67 73.22,81.57 73.03,81.57 72.93,81.67 72.93,81.67 72.83,81.77 72.64,81.77 72.55,81.67 72.55,81.67 72.45,81.57 69.68,81.57 69.62,81.63 64.86,81.63 v1(63.98,82.51)
  BOTTOM w0.076: U0400.AU70 107.51,72.98 107.51,73.62 106.78,74.35 106.78,74.65 106.2,75.24 106.2,75.26
  BOTTOM w0.102: v1(105.26,77.45) 105.26,76.83 105.41,76.68 105.74,76.68 106.2,76.22 106.2,75.26 ; CON2000.38 63.42,83.07 v1(63.98,82.51)
M_A_D15: length 56.8
  TOP w0.102: v2(68.33,81.82) v1(68.33,82.53)
  IN1 w0.097: v1(103.91,78.77) 101.19,78.77 97.77,82.19 88.06,82.19 88.05,82.19 83.52,82.19 83.42,82.29 83.42,82.89 83.32,82.98 83.13,82.98 83.03,82.89 83.03,82.29 82.94,82.19 82.74,82.19 82.65,82.29 82.65,82.89 82.55,82.98 82.36,82.98 82.26,82.89 82.26,82.29 82.16,82.19 81.97,82.19 81.88,82.29 81.88,82.89 81.78,82.98 81.59,82.98 81.49,82.89 81.49,82.29 81.39,82.19 81.2,82.19 81.1,82.29 81.1,82.89 81.01,82.98 80.81,82.98 80.72,82.89 80.72,82.29 80.62,82.19 80.43,82.19 80.33,82.29 80.33,82.89 80.23,82.98 80.04,82.98 79.94,82.89 79.94,82.29 79.85,82.19 79.66,82.19 79.56,82.29 79.56,82.89 79.46,82.98 79.27,82.98 79.17,82.89 79.17,82.85 79.08,82.76 78.88,82.76 78.79,82.85 78.79,82.89 78.69,82.98 68.78,82.98 v1(68.33,82.53)
  BOTTOM w0.076: 106.6,74.58 106.6,74.29 107.35,73.55 107.35,72.9 107.43,72.82 107.43,72.42 U0400.AU69
  BOTTOM w0.102: v1(68.33,82.53) 69.12,83.32 CON2000.37 ; v1(103.91,78.77) 103.56,78.41 103.56,78.08 105.18,76.46 105.69,76.46 105.89,76.25 105.89,75.29 106.6,74.58
M_A_D16: length 51.1
  IN1 w0.097: v1(95.35,75.59) 95.35,78.79 94.34,79.81 66.13,79.81 v1(65.33,80.61)
  BOTTOM w0.076: U0400.BB65 104.14,69.58
  BOTTOM w0.102: v1(65.33,80.61) 64.79,80.07 CON2000.50 ; v1(95.35,75.59) 95.76,75.19 95.76,74.4 96.43,73.73 98.44,73.73 98.76,74.04 101.19,74.04 v2(101.57,73.66) 101.9,73.66 102.75,72.81 102.75,70.96 104.14,69.58
M_A_D17: length 53.6
  TOP w0.102: v2(68.91,79.99) 68.91,80.12 v1(68.43,80.61)
  IN1 w0.097: v1(96.65,75.64) 96.65,76.16 96.55,76.26 95.98,76.26 95.89,76.35 95.89,76.55 95.95,76.62 95.98,76.64 96.55,76.64 96.65,76.74 96.65,76.93 96.55,77.03 95.77,77.03 95.67,77.13 95.67,77.32 95.77,77.42 96.55,77.42 96.65,77.51 96.65,77.7 96.55,77.8 95.77,77.8 95.67,77.9 95.67,78.09 95.77,78.19 96.55,78.19 96.65,78.28 96.65,78.62 95.13,80.14 68.9,80.14 v1(68.43,80.61)
  BOTTOM w0.076: U0400.AW65 106.31,69.89 105.66,69.89 105.62,69.94 105.46,70.01 105.17,70.01 105.09,69.97 104.9,69.97 104.81,70.01 104.31,70.01 104.23,70.08
  BOTTOM w0.102: CON2000.45 69.14,81.32 v1(68.43,80.61) ; v1(96.65,75.64) 97.54,74.75 101.88,74.75 103.13,73.5 103.13,71.19 104.23,70.08
M_A_D18: length 54.2
  IN1 w0.097: v1(88.75,75.66) 88.75,76.12 88.62,76.25 69.85,76.25 69.45,75.84 65.82,75.84 65.35,76.3 65.35,76.51 64.67,77.19 64.26,77.19 63.94,77.52 v1(63.94,78.67)
  BOTTOM w0.076: U0400.AW63 106.62,67.64 106.36,67.38 106.11,67.38 105.97,67.44 105.56,67.44 105.35,67.65 104.21,67.65 103.84,68.03 102.8,68.03
  BOTTOM w0.102: CON2000.58 63.43,78.07 63.94,78.58 v1(63.94,78.67) ; v1(88.75,75.66) 88.75,74.02 96.2,66.57 96.45,66.32 v2(99.68,66.32) 100.46,66.32 100.8,66.67 100.8,66.84 101.98,68.03 102.8,68.03
M_A_D19: length 53.6
  IN1 w0.097: v1(89.98,75.66) 89.98,75.99 89.41,76.56 69.72,76.56 69.32,76.15 66.22,76.15 65.23,77.14 v1(65.23,78.65)
  BOTTOM w0.076: U0400.AY63 105.7,68.08 105.59,68.08 105.32,67.82 104.27,67.82 103.9,68.19 102.88,68.19 102.85,68.23 101.9,68.23 101.86,68.19
  BOTTOM w0.102: v1(89.98,75.66) 89.98,73.24 96.46,66.75 v2(97.89,66.75) 100.42,66.75 101.86,68.19 ; v1(65.23,78.65) 65.23,78.18 64.12,77.07 CON2000.62
M_A_D20: length 52
  IN1 w0.097: v1(94.72,74.96) 94.72,77.9 93.13,79.49 65.23,79.49 v1(64.11,80.61)
  BOTTOM w0.076: 103.98,69.43 104.01,69.4 104.38,69.4 104.54,69.31 105.05,69.31 U0400.BA65
  BOTTOM w0.102: v1(94.72,74.96) 94.72,74.55 96.6,72.67 v2(97.23,72.67) 97.87,72.67 98.83,73.64 100.94,73.64 101.57,73 102.11,73 102.56,72.55 102.56,70.85 103.98,69.43 ; CON2000.46 63.64,81.07 v1(64.11,80.61)
M_A_D21: length 52.3
  IN1 w0.097: v1(67.21,80.61) 67.63,81.03 69.37,81.03 69.43,80.96 95.77,80.96 97.05,79.68 97.05,75.44 96.57,74.96 v1(96.19,74.96)
  BOTTOM w0.076: U0400.AY65 105.74,69.58 105.52,69.8 105.42,69.84 105.21,69.84 105.13,69.81 104.86,69.81 104.78,69.84 104.21,69.84 104.18,69.87
  BOTTOM w0.102: CON2000.49 69.35,80.32 69.22,80.19 67.63,80.19 v1(67.21,80.61) ; v1(96.19,74.96) 96.75,74.4 v2(96.9,74.4) 101.61,74.4 102.94,73.07 102.94,71.11 104.18,69.87
M_A_D22: length 52.7
  IN1 w0.097: v1(68.39,76.57) 68.81,76.99 69.22,76.99 69.31,76.9 72.89,76.9 72.99,77 72.99,77.55 73.09,77.64 73.28,77.64 73.38,77.55 73.38,77 73.47,76.9 73.66,76.9 73.76,77 73.76,77.55 73.86,77.64 74.05,77.64 74.15,77.55 74.15,77 74.24,76.9 74.44,76.9 74.53,77 74.53,77.55 74.63,77.64 74.82,77.64 74.92,77.55 74.92,77 75.02,76.9 75.21,76.9 75.31,77 75.31,77.55 75.4,77.64 75.6,77.64 75.69,77.55 75.69,77 75.79,76.9 75.98,76.9 76.08,77 76.08,77.55 76.17,77.64 76.37,77.64 76.46,77.55 76.46,77.26 76.56,77.17 76.75,77.17 76.85,77.26 76.85,77.55 77.01,77.71 89.16,77.71 v1(91.21,75.66)
  BOTTOM w0.076: 101.91,68.43 102.89,68.43 102.96,68.36 103.97,68.36 104.34,67.99 105.05,67.99 U0400.BA63
  BOTTOM w0.102: v1(68.39,76.57) 68.79,76.97 69.21,76.97 69.35,76.82 CON2000.63 ; 101.91,68.43 101.83,68.43 100.58,67.19 96.48,67.19 91.21,72.45 v2(91.21,72.82) v1(91.21,75.66)
M_A_D23: length 52.3
  TOP w0.102: v1(67.11,76.57) v2(66.47,76.57)
  IN1 w0.097: v1(67.11,76.57) 67.84,77.31 70.24,77.31 70.34,77.4 70.34,77.88 70.44,77.98 70.63,77.98 70.73,77.88 70.73,77.4 70.82,77.31 71.02,77.31 71.11,77.4 71.11,77.88 71.21,77.98 71.4,77.98 71.5,77.88 71.5,77.4 71.6,77.31 71.79,77.31 71.89,77.4 71.89,77.88 71.98,77.98 72.18,77.98 72.27,77.88 72.27,77.77 72.37,77.68 72.56,77.68 72.66,77.77 72.66,77.88 72.8,78.02 89.46,78.02 v1(91.82,75.66)
  BOTTOM w0.076: 102.9,68.66 103.03,68.52 104.04,68.52 104.31,68.25 U0400.BB63
  BOTTOM w0.102: CON2000.59 68.36,77.82 v1(67.11,76.57) ; v1(91.82,75.66) 91.82,72.47 96.79,67.5 100.62,67.5 101.78,68.66 102.9,68.66
M_A_D24: length 51.8
  IN1 w0.097: v1(68.35,73.43) 69.14,74.22 70.71,74.22 70.81,74.32 70.81,74.82 70.9,74.92 71.1,74.92 71.19,74.82 71.19,74.32 71.29,74.22 71.48,74.22 71.58,74.32 71.58,74.82 71.67,74.92 71.87,74.92 71.96,74.82 71.96,74.32 72.06,74.22 72.25,74.22 72.35,74.32 72.35,74.82 72.45,74.92 72.64,74.92 72.74,74.82 72.74,74.32 72.83,74.22 73.03,74.22 73.12,74.32 73.12,74.82 73.22,74.92 73.41,74.92 73.51,74.82 73.51,74.78 73.6,74.68 73.8,74.68 73.89,74.78 73.89,74.82 74.09,75.02 87.65,75.02 88.19,74.48 91.84,74.48 92.75,73.56 92.76,73.56 92.78,73.54 96.98,73.54 96.99,73.55 98.21,74.77 98.44,75 101.79,75 102.82,73.96 102.82,71.3 102.82,71.05 102.82,69.02 103.61,68.24 v3(103.61,67.62)
  BOTTOM w0.076: U0400.BA61 105.05,67.49 103.74,67.49 v3(103.61,67.62)
  BOTTOM w0.102: CON2000.79 68.48,72.82 68.35,72.95 v1(68.35,73.43)
M_A_D25: length 54.1
  TOP w0.102: v2(68.09,75.93) 68.3,75.72 v1(68.3,75.33)
  IN1 w0.097: v1(68.3,75.33) 68.74,74.9 69.54,74.9 70.28,75.64 87.91,75.64 88.44,75.1 92.11,75.1 93.04,74.17 96.64,74.17 99.18,76.71 102.06,76.71 103.45,75.31 103.45,70 104.65,68.81 104.65,67.13 104.47,66.95 103.96,66.95 v3(103.58,66.58)
  BOTTOM w0.076: U0400.AW61 106.33,66.83 105.56,66.83 105.43,66.79 105.19,66.79 105.1,66.83 104.88,66.83 104.8,66.79 104.44,66.79 104.29,66.94 103.95,66.94 v3(103.58,66.58)
  BOTTOM w0.102: v1(68.3,75.33) 68.79,75.82 CON2000.67
M_A_D26: length 52.1
  IN1 w0.097: v1(101.45,66.91) 101.01,67.35 98.72,67.35 94.31,71.76 92.01,71.76 91.07,72.69 80.34,72.69 80.22,72.58 80.22,72.26 80.13,72.16 79.93,72.16 79.84,72.26 79.84,72.58 79.74,72.67 79.55,72.67 79.45,72.58 79.45,72.03 79.36,71.94 79.16,71.94 79.07,72.03 79.07,72.58 78.97,72.67 78.78,72.67 78.68,72.58 78.68,72.03 78.58,71.94 78.39,71.94 78.29,72.03 78.29,72.58 78.2,72.67 78,72.67 77.91,72.58 77.91,72.03 77.81,71.94 77.62,71.94 77.52,72.03 77.52,72.58 77.43,72.67 77.23,72.67 77.14,72.58 77.14,72.03 77.04,71.94 76.85,71.94 76.75,72.03 76.75,72.58 76.65,72.67 76.46,72.67 76.36,72.58 76.36,72.03 76.27,71.94 76.07,71.94 75.98,72.03 75.98,72.58 75.88,72.67 75.69,72.67 75.59,72.58 75.59,72.03 75.49,71.94 75.3,71.94 75.21,72.03 75.21,72.42 75.11,72.52 74.92,72.52 74.82,72.42 74.82,72.03 74.72,71.94 74.53,71.94 74.43,72.03 74.43,72.4 74.34,72.5 74.14,72.5 74.05,72.4 74.05,72.03 73.95,71.94 70.18,71.94 69.43,71.19 68.5,71.19 68.4,71.29 v1(68.4,71.6)
  BOTTOM w0.076: 101.72,65.85 102.01,65.56 102.87,65.56 103.16,65.85 104.62,65.85 104.65,65.88 U0400.BB59
  BOTTOM w0.102: v1(68.4,71.6) 68.81,72 69.21,72 69.38,71.82 CON2000.83 ; v1(101.45,66.91) 101.45,66.12 101.72,65.85
M_A_D27: length 54.2
  IN1 w0.097: v1(65.94,73.33) 65.71,73.1 65.71,71.87 66.33,71.25 68,71.25 68.37,70.88 69.56,70.88 70.19,71.51 80.59,71.51 80.68,71.6 80.68,72.29 80.78,72.38 80.97,72.38 81.07,72.29 81.07,71.6 81.16,71.51 81.36,71.51 81.45,71.6 81.45,72.29 81.55,72.38 81.74,72.38 81.84,72.29 81.84,72.11 81.94,72.01 82.13,72.01 82.23,72.11 82.23,72.29 82.32,72.38 90.94,72.38 91.88,71.45 94.17,71.45 98.59,67.02 100.75,67.02 101.88,65.89 102.72,65.89 v3(103.44,65.17)
  BOTTOM w0.076: U0400.AW59 106.35,66.16 105.87,66.16 105.78,66.13 105.63,65.98 105.63,65.79 105.5,65.66 105.45,65.63 105.13,65.63 104.99,65.54 104.98,65.53 arc(104.93,65.52) 104.89,65.51 104.86,65.48 arc(104.82,65.47) 104.79,65.47 104.2,65.47 104.15,65.52 103.8,65.52 v3(103.44,65.17)
  BOTTOM w0.102: CON2000.70 64.2,75.07 v1(65.94,73.33)
M_A_D28: length 52.3
  TOP w0.102: v1(63.96,76.57) v2(63.96,77.35)
  IN1 w0.097: v3(103.05,67.6) 103.23,67.78 103.23,67.78 103.24,67.79 103.24,68.16 102.51,68.89 102.51,71.05 102.51,71.3 102.51,72.1 100.46,74.15 98.82,74.15 97.93,73.26 97.92,73.26 97.89,73.23 92.65,73.23 92.63,73.25 92.62,73.25 92.62,73.26 92.61,73.26 91.7,74.17 73.41,74.17 73.16,73.91 70,73.91 69.09,73 67.56,73 67.34,73.23 67.34,74.25 66.37,75.21 65.32,75.21 v1(63.96,76.57)
  BOTTOM w0.076: U0400.BB61 104.48,67.22 104.43,67.27 103.78,67.27 103.74,67.24 103.41,67.24 v3(103.05,67.6)
  BOTTOM w0.102: CON2000.66 63.46,76.07 v1(63.96,76.57)
M_A_D29: length 53.8
  TOP w0.102: v2(66.95,74.63) v1(67.67,75.34)
  IN1 w0.097: v1(67.67,75.34) 68.43,74.58 69.93,74.58 70.68,75.33 87.78,75.33 88.31,74.79 91.97,74.79 92.91,73.85 96.77,73.85 98.23,75.31 102.03,75.31 103.14,74.21 103.14,69.15 104.27,68.02 104.27,67.46 104.15,67.34 103.86,67.34 103.58,67.06 103.51,67.06 v3(103,66.55)
  BOTTOM w0.076: v3(103,66.55) 103.42,66.97 103.74,66.97 103.88,67.11 104.36,67.11 104.51,66.96 104.77,66.96 104.85,66.99 105.13,66.99 105.22,66.96 105.41,66.96 105.57,67.01 105.68,67.12 U0400.AY61
  BOTTOM w0.102: v1(67.67,75.34) 68.18,74.82 CON2000.71
M_A_D30: length 53.6
  TOP w0.102: v2(63.78,70.5) 63.78,70.92 v1(63.97,71.11)
  IN1 w0.097: v3(102.86,65.15) 102.44,65.57 101.73,65.57 100.59,66.71 98.45,66.71 94.03,71.13 91.75,71.13 90.81,72.07 83.12,72.07 82.68,71.63 82.68,71.5 82.58,71.4 82.39,71.4 82.29,71.5 82.29,71.56 82.2,71.66 82,71.66 81.91,71.56 81.91,71.29 81.81,71.19 70.32,71.19 69.69,70.57 66.01,70.57 65.88,70.7 65.88,71.26 65.56,71.58 64.38,71.58 64.27,71.68 64.27,71.97 64.38,72.07 65.02,72.07 65.13,72.18 65.13,72.47 65.02,72.57 63.68,72.57 63.58,72.47 63.58,71.5 v1(63.97,71.11)
  BOTTOM w0.076: 103.38,65.66 103.4,65.69 104.22,65.69 104.27,65.63 104.71,65.63 arc(104.81,65.65) 104.9,65.71 105.09,65.9 U0400.BA59
  BOTTOM w0.102: 103.38,65.66 v3(102.86,65.15) ; v1(63.97,71.11) 63.51,71.57 CON2000.84
M_A_D31: length 53.7
  IN1 w0.097: v1(101.68,65.15) 101.68,65.18 100.46,66.4 98.32,66.4 93.9,70.82 91.62,70.82 90.69,71.76 83.54,71.76 82.65,70.87 70.44,70.87 69.82,70.25 67.43,70.25 67.08,69.91 66.42,69.91 66.32,69.81 66.32,69.42 66.22,69.32 66.02,69.32 65.91,69.42 65.91,70.04 65.8,70.15 65.62,70.15 65.51,70.03 65.51,69.42 65.41,69.32 64.72,69.32 64.54,69.5 64.54,70.41 64.69,70.56 65.15,70.56 65.28,70.69 65.28,71.1 v1(65.25,71.12)
  BOTTOM w0.076: 103.41,64.76 103.5,64.76 103.51,64.77 104.16,64.77 104.44,65.05 104.84,65.05 104.84,65.05 104.97,64.99 105.25,64.99 105.41,65.15 105.41,65.33 105.43,65.38 105.55,65.5 105.7,65.58 105.78,65.66 105.78,65.71 U0400.AY59
  BOTTOM w0.102: v1(65.25,71.12) 63.8,72.57 CON2000.80 ; 103.41,64.76 102.07,64.76 v1(101.68,65.15)
M_A_D32: length 52.2
  TOP w0.102: v1(65.2,46.89) v2(65.2,47.53)
  IN1 w0.097: v1(65.2,46.89) 65.2,46.17 65.33,46.05 68.96,46.05 69.3,46.39 75.31,46.39 80.21,51.29 82.02,51.29 82.35,50.95 82.35,50.8 82.42,50.73 v1(83.54,50.73)
  BOTTOM w0.076: U0400.AY39 105.79,54.85 105.47,55.17 105.09,55.17 104.84,55.29 104.38,55.29 104.21,55.11 103.32,55.11 103.02,54.82 102.77,54.82
  BOTTOM w0.102: CON2000.170 64.45,48.07 65.2,47.32 v1(65.2,46.89) ; v1(83.54,50.73) 83.54,50.78 82.98,51.34 82.98,52.15 85.32,54.49 90.79,54.49 91.12,54.81 101.74,54.81 101.74,54.82 102.77,54.82
M_A_D33: length 51.6
  TOP w0.102: v1(66.74,46.77) 65.74,45.77 v2(65.51,45.77)
  IN1 w0.097: v1(66.74,46.77) 67.6,47.63 70.58,47.63 70.88,47.32 74.92,47.32 80.15,52.56 83.42,52.56 83.43,52.56 83.76,52.56 83.76,52.56 84.53,52.56 84.62,52.47 v1(85.06,52.47)
  BOTTOM w0.076: 102.36,53.6 102.43,53.6 102.51,53.68 104,53.68 104.28,53.96 104.81,53.96 104.84,53.95 104.9,53.92 105.08,53.92 105.2,53.96 105.46,53.96 105.49,53.95 105.55,53.92 106.34,53.92 106.34,53.92 106.62,54.2 U0400.AW39
  BOTTOM w0.102: 102.36,53.6 102.25,53.6 102.24,53.59 102.02,53.59 101.91,53.47 99.43,53.47 98.7,52.74 91.97,52.74 91.65,52.42 89.76,50.52 87,50.52 v2(86.49,51.03) 85.05,52.47 85.05,52.47 v1(85.06,52.47) ; CON2000.169 69.3,48.32 68.99,48.01 67.64,48.01 66.74,47.11 v1(66.74,46.77)
M_A_D34: length 53.4
  TOP w0.102: v2(62.79,43.92) 63.61,43.92 v1(64.08,43.46)
  IN1 w0.097: v1(86.56,50.35) 85.37,50.35 83.74,48.72 79.99,48.72 75.37,44.1 67.94,44.1 66.55,45.49 63.96,45.49 63.4,44.94 63.4,44.13 v1(64.08,43.46)
  BOTTOM w0.076: U0400.AY37 105.84,53.76 105.5,53.76 105.43,53.79 105.23,53.79 105.11,53.76 104.85,53.76 104.78,53.79 104.35,53.79 104.07,53.51 102.71,53.51 102.58,53.38 102.45,53.38
  BOTTOM w0.102: CON2000.186 63.46,44.07 v1(64.08,43.46) ; 102.45,53.38 102.12,53.38 102.01,53.27 99.65,53.27 98.81,52.42 92.11,52.42 91.78,52.1 89.44,49.76 v2(89.03,49.76) 87.71,49.76 87.33,50.14 86.77,50.14 v1(86.56,50.35)
M_A_D35: length 52.8
  TOP w0.102: v1(68.4,43.36) v2(68.4,44)
  IN1 w0.097: v1(84.41,48.11) 84.3,48 80.17,48 79.98,47.82 75.1,42.94 74.03,42.94 73.93,43.03 73.93,43.38 73.84,43.48 73.64,43.48 73.55,43.38 73.55,43.03 73.45,42.94 73.26,42.94 73.16,43.03 73.16,43.38 73.07,43.48 72.87,43.48 72.78,43.38 72.78,43.03 72.68,42.94 72.49,42.94 72.39,43.03 72.39,43.38 72.29,43.48 72.1,43.48 72,43.38 72,43.03 71.91,42.94 71.71,42.94 71.62,43.03 71.62,43.38 71.52,43.48 71.33,43.48 71.23,43.38 71.23,43.03 71.14,42.94 70.94,42.94 70.85,43.03 70.85,43.38 70.75,43.48 70.56,43.48 70.46,43.38 70.46,43.03 70.36,42.94 70.17,42.94 70.07,43.03 70.07,43.38 69.98,43.48 69.78,43.48 69.69,43.38 69.69,43.03 69.59,42.94 68.83,42.94 v1(68.4,43.36)
  BOTTOM w0.076: U0400.AW37 106.37,53.38 106.16,53.38 106.11,53.33 105.59,53.33 105.36,53.1 104.35,53.1 104.28,53.02 103.39,53.02 103.34,52.97 103.1,52.97
  BOTTOM w0.102: v1(84.41,48.11) v2(85.4,48.11) 85.85,48.11 85.95,48.01 85.95,47.4 86.05,47.3 86.26,47.3 86.36,47.4 86.36,48.03 86.46,48.13 86.66,48.13 86.77,48.03 86.77,47.75 86.87,47.65 87.07,47.65 87.17,47.75 87.17,48.03 87.27,48.13 89.16,48.13 92.18,51.15 92.41,51.37 98.91,51.37 100.17,52.63 102.24,52.63 102.38,52.77 102.75,52.77 102.96,52.97 103.1,52.97 ; CON2000.187 68.87,43.82 v1(68.4,43.36)
M_A_D36: length 51.2
  TOP w0.102: v2(68.45,47.4) 68,46.94 v1(68,46.77)
  IN1 w0.097: v1(68,46.77) 68,47.17 68.13,47.3 69.59,47.3 69.77,47.12 69.98,47.12 70.16,47.3 70.47,47.3 70.76,47.01 75.05,47.01 80.15,52.1 82.58,52.1 82.7,51.98 82.7,51.69 82.83,51.56 v1(83.44,51.56)
  BOTTOM w0.076: U0400.BB39 104.46,54.85 104.39,54.78 103.5,54.78 103.07,54.36 102.77,54.36
  BOTTOM w0.102: 102.77,54.36 102.46,54.36 102.46,54.36 102.1,54.36 102.1,54.36 101.77,54.36 101.59,54.18 91.38,54.18 91.06,53.85 89.36,53.85 89.18,53.67 v2(88.77,53.67) 88.6,53.67 88.41,53.85 88.16,53.85 88.05,53.75 88.05,52.71 87.95,52.61 87.75,52.61 87.65,52.71 87.65,53.75 87.55,53.85 87.34,53.85 87.24,53.75 87.24,52.07 87.14,51.97 86.94,51.97 86.83,52.07 86.83,53.75 86.73,53.85 86.42,53.85 85.83,53.27 85.22,53.27 84.94,52.99 84.93,52.99 84.7,52.75 84.7,52.74 84.65,52.7 84.65,52.3 84.73,52.22 84.73,51.74 84.56,51.56 v1(83.44,51.56) ; CON2000.173 68.55,47.32 v1(68,46.77)
M_A_D37: length 51.4
  TOP w0.102: v1(63.93,46.84) 63.93,46.97 v2(63.4,47.5)
  IN1 w0.097: v1(63.93,46.84) 63.93,47.4 64.06,47.53 65.66,47.53 65.86,47.32 65.86,46.48 65.99,46.36 68.83,46.36 69.17,46.7 75.18,46.7 80.1,51.62 82.25,51.62 82.7,51.16 83.92,51.16 84.51,51.74 84.51,51.92 v1(84.28,52.15)
  BOTTOM w0.076: U0400.BA39 105.17,55 105.05,55 104.8,55.12 104.47,55.12 104.3,54.95 103.41,54.95 103.01,54.55 102.77,54.55
  BOTTOM w0.102: v1(63.93,46.84) 63.53,47.25 63.15,47.25 62.98,47.07 CON2000.174 ; 102.77,54.55 101.66,54.55 101.61,54.5 91.25,54.5 90.92,54.17 85.82,54.17 v2(85.37,53.72) 85.01,53.72 83.95,52.67 83.95,52.48 v1(84.28,52.15)
M_A_D38: length 51.7
  TOP w0.102: v2(66.65,43.85) 66.65,43.84 v1(67.14,43.36)
  IN1 w0.097: v1(67.14,43.36) 67.14,43.74 67.01,43.87 66.4,43.87 66.27,43.74 66.27,42.85 66.4,42.72 67.27,42.72 67.37,42.62 75.24,42.62 80.3,47.69 84.56,47.69 85.24,48.37 v1(85.24,49.02)
  BOTTOM w0.076: 103.05,53.16 103.07,53.18 104.21,53.18 104.28,53.26 105.05,53.26 U0400.BA37
  BOTTOM w0.102: 103.05,53.16 102.88,53.16 102.69,52.97 102.29,52.97 102.16,52.83 100.03,52.83 98.88,51.69 92.27,51.69 92.05,51.46 89.05,48.47 85.8,48.47 v1(85.24,49.02) ; CON2000.183 69.05,44.82 68.89,44.66 67.54,44.66 67.14,44.25 v1(67.14,43.36)
M_A_D39: length 51.7
  TOP w0.102: v1(65.38,43.41) 64.57,44.22 v2(64.54,44.22)
  IN1 w0.097: v1(65.38,43.41) 64.97,43.82 64.97,44.99 65.1,45.11 66.45,45.11 67.77,43.79 75.51,43.79 80.04,48.32 83.88,48.32 85.04,49.48 v1(85.7,49.48)
  BOTTOM w0.076: U0400.BB37 104.32,53.53 104.14,53.35 102.8,53.35 102.73,53.28
  BOTTOM w0.102: v1(85.7,49.48) v2(87.25,49.48) 87.48,49.25 89.39,49.25 91.91,51.78 92.24,52.11 98.93,52.11 99.87,53.04 102.07,53.04 102.21,53.17 102.62,53.17 102.73,53.28 ; v1(65.38,43.41) 65.38,43.82 64.26,44.94 63.2,44.94 63.06,45.07 CON2000.182
M_A_D40: length 53.3
  TOP w0.102: v2(68.91,40.77) 68.91,40.6 68.44,40.13 68.43,40.13 68.42,40.12 68.42,40.12 68.41,40.12 v1(68.41,40.12)
  IN1 w0.097: v1(68.41,40.12) 68.41,40.44 68.54,40.57 69.54,40.57 69.63,40.47 69.63,40.42 69.73,40.32 69.92,40.32 70.02,40.42 70.02,40.47 70.12,40.57 70.31,40.57 70.4,40.47 70.4,40.42 70.5,40.32 70.69,40.32 70.79,40.42 70.79,40.47 70.89,40.57 71.08,40.57 71.18,40.47 71.18,40.42 71.27,40.32 71.47,40.32 71.56,40.42 71.56,40.47 71.66,40.57 72.08,40.57 72.58,41.07 72.9,41.07 72.99,40.97 72.99,40.42 73.09,40.32 73.28,40.32 73.38,40.42 73.38,40.97 73.47,41.07 73.67,41.07 73.76,40.97 73.76,40.42 73.86,40.32 74.05,40.32 74.15,40.42 74.15,40.97 74.25,41.07 74.44,41.07 74.54,40.97 74.54,40.42 74.63,40.32 74.83,40.32 74.92,40.42 74.92,40.97 75.02,41.07 75.88,41.07 75.95,41.14 75.96,41.14 80.94,46.12 81.69,46.12 81.69,46.13 85.18,46.13 86.78,47.73 86.78,48.31 89.44,50.97 100.16,50.97 100.27,51.07 102.2,51.07 v3(102.9,51.77)
  BOTTOM w0.076: U0400.AY35 105.84,52.27 105.5,52.27 105.43,52.23 105.22,52.23 105.1,52.27 104.85,52.27 104.76,52.23 104.51,52.23 104.39,52.36 103.77,52.36 103.68,52.28
  BOTTOM w0.102: v1(68.41,40.12) 68.41,40.12 68.42,40.12 68.42,40.15 67.69,40.87 67.69,41.09 67.81,41.2 68.12,41.2 68.33,41.4 68.33,41.76 68.58,42.01 69.06,42.01 69.25,41.82 CON2000.195 ; v3(102.9,51.77) 103.33,52.21 103.61,52.21 103.68,52.28
M_A_D41: length 53.9
  TOP w0.102: v2(65.77,42.19) v1(65.18,41.6)
  IN1 w0.097: v1(100.33,51.8) 89.38,51.8 86.16,48.58 86.16,47.99 84.93,46.76 80.68,46.76 75.7,41.78 75.62,41.69 72.32,41.69 71.82,41.19 67.5,41.19 66.89,41.8 66.02,41.8 65.29,42.53 64.67,42.53 64.54,42.4 64.54,42.23 v1(65.18,41.6)
  BOTTOM w0.076: U0400.AW35 106.39,52.4 106.07,52.72 105.59,52.72 105.38,52.93 104.42,52.93 104.34,52.85 103.52,52.85 103.45,52.78 103.35,52.78
  BOTTOM w0.102: 103.35,52.78 103.04,52.78 102.82,52.56 102.46,52.56 102.32,52.42 100.95,52.42 v1(100.33,51.8) ; CON2000.190 63.02,43.07 63.14,42.95 64.14,42.95 65.18,41.91 v1(65.18,41.6)
M_A_D42: length 53.4
  TOP w0.102: v2(64.24,38.38) 64.49,38.38 v1(65.2,39.09)
  IN1 w0.097: v1(65.2,39.09) 64.81,38.7 64.81,38.5 64.94,38.37 65.7,38.37 66.69,37.38 72.9,37.38 73.43,37.91 75.46,37.91 75.46,37.91 77.2,37.91 82.55,43.26 82.9,43.62 83.92,43.62 85.92,43.61 86.21,43.61 90.44,47.84 101.69,47.84 103.15,49.3 v3(103.15,50.38)
  BOTTOM w0.076: 105.76,51.17 105.49,50.9 105.39,50.85 105.05,50.85 104.99,50.83 104.9,50.79 104.81,50.74 103.51,50.74 103.45,50.68
  BOTTOM w0.102: CON2000.204 63.17,39.57 63.22,39.52 64.92,39.52 65.19,39.26 65.19,39.11 v1(65.2,39.09) ; U0400.AY33 105.76,51.17 ; 103.45,50.68 v3(103.15,50.38)
M_A_D43: length 51.9
  TOP w0.102: v1(68.38,38.41) 68.38,38.18 68.83,37.72 v2(68.83,37.7)
  IN1 w0.097: v3(103.48,51.8) 102.44,50.76 101.76,50.76 101.53,50.53 101.53,49.14 100.94,48.56 90.32,48.56 90.31,48.56 90.26,48.56 85.95,44.24 84.18,44.24 84.18,44.24 82.65,44.24 81.93,43.52 76.94,38.54 75.72,38.54 72.94,38.54 72.84,38.44 72.84,38.3 72.75,38.2 72.55,38.2 72.46,38.3 72.46,38.44 72.36,38.54 72.17,38.54 72.07,38.44 72.07,38.1 71.98,38 71.78,38 71.69,38.1 71.69,38.41 71.59,38.51 71.4,38.51 71.3,38.41 71.3,38.1 71.2,38 71.01,38 70.91,38.1 70.91,38.41 70.82,38.51 70.62,38.51 70.53,38.41 70.53,38.1 70.43,38 70.24,38 70.14,38.1 70.14,38.41 70.05,38.51 69.85,38.51 69.76,38.41 69.76,38.1 69.66,38 68.78,38 v1(68.38,38.41)
  BOTTOM w0.076: 103.81,52.13 103.87,52.19 104.32,52.19 104.44,52.07 104.81,52.07 104.89,52.1 105.07,52.1 105.2,52.07 105.46,52.07 105.49,52.08 105.55,52.1 106.39,52.1 106.62,51.87 U0400.AW33
  BOTTOM w0.102: CON2000.207 68.79,38.82 v1(68.38,38.41) ; 103.81,52.13 v3(103.48,51.8)
M_A_D44: length 51.8
  TOP w0.102: v2(67.03,40.82) 67.07,40.78 v1(67.07,40.12)
  IN1 w0.097: v1(102.26,51.8) 101.84,51.39 89.42,51.39 86.47,48.44 86.47,47.86 85.05,46.44 80.82,46.44 75.83,41.45 75.82,41.45 75.75,41.38 72.45,41.38 71.95,40.88 67.37,40.88 66.76,41.49 66.33,41.49 66.18,41.34 66.18,41.01 v1(67.07,40.12)
  BOTTOM w0.076: 103.53,52.4 103.66,52.52 104.45,52.52 104.47,52.5 U0400.BB35
  BOTTOM w0.102: 103.53,52.4 103.19,52.4 102.95,52.15 102.61,52.15 v1(102.26,51.8) ; v1(67.07,40.12) 67.07,42.15 67.74,42.82 CON2000.191
M_A_D45: length 52
  TOP w0.102: v2(63.96,42.27) v1(63.96,41.61)
  IN1 w0.097: v1(100.99,51.8) 100.98,51.8 100.58,52.21 89.23,52.21 85.85,48.82 85.85,48.12 84.81,47.08 80.56,47.08 75.49,42.01 69.92,42.01 69.91,42.02 67.12,42.02 67.02,42.12 66.15,42.12 65.42,42.84 63.4,42.84 63.22,42.67 63.22,42.18 63.4,42 63.57,42 v1(63.96,41.61)
  BOTTOM w0.076: U0400.BA35 105.05,52.77 104.5,52.77 104.43,52.69 103.59,52.69 103.49,52.59 103.33,52.59
  BOTTOM w0.102: v1(100.99,51.8) 101.4,52.21 102.4,52.21 102.54,52.35 102.88,52.35 103.12,52.59 103.33,52.59 ; v1(63.96,41.61) 63.49,42.07 CON2000.194
M_A_D46: length 52.7
  TOP w0.102: v1(63.98,39.09) 63.57,39.5 62.89,39.5 v2(62.87,39.49)
  IN1 w0.097: v1(101.93,50.29) 102.18,50.04 102.18,49.14 101.28,48.24 90.39,48.24 86.08,43.93 86.05,43.93 84.05,43.93 82.78,43.93 82.24,43.39 77.07,38.22 75.59,38.22 73.3,38.22 72.77,37.69 66.88,37.69 65.76,38.81 65.76,39.33 65.59,39.5 64.39,39.5 v1(63.98,39.09)
  BOTTOM w0.076: U0400.BA33 105.17,51.02 105.02,51.02 104.9,50.97 104.78,50.91 104.77,50.91 103.38,50.91 103.27,50.79
  BOTTOM w0.102: CON2000.208 63.46,38.57 v1(63.98,39.09) ; v1(101.93,50.29) 101.93,50.57 102.15,50.79 103.27,50.79
M_A_D47: length 51.8
  TOP w0.102: v1(67.16,38.41) 67.16,38.48 v2(67.87,39.19)
  IN1 w0.097: v1(67.16,38.41) 67.6,38.85 75.85,38.85 76.36,38.85 82.06,44.55 82.17,44.66 85.79,44.66 88.5,47.37 88.5,47.51 88.39,47.62 88.39,47.75 88.53,47.89 88.67,47.89 88.78,47.78 88.91,47.78 89.05,47.92 89.05,48.05 88.94,48.16 88.94,48.3 89.08,48.44 89.21,48.44 89.26,48.39 89.32,48.33 89.46,48.33 90.01,48.88 100.61,48.88 101.12,49.38 101.12,50.34 v1(101.12,50.35)
  BOTTOM w0.076: 103.03,50.98 103.23,50.98 103.31,51.07 104.36,51.07 104.47,51.17 U0400.BB33
  BOTTOM w0.102: v1(67.16,38.41) 66.22,38.41 66.04,38.59 66.04,39.45 66.17,39.58 69.12,39.58 69.37,39.82 CON2000.203 ; v1(101.12,50.35) 101.66,50.88 101.93,50.88 102.03,50.98 103.03,50.98
M_A_D48: length 55.6
  TOP w0.102: v1(63.98,37.36) 64.47,36.87 v2(64.47,36.58)
  IN1 w0.097: v1(87.57,43.51) 87.07,43.01 85.67,43.01 83.67,43.01 83.16,43.01 77.45,37.31 75.21,37.31 73.68,37.31 73.15,36.77 73.14,36.77 72.77,36.4 71.62,36.4 71.32,36.7 65.97,36.7 65.81,36.86 65.81,37.4 65.45,37.77 64.57,37.77 64.07,38.27 63.89,38.27 63.57,37.95 63.57,37.77 v1(63.98,37.36)
  BOTTOM w0.076: 102.47,49.89 103.14,49.89 103.24,49.99 103.86,49.99 104.17,50.3 104.86,50.3 104.87,50.29 104.88,50.29 105.25,50.14 105.53,50.14 105.8,49.87 U0400.AY31
  BOTTOM w0.102: CON2000.216 63.6,36.57 63.98,36.96 v1(63.98,37.36) ; v1(87.57,43.51) 87.57,45.67 92.57,50.68 97.64,50.68 98.43,49.89 102.47,49.89
M_A_D49: length 56.6
  TOP w0.102: v2(66.07,38.48) 66.07,38.15 v1(65.28,37.37)
  IN1 w0.097: v1(65.28,37.37) 64.87,36.95 63.87,36.95 63.75,36.83 63.75,36.51 63.87,36.39 71.19,36.39 71.49,36.09 72.92,36.09 73.82,37 75.08,37 77.58,36.99 83.29,42.7 83.54,42.7 83.54,42.7 85.54,42.7 86.82,42.7 87.51,42.7 88.47,43.65 v1(88.47,44.41)
  BOTTOM w0.076: U0400.AW31 106.62,49.87 106.62,49.22 106.38,48.98 106.25,48.94 105.55,48.94 105.49,48.96 105.46,48.98 105.2,48.98 105.08,48.94 104.9,48.94 104.84,48.97 104.81,48.98 104.44,48.98 104.29,48.82 104.11,48.82 103.82,48.54 103.51,48.54 103.43,48.62 102.59,48.62
  BOTTOM w0.102: v1(65.28,37.37) 64.87,37.77 64.16,37.77 64.16,37.77 63.19,37.77 62.99,37.57 CON2000.212 ; v1(88.47,44.41) v2(89.98,44.41) 90.4,44.41 94.26,48.26 97.34,48.26 97.7,48.62 102.59,48.62
M_A_D50: length 56.1
  TOP w0.102: v1(64.38,34.6) 64.38,34.28 65.18,33.48 v2(65.76,33.48)
  IN1 w0.097: v1(93.41,46.65) 93.41,44.25 92.63,43.47 92.63,43.47 88.82,39.66 85.56,39.66 84.54,39.66 76.86,31.98 76.81,31.93 67.3,31.93 67.08,32.15 66.67,32.15 66.54,32.28 66.35,32.28 64.38,34.25 v1(64.38,34.6)
  BOTTOM w0.076: 102.67,48.33 102.71,48.37 103.89,48.37 104.18,48.66 104.36,48.66 104.51,48.81 104.78,48.81 104.85,48.78 104.86,48.78 105.1,48.78 105.22,48.81 105.43,48.81 105.5,48.78 105.84,48.78 U0400.AY29
  BOTTOM w0.102: v1(64.38,34.6) 63.97,34.19 63.36,34.19 63.12,34.43 63.12,34.5 63.04,34.57 CON2000.224 ; 102.67,48.33 99.89,48.33 99.82,48.26 97.79,48.26 97.54,48.01 97.47,47.95 95.19,47.95 94.93,47.95 93.63,46.65 v1(93.41,46.65)
M_A_D51: length 55.4
  TOP w0.102: v1(65.62,34.61) 65.62,34.99 v2(65.85,35.22)
  IN1 w0.097: v1(91.64,44.86) 91.64,43.87 88.38,40.6 85.95,40.6 85.95,40.6 84.67,40.6 84.15,40.6 76.99,33.44 67.6,33.44 66.35,34.7 66.35,35.56 66.07,35.84 65.75,35.84 65.62,35.71 v1(65.62,34.61)
  BOTTOM w0.076: 106.46,48.65 106.14,48.32 105.57,48.32 105.36,48.11 104.34,48.11 104.1,47.88 103.02,47.88 102.85,47.71 101.83,47.71
  BOTTOM w0.102: v1(91.64,44.86) 92.74,44.86 93.3,45.42 93.75,45.42 95.32,46.99 97.87,46.99 98.18,47.31 100.38,47.31 100.44,47.37 100.56,47.49 101.61,47.49 101.82,47.71 101.83,47.71 ; U0400.AW29 106.46,48.65 ; CON2000.228 62.09,33.58 64.85,33.58 65.62,34.36 v1(65.62,34.61)
M_A_D52: length 53.9
  TOP w0.102: v1(68.66,35.98) 69.3,35.98 v2(69.44,36.12)
  IN1 w0.097: v1(68.66,35.98) 71.16,35.98 71.36,35.78 73.52,35.78 73.61,35.87 73.61,36.15 73.71,36.25 73.85,36.25 73.94,36.15 73.94,35.7 74.04,35.61 74.23,35.61 74.33,35.7 74.33,36.5 74.46,36.63 74.62,36.63 74.72,36.53 74.72,35.7 74.81,35.61 75.01,35.61 75.1,35.7 75.1,36.5 75.23,36.63 75.39,36.63 75.49,36.53 75.49,35.7 75.59,35.61 75.78,35.61 75.87,35.7 75.87,36.53 76,36.65 76.22,36.65 76.32,36.56 76.32,35.87 76.41,35.78 76.8,35.78 83.41,42.39 85.41,42.39 86.69,42.39 86.69,42.38 87.64,42.38 88.9,43.65 v1(88.9,44.85)
  BOTTOM w0.076: U0400.BB31 104.21,49.87 103.98,49.65 103.97,49.65 103.96,49.63 103.36,49.63 103.1,49.38 102.74,49.38
  BOTTOM w0.102: v1(68.66,35.98) 68.66,36.48 69,36.82 CON2000.215 ; v1(88.9,44.85) 89.64,44.85 90.37,45.58 90.37,46.15 90.12,46.41 90.12,47.32 92.83,50.04 97.46,50.04 98.12,49.38 102.74,49.38
M_A_D53: length 54.7
  TOP w0.102: v1(67.41,35.97) 66.95,36.43 v2(66.95,36.6)
  IN1 w0.097: v1(89.8,45.74) 89.8,44.11 87.77,42.07 86.56,42.07 85.28,42.07 83.54,42.07 76.4,34.93 74.01,34.93 73.91,35.02 73.91,35.14 73.82,35.23 73.62,35.23 73.53,35.14 73.53,35.01 73.43,34.91 73.08,34.91 72.95,35.04 72.95,35.28 72.77,35.46 71.17,35.46 70.97,35.66 69.01,35.66 68.73,35.38 67.03,35.38 66.9,35.51 66.9,35.84 67.03,35.97 v1(67.41,35.97)
  BOTTOM w0.076: 102.39,49.63 103.12,49.63 103.3,49.81 103.91,49.81 104.24,50.14 104.81,50.14 104.89,50.11 105.12,49.87 U0400.BA31
  BOTTOM w0.102: v1(89.8,45.74) 89.42,46.12 v2(89.42,46.61) 89.42,47.08 92.7,50.36 97.5,50.36 98.22,49.63 102.39,49.63 ; v1(67.41,35.97) 67.41,36.96 68.28,37.82 CON2000.211
M_A_D54: length 53.7
  TOP w0.102: v1(68.28,32.88) v2(68.28,32.24)
  IN1 w0.097: v1(68.28,32.88) 68.52,33.13 68.83,33.13 68.93,33.03 68.93,32.65 69.02,32.56 69.22,32.56 69.31,32.65 69.31,33.03 69.41,33.13 69.6,33.13 69.7,33.03 69.7,32.65 69.8,32.56 69.99,32.56 70.09,32.65 70.09,33.03 70.18,33.13 70.38,33.13 70.47,33.03 70.47,32.65 70.57,32.56 70.76,32.56 70.86,32.65 70.86,33.03 70.96,33.13 72.22,33.13 72.32,33.03 72.32,32.65 72.42,32.56 72.61,32.56 72.71,32.65 72.71,33.03 72.8,33.13 73,33.13 73.09,33.03 73.09,32.65 73.19,32.56 73.38,32.56 73.48,32.65 73.48,33.03 73.57,33.13 73.77,33.13 73.86,33.03 73.86,32.65 73.96,32.56 74.15,32.56 74.25,32.65 74.25,33.03 74.35,33.13 74.54,33.13 74.64,33.03 74.64,32.84 74.73,32.74 74.93,32.74 75.02,32.84 75.02,33.03 75.12,33.13 77.12,33.13 84.28,40.29 84.54,40.29 84.54,40.29 85.82,40.29 88.56,40.29 92.56,44.29 92.56,44.83 v1(92.08,45.32)
  BOTTOM w0.076: U0400.BA29 105.05,48.28 104.27,48.28 104.03,48.04 102.93,48.04 102.8,47.91 102.77,47.91
  BOTTOM w0.102: v1(92.08,45.32) 92.75,45.32 93.29,45.86 93.74,45.86 95.19,47.31 97.73,47.31 98.05,47.63 100.25,47.63 100.43,47.81 101.61,47.81 101.71,47.91 102.77,47.91 ; CON2000.229 69.21,33.32 69.16,33.38 68.78,33.38 68.29,32.88 v1(68.28,32.88)
M_A_D55: length 53.6
  TOP w0.102: v2(66.52,31.88) 67.03,32.39 v1(67.03,32.88)
  IN1 w0.097: v1(67.03,32.88) 67.03,33.33 66.87,33.49 66.61,33.49 66.32,33.2 66.32,32.95 66.8,32.46 67.28,32.46 67.51,32.24 76.68,32.24 76.73,32.29 84.41,39.98 85.69,39.98 88.69,39.98 92.96,44.25 v1(92.96,46.18)
  BOTTOM w0.076: 102.69,48.13 102.74,48.13 102.81,48.21 103.96,48.21 104.24,48.49 104.42,48.49 104.48,48.55 U0400.BB29
  BOTTOM w0.102: v1(67.03,32.88) 67.03,33.59 67.59,34.14 68.98,34.14 69.16,34.32 CON2000.225 ; 102.69,48.13 100.3,48.13 100.11,47.95 97.92,47.95 97.6,47.63 95.06,47.63 93.61,46.18 v1(92.96,46.18)
M_A_D56: length 57.7
  TOP w0.102: v2(67.74,29.8) 67.21,30.33 v1(67.21,30.47)
  IN1 w0.097: v3(102.83,46.43) 102.83,45.98 102.65,45.8 99.64,45.8 99.42,45.57 99.42,44.99 100.03,44.37 100.03,44.28 99.88,44.12 99.74,44.12 99.38,44.48 99.24,44.48 99.1,44.34 99.1,44.18 99.46,43.82 99.46,43.71 99.32,43.56 99.2,43.56 98.83,43.93 98.7,43.93 98.56,43.8 98.56,43.64 98.83,43.37 98.83,43.23 98.7,43.11 98.57,43.11 98.29,43.39 98.07,43.39 95.46,40.78 95.14,40.78 92.49,38.12 85.18,38.12 76.65,29.59 68.6,29.59 68.33,29.86 66.85,29.86 66.73,29.98 66.73,30.34 66.85,30.47 v1(67.21,30.47)
  BOTTOM w0.076: U0400.AY27 105.84,47.29 105.52,47.29 105.4,47.25 105.22,47.25 105.17,47.27 105.14,47.29 104.87,47.29 104.75,47.25 104.41,47.25 104.37,47.22 103.37,47.22 103.05,46.89
  BOTTOM w0.102: 103.05,46.89 102.83,46.68 v3(102.83,46.43) ; v1(67.21,30.47) 67.21,31.81 67.68,32.27 68.54,32.27 68.59,32.32 CON2000.233
M_A_D57: length 57.1
  IN1 w0.097: v1(100.61,46.51) 100.21,46.11 99.52,46.11 99.51,46.1 99.05,46.1 98.62,45.68 98.62,45.53 99.09,45.06 99.09,44.92 98.94,44.78 98.8,44.78 98.33,45.25 98.19,45.25 98.04,45.1 98.04,44.96 98.51,44.49 98.51,44.34 98.37,44.2 98.23,44.2 97.76,44.67 97.61,44.67 97.47,44.53 97.47,44.38 97.94,43.91 97.94,43.77 97.79,43.63 97.65,43.63 97.18,44.09 97.04,44.09 96.89,43.95 96.89,43.81 97,43.7 97.36,43.34 97.36,43.19 97.22,43.05 97.08,43.05 96.73,43.4 96.58,43.4 94.59,41.4 94.59,41.1 94.33,40.84 93.97,40.84 93.84,40.7 93.84,40.56 93.92,40.48 93.92,40.35 93.78,40.21 93.64,40.21 93.47,40.39 93.33,40.39 93.19,40.25 93.19,40.11 93.37,39.94 93.37,39.8 93.23,39.66 93.1,39.66 92.92,39.84 92.78,39.84 92.65,39.7 92.65,39.57 92.82,39.39 92.82,39.25 92.69,39.12 92.55,39.12 92.37,39.29 92.24,39.29 92.1,39.16 92.1,39.02 92.28,38.85 92.28,38.71 92.14,38.57 92,38.57 91.83,38.75 91.69,38.75 91.38,38.44 85.05,38.44 76.52,29.9 68.99,29.9 v1(68.43,30.47)
  BOTTOM w0.076: 101.83,47.02 102.08,47.27 102.67,47.27 103.11,47.71 104.17,47.71 104.4,47.95 105.34,47.95 105.56,47.73 106.07,47.73 106.09,47.71 106.38,47.42 U0400.AW27
  BOTTOM w0.102: v1(100.61,46.51) 100.99,46.89 101.42,46.89 101.45,46.92 101.73,46.92 101.83,47.02 ; v1(68.43,30.47) 68.43,30.97 68.79,31.32 CON2000.237
M_A_D58: length 57.4
  TOP w0.102: v1(67.82,27.38) 66.76,27.38 v2(66.76,27.39)
  IN1 w0.097: v3(103.2,45.19) 103.2,44.39 94.84,36.03 86.52,36.03 83.06,32.57 83.04,32.57 83.04,32.56 82.58,32.56 76.95,26.93 76.38,26.93 76.28,27.02 76.28,27.37 76.19,27.46 75.97,27.46 75.89,27.38 75.89,26.92 75.8,26.82 75.6,26.82 75.51,26.92 75.51,27.36 75.41,27.46 75.21,27.46 75.12,27.37 75.12,26.92 75.02,26.82 74.83,26.82 74.73,26.92 74.73,27.36 74.64,27.46 74.45,27.46 74.35,27.36 74.35,26.92 74.25,26.82 74.06,26.82 73.96,26.92 73.96,27.36 73.87,27.46 73.67,27.46 73.58,27.36 73.58,26.92 73.48,26.82 73.29,26.82 73.19,26.92 73.19,27.36 73.09,27.46 72.9,27.46 72.8,27.36 72.8,26.92 72.71,26.82 72.51,26.82 72.42,26.92 72.42,27.36 72.32,27.46 72.13,27.46 72.03,27.36 72.03,26.92 71.94,26.82 67.95,26.82 67.82,26.95 v1(67.82,27.38)
  BOTTOM w0.076: U0400.AY25 105.75,46.19 105.38,45.82 104.97,45.82 104.57,45.63 103.65,45.63 v3(103.2,45.19)
  BOTTOM w0.102: CON2000.249 69.19,28.32 68.96,28.09 68.07,28.09 67.82,27.84 v1(67.82,27.38)
M_A_D59: length 57.8
  TOP w0.102: v1(64.77,26.95) 65.28,26.44 v2(65.28,26.29)
  IN1 w0.097: v3(103.35,46.66) 103.61,46.41 103.61,44.35 94.97,35.71 86.72,35.71 83.24,32.24 82.78,32.24 77.05,26.51 67.63,26.51 66.68,27.46 65.28,27.46 v1(64.77,26.95)
  BOTTOM w0.076: U0400.AW25 106.62,46.84 106.34,47.12 105.56,47.12 105.43,47.09 105.18,47.09 105.1,47.12 104.91,47.12 104.78,47.09 104.47,47.09 104.44,47.05 103.74,47.05 v3(103.35,46.66)
  BOTTOM w0.102: v1(64.77,26.95) 64.77,27.49 64.18,28.07 CON2000.250
M_A_D60: length 55.2
  TOP w0.102: v2(63.98,33.61) v1(63.98,32.97)
  IN1 w0.097: v1(63.98,32.97) 65.28,31.68 66.29,31.68 66.42,31.55 66.83,31.55 67.05,31.33 72.61,31.33 72.73,31.2 72.73,30.6 72.8,30.53 74.5,30.53 74.57,30.6 74.57,31.09 74.7,31.22 74.92,31.22 75.05,31.1 75.05,30.6 75.12,30.53 75.35,30.53 75.43,30.6 75.43,31.23 75.53,31.33 75.7,31.33 75.82,31.2 75.82,30.6 75.89,30.53 76.26,30.53 84.79,39.06 85.31,39.06 90.7,39.06 95.22,43.58 95.22,44.22 98.24,47.24 101.76,47.24 v3(102.31,46.69)
  BOTTOM w0.076: v3(102.31,46.69) 102.51,46.89 102.79,46.89 103.28,47.38 104.3,47.38 104.44,47.52 U0400.BB27
  BOTTOM w0.102: CON2000.232 63.14,32.57 63.2,32.51 63.53,32.51 v1(63.98,32.97)
M_A_D61: length 57.2
  TOP w0.102: v1(66.18,31.21) 66.18,30.17 v2(65.99,29.97)
  IN1 w0.097: v1(101.3,46.48) 100.85,46.93 99.42,46.93 98.71,46.22 98.57,46.22 98.31,46.48 98.16,46.48 98.02,46.33 98.02,46.19 98.28,45.93 98.28,45.79 98.14,45.64 97.99,45.64 97.81,45.83 97.66,45.83 97.52,45.68 97.52,45.54 97.7,45.35 97.7,45.21 91.24,38.75 85.18,38.75 85.18,38.75 84.92,38.75 76.39,30.22 72.39,30.22 72.29,30.31 72.29,30.77 72.2,30.86 70.84,30.86 70.75,30.77 70.75,30.31 70.65,30.22 70.46,30.22 70.36,30.31 70.36,30.92 70.27,31.01 70.07,31.01 69.98,30.92 69.98,30.31 69.88,30.22 69.69,30.22 69.59,30.31 69.59,30.57 69.14,31.01 66.88,31.01 66.69,31.21 v1(66.18,31.21)
  BOTTOM w0.076: 101.83,46.74 102.18,47.09 102.74,47.09 103.19,47.55 104.23,47.55 104.47,47.78 105.05,47.78 U0400.BA27
  BOTTOM w0.102: 101.83,46.74 101.8,46.71 101.52,46.71 v1(101.3,46.48) ; CON2000.236 63.09,31.57 63.25,31.73 65.66,31.73 v1(66.18,31.21)
M_A_D62: length 56.2
  TOP w0.102: v2(63.86,27.99) 63.96,28.09 63.96,28.7 v1(64.14,28.88)
  IN1 w0.097: v1(64.14,28.88) 64.14,28.43 64.77,27.79 69.6,27.79 69.69,27.69 69.69,27.28 69.79,27.18 69.98,27.18 70.08,27.28 70.08,27.69 70.18,27.79 70.37,27.79 70.47,27.69 70.47,27.3 70.56,27.21 70.75,27.21 70.85,27.3 70.85,27.69 70.95,27.79 71.14,27.79 71.24,27.69 71.24,27.3 71.36,27.18 71.51,27.18 71.62,27.29 71.62,27.69 71.72,27.79 77.37,27.79 82.45,32.87 82.91,32.87 86.38,36.34 94.71,36.34 102.67,44.3 v3(102.67,44.99)
  BOTTOM w0.076: v3(102.67,44.99) 102.67,45.21 103.02,45.57 103.3,45.57 103.53,45.8 104.53,45.8 104.93,45.99 105.11,45.99 U0400.BA25
  BOTTOM w0.102: v1(64.14,28.88) 63.75,29.27 63.28,29.27 63.09,29.07 CON2000.246
M_A_D63: length 56.5
  TOP w0.102: v2(68.43,27.94) 67.31,27.94 66.98,28.27 v1(66.98,28.56)
  IN1 w0.097: v1(66.98,28.56) 67.44,28.1 77.24,28.1 82.43,33.29 82.57,33.29 82.66,33.2 82.79,33.2 82.93,33.34 82.93,33.47 82.84,33.56 82.84,33.7 82.97,33.84 83.11,33.84 83.2,33.75 83.34,33.75 83.48,33.88 83.48,34.02 83.38,34.11 83.38,34.25 83.52,34.38 83.66,34.38 83.75,34.29 83.88,34.29 84.02,34.43 84.02,34.57 83.93,34.66 83.93,34.79 84.07,34.93 84.2,34.93 84.29,34.84 84.43,34.84 84.57,34.97 84.57,35.11 84.48,35.2 84.48,35.34 84.61,35.47 84.75,35.47 84.84,35.38 84.98,35.38 85.11,35.52 85.11,35.66 85.02,35.75 85.02,35.88 85.16,36.02 85.53,36.02 85.66,36.15 85.66,36.53 85.79,36.65 94.22,36.65 94.64,37.08 94.64,37.22 94.24,37.62 94.24,37.76 94.39,37.91 94.53,37.91 94.93,37.51 95.07,37.51 95.22,37.65 95.22,37.8 94.82,38.2 94.82,38.34 94.96,38.48 95.1,38.48 95.5,38.08 95.97,38.08 98.55,40.67 98.57,40.67 98.8,40.91 98.8,40.92 102.05,44.17 102.05,44.69 102.12,44.75 v3(102.12,44.82)
  BOTTOM w0.076: 102.57,45.59 102.72,45.74 103.22,45.74 103.45,45.96 104.2,45.96 104.43,46.19 U0400.BB25
  BOTTOM w0.102: 102.57,45.59 102.12,45.13 v3(102.12,44.82) ; v1(66.98,28.56) 66.98,28.93 67.37,29.32 CON2000.245
M_A_DIM0_CKE0: length 50.3
  TOP w0.165: v1(67.77,66.93) v2(67.77,67.57)
  IN1 w0.152: v1(90.31,70.77) 89.29,69.75 70.82,69.75 70.03,68.95 69.46,68.95 69.31,68.8 69.31,67.82 69.16,67.67 68.55,67.67 68.4,67.82 68.4,68.8 68.24,68.95 67.81,68.95 66.88,68.02 66.88,67.82 67.59,67.11 67.59,67.11 v1(67.77,66.93)
  BOTTOM w0.076: 103.17,64.42 103.4,64.42 103.58,64.61 104.23,64.61 104.51,64.89 104.8,64.89 104.94,64.83 105.11,64.83 U0400.BA56
  BOTTOM w0.165: v1(67.77,66.93) 67.77,66.47 68.92,65.32 CON2000.109 ; 103.17,64.42 101.31,64.42 100.67,65.06 100.21,65.06 99.59,65.68 96.1,65.68 91.01,70.77 v1(90.31,70.77)
M_A_DIM0_CKE1: length 49.8
  TOP w0.165: v2(63.96,66.59) v1(63.96,65.96)
  IN1 w0.152: v1(63.96,65.96) 63.96,67.9 64.72,68.66 66.9,68.66 66.94,68.69 66.94,68.69 67.63,69.38 69.85,69.38 70.64,70.18 88.45,70.18 v1(89.04,70.77)
  BOTTOM w0.076: 103.2,64.17 103.38,64.17 103.65,64.44 104.32,64.44 104.5,64.62 U0400.BB56
  BOTTOM w0.165: v1(89.04,70.77) 89.5,70.31 90.77,70.31 95.84,65.24 99.41,65.24 v2(100.03,64.62) 100.48,64.17 103.2,64.17 ; CON2000.110 63.37,65.07 63.96,65.66 v1(63.96,65.96)
M_A_DIM0_CLK0: length 50.3
  IN1 w0.109: v3(108.2,63.26) 108.18,63.26 107.73,62.81 107.59,62.67 107.42,62.67 107.42,62.67 107.04,62.67 106.56,63.15 106.56,63.15 106.54,63.17 106.22,63.17 105.26,62.2 100.05,62.2 99.54,61.7 96.47,61.7 96.28,61.89 77.47,61.89 76.68,61.1 76.35,61.1 76.1,61.36 75.94,61.36 75.63,61.05 75.63,60.9 75.89,60.64 75.89,60.31 75.46,59.88 75.13,59.88 74.87,60.14 74.72,60.14 74.41,59.83 74.41,59.67 74.66,59.41 74.66,59.08 74.23,58.65 73.9,58.65 73.64,58.91 73.49,58.91 73.18,58.6 73.18,58.45 73.44,58.19 73.44,57.86 72.79,57.21 70.7,57.21 70.43,57.48 70.43,57.83 70.34,57.91 69.87,57.91 69.77,57.82 69.77,57.46 69.52,57.21 68.91,57.21 68.5,57.61 68.5,57.76 v1(68.22,58.04)
  BOTTOM w0.102: U0400.AT53 108.2,63.03 v3(108.2,63.26) ; v1(68.22,58.04) 68.61,58.42 69.16,58.42 69.26,58.32 CON2000.137
M_A_DIM0_CLK1: length 50.2
  IN1 w0.109: v1(64.39,58.04) 64.12,58.31 64.12,58.51 64.24,58.64 71.49,58.64 72.19,58.64 76.16,62.61 81.83,62.61 81.83,62.61 82.25,62.61 82.26,62.61 96.58,62.61 96.75,62.45 99.62,62.45 99.8,62.63 101.47,62.63 101.49,62.65 105.09,62.65 106.11,63.67 107.59,63.67 v3(108.04,64.12)
  BOTTOM w0.102: v1(64.39,58.04) 63.98,58.45 63.5,58.45 63.13,58.07 CON2000.138 ; U0400.AT55 108.04,64.11 v3(108.04,64.12)
M_A_DIM0_CLK#0: length 50.3
  IN1 w0.109: v5(68.94,58.02) 68.8,58.02 68.74,57.95 68.74,57.67 68.99,57.42 69.43,57.42 69.56,57.54 69.56,57.9 69.78,58.12 70.43,58.12 70.64,57.91 70.64,57.57 70.79,57.42 72.7,57.42 73.23,57.95 73.23,58.1 72.97,58.36 72.97,58.69 73.4,59.12 73.73,59.12 73.99,58.86 74.14,58.86 74.45,59.17 74.45,59.33 74.19,59.58 74.19,59.91 74.63,60.35 74.96,60.35 75.22,60.09 75.37,60.09 75.68,60.4 75.68,60.55 75.42,60.81 75.42,61.14 75.85,61.57 76.18,61.57 76.44,61.32 76.6,61.32 77.38,62.1 96.37,62.1 96.56,61.91 99.45,61.91 99.96,62.42 105.17,62.42 106.13,63.38 106.62,63.38 106.64,63.36 106.65,63.36 107.13,62.88 107.34,62.88 107.48,62.88 107.64,63.04 107.64,63.13 v3(107.49,63.28)
  BOTTOM w0.102: v5(68.94,58.02) 68.87,58.02 68.73,57.88 68.73,57.87 68.63,57.77 68.63,57.51 68.89,57.26 69.06,57.26 69.2,57.39 69.2,57.7 69.32,57.82 CON2000.139 ; U0400.AU53 107.78,63.18 107.68,63.28 v3(107.49,63.28)
M_A_DIM0_CLK#1: length 50.2
  IN1 w0.109: v3(107.47,64.11) 107.47,63.95 107.4,63.88 106.03,63.88 105,62.86 101.49,62.86 101,62.86 100.98,62.84 99.71,62.84 99.53,62.66 96.83,62.66 96.67,62.82 82.34,62.82 82.34,62.83 81.74,62.83 76.08,62.82 72.1,58.85 71.57,58.85 64.16,58.85 63.91,58.6 63.91,58.24 v1(63.7,58.04)
  BOTTOM w0.102: CON2000.140 63.23,57.57 63.45,57.36 63.94,57.36 64.07,57.49 64.07,57.67 v1(63.7,58.04) ; U0400.AU55 107.61,63.71 107.47,63.85 v3(107.47,64.11)
M_A_DIM0_CS#0: length 53.6
  TOP w0.165: v2(66.09,50.55) 66.32,50.78 v1(66.32,51.16)
  IN1 w0.152: v1(66.32,51.16) 67.46,50.02 70.42,50.02 70.53,49.91 74.75,49.91 79.27,54.43 79.27,54.74 79.43,54.89 79.87,54.89 79.98,54.78 79.98,54.66 80.14,54.51 81.89,54.51 82.09,54.71 82.09,55.07 82.25,55.22 103.78,55.22 103.9,55.1 104.7,55.1 107.06,57.46 107.06,58.26 v3(107.49,58.69)
  BOTTOM w0.076: U0400.AU45 107.78,58.4 v3(107.49,58.69)
  BOTTOM w0.165: v1(66.32,51.16) 66.8,51.63 67.09,51.63 67.34,51.89 67.34,53.2 67.47,53.32 CON2000.149
M_A_DIM0_CS#1: length 55
  TOP w0.165: v1(67.11,49.15) v2(67.11,48.52)
  IN1 w0.152: v1(67.11,49.15) 67.11,48.75 67.59,48.26 70.84,48.26 71.14,47.96 74.63,47.96 79.88,53.2 96.34,53.2 96.49,53.36 96.49,53.72 96.64,53.88 97.25,53.88 97.41,53.72 97.41,53.36 97.56,53.2 98.17,53.2 98.32,53.36 98.32,53.72 98.47,53.88 99.08,53.88 99.23,53.72 99.23,53.52 99.36,53.39 100.02,53.39 100.15,53.52 100.15,53.72 100.3,53.88 100.91,53.88 101.14,53.65 104.14,53.65 104.57,54.08 106.15,54.08 107.06,54.99 107.06,56.1 107.72,56.76 v3(108.76,56.76)
  BOTTOM w0.076: v3(108.76,56.76) 108.57,56.76 108.02,57.31 U0400.AU43
  BOTTOM w0.165: v1(67.11,49.15) 67.11,49.58 67.86,50.33 68.51,50.33 69.08,50.9 69.08,51.16 69.09,51.16 69.25,51.32 CON2000.157
M_A_DIM0_ODT0: length 56
  TOP w0.165: v3(107.48,57.72) 106.85,57.72 106.27,57.15 v2(106.27,56.67)
  IN1 w0.152: v3(107.48,57.72) 107.48,57.52 104.75,54.79 82.86,54.79 82.13,54.07 79.52,54.07 74.93,49.48 70.35,49.48 70.25,49.58 67.28,49.58 66.27,50.6 65.58,50.6 v1(65.05,51.13)
  BOTTOM w0.076: U0400.AT45 108.2,58.23 107.86,57.89 107.65,57.89 v3(107.48,57.72)
  BOTTOM w0.165: CON2000.155 69.17,51.82 68.81,51.46 68.81,51.01 68.4,50.6 65.58,50.6 v1(65.05,51.13)
M_A_DIM0_ODT1: length 56.1
  TOP w0.165: v2(69.49,49.61) 68.8,49.61 68.52,49.33 68.52,49.32 v1(68.35,49.15)
  IN1 w0.152: v3(108.26,57.76) 108.11,57.76 106.63,56.28 106.63,55.17 105.97,54.51 101.99,54.51 101.84,54.36 96.14,54.36 95.91,54.12 95.91,53.79 95.75,53.64 95.14,53.64 94.99,53.79 94.99,54.12 94.84,54.28 94.23,54.28 94.08,54.12 94.08,53.79 93.93,53.64 93.32,53.64 93.16,53.79 93.16,54.12 93.01,54.28 92.4,54.28 92.25,54.12 92.25,53.79 92.1,53.64 91.49,53.64 91.33,53.79 91.33,54.12 91.18,54.28 90.57,54.28 90.42,54.12 90.42,53.79 90.27,53.64 89.66,53.64 89.51,53.79 89.51,54.12 89.35,54.28 88.74,54.28 88.59,54.12 88.59,53.79 88.44,53.64 87.83,53.64 87.68,53.79 87.68,54.12 87.52,54.28 86.91,54.28 86.76,54.12 86.76,53.79 86.61,53.64 86,53.64 85.85,53.79 85.85,54.12 85.7,54.28 85.09,54.28 84.93,54.12 84.93,53.79 84.78,53.64 84.17,53.64 84.02,53.79 84.02,54.12 83.87,54.28 83.26,54.28 83.1,54.12 83.1,53.79 82.95,53.64 79.7,53.64 74.45,48.39 71.32,48.39 71.02,48.69 68.48,48.69 68.35,48.82 v1(68.35,49.15)
  BOTTOM w0.076: v3(108.26,57.76) 108.43,57.58 U0400.AT43
  BOTTOM w0.165: CON2000.161 69.12,50.32 68.35,49.56 v1(68.35,49.15)
M_A_DQS0: length 64.3
  IN1 w0.122: v1(111.17,75.67) 111.17,76.16 111.17,76.32 110.82,76.67 110.82,81.11 110.24,81.69 110,81.69 109.83,81.52 109.41,81.52 108.97,81.96 108.97,82.41 109.17,82.62 109.17,82.84 108.85,83.17 108.72,83.17 108.49,82.93 108.09,82.93 107.6,83.42 107.6,83.75 107.8,83.95 107.8,84.21 107.48,84.53 107.28,84.53 107.07,84.32 106.7,84.32 106.23,84.79 106.23,85.16 106.43,85.36 106.43,85.58 105.19,86.82 102.36,86.82 102.11,87.07 90.17,87.07 88.75,88.5 79.5,88.5 77.44,90.56 70.23,90.56 69.2,89.52 68.11,89.52 67.83,89.8 67.83,90.08 v5(67.62,90.3)
  BOTTOM w0.076: U0400.AM69 110.93,72.04 111.22,72.33 111.22,72.79 111.27,72.89 111.27,73.12 111.22,73.23 111.22,73.6 111.72,74.1 111.72,74.91 111.72,75.12 111.58,75.26
  BOTTOM w0.109: CON2000.13 69.14,89.32 69.04,89.43 68.09,89.43 67.84,89.68 67.84,90.1 67.63,90.3 v5(67.62,90.3) ; 111.58,75.26 v1(111.17,75.67)
M_A_DQS1: length 56.5
  IN1 w0.122: v1(65,84.66) 64.87,84.53 64.87,84.53 64.74,84.41 64.74,83.86 65.17,83.44 66.63,83.44 67.35,84.15 87.68,84.15 88.47,83.36 100.46,83.36 106.01,77.81 106.01,76.65 106.18,76.48 106.5,76.48 v1(106.73,76.71)
  BOTTOM w0.076: U0400.AT70 108.47,72.18 108.42,72.13 108.31,72.13 108.23,72.2 108.2,72.28 108.2,72.45 108.24,72.55 108.24,72.83 108.19,72.92 108.19,73.09 108.24,73.2 108.24,73.62 107.53,74.34 107.53,75.17 107.58,75.22 107.58,75.26
  BOTTOM w0.109: CON2000.34 63.2,84.07 63.36,83.92 64.38,83.92 64.69,84.23 64.69,84.36 v1(65,84.66) ; 107.58,75.26 107.58,76.02 107.14,76.46 106.99,76.46 v1(106.73,76.71)
