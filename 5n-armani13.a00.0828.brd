# Allegro board 5n-armani13.a00.0828.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+5VSB&+3P3VSB_IN on TOP (solid shape): 184.25,42.5 184.25,40.2 183.72,39.67 183.69,39.67 183.4,39.63 183.18,39.42 179.78,39.42 179.58,39.63 179.58,41.49 179.64,41.58 179.74,41.57 179.99,41.48 180.24,41.57 180.3,41.6 180.37,41.57 180.96,41.68 180.72,42.23 180.65,42.3 180.68,42.4 181.18,42.91 183.84,42.91
+5VSB&+3P3VSB_IN on BOTTOM (solid shape): 192.64,53.89 192.64,53.4 192.57,53.33 192.09,53.33 191.94,53.18 191.94,52.66 191.5,52.21 191.5,51.35 191.23,51.08 188,51.08 187.85,51.23 187.85,52.93 188.06,53.14 188.75,53.14 189.51,53.9 192.64,53.9
+5VSB&+3P3VSB_IN on BOTTOM (solid shape): 184.66,41.43 184.56,41.33 184.05,41.33 183.93,41.21 183.93,40.5 182.8,39.37 182.8,38.89 182.66,38.75 182.4,38.75 182.39,38.74 177.65,38.74 177.65,39.17 178.11,39.63 178.11,39.71 178.16,39.91 178.11,40.1 178.11,40.36 178,40.46 177.9,40.46 177.67,40.54 177.44,40.46 175.36,40.46 175.17,40.52 174.98,40.46 174.9,40.46 174.83,40.54 174.83,40.96 174.83,40.97 174.83,41.18 174.9,41.25 181.79,41.25 182.34,41.81 184.66,41.81
+5VSB_HGR_D on BOTTOM (solid shape): 186.93,40.88 186.93,38.64 186.79,38.5 186.04,38.5 185.96,38.58 185.96,40.04 185.96,40.13 185.87,40.13 185.77,40.24 184.42,40.24 184.2,40.45 184.2,40.99 186.82,40.99
+5VSB_LGR_D on BOTTOM (solid shape): 185.22,46.94 185.22,46.71 184.66,46.15 184.66,43.32 184.63,43.29 184.24,43.29 184.16,43.37 184.16,44 183.95,44.22 183.79,44.34 183.79,45.89 183.59,46.09 183.02,46.09 182.91,46.21 182.91,46.92 183.06,47.07 185.09,47.07
+5VSB_PHASE1_S on BOTTOM (solid shape): 193.14,42.15 193.14,35.84 192.53,35.23 187.76,35.23 187.25,35.74 187.25,41.03 187,41.27 185.49,41.27 184.69,42.07 182.23,42.07 182.21,42.09 182.21,43.1 184.66,43.1 184.88,43.32 184.89,43.32 184.89,43.61 185.29,44.02 191.27,44.02
+5VSB_SN_S on BOTTOM (solid shape): 187,46.97 187,45.21 186.66,44.88 185.19,44.88 184.89,45.19 184.89,46.05 185.38,46.55 185.38,46.95 185.5,47.07 186.89,47.07
+19VADC_VIN on TOP (solid shape): outline of 278 points within 38.48,96.78 53.47,102.92
+19VADC_VIN on BOTTOM (solid shape): outline of 245 points within 29.32,95.76 43.08,101.65
+19VADC_VIN on IN1 (solid shape): outline of 180 points within 33.78,95.48 45.42,100.68
+VBATT on TOP (solid shape): outline of 898 points within 120.04,10.39 145.29,20.39
+VBATT on BOTTOM (solid shape): outline of 237 points within 120.92,14.53 147.87,27.22
+VBATT_F on BOTTOM (solid shape): 133.36,18.26 133.36,17.65 132.1,16.4 132.1,14.72 131.2,13.82 127.63,13.82 126.99,14.46 129.82,14.46 129.82,14.4 129.83,14.35 129.85,14.29 129.88,14.24 129.92,14.2 129.96,14.16 130,14.13 130.05,14.1 130.1,14.09 130.16,14.08 130.21,14.07 130.27,14.08 130.32,14.09 130.38,14.12 130.42,14.14 130.47,14.18 130.5,14.22 130.53,14.27 130.56,14.32 130.57,14.37 130.58,14.43 130.58,14.48 130.57,14.54 130.56,14.59 130.53,14.64 130.5,14.69 130.47,14.73 130.42,14.77 130.38,14.8 130.32,14.82 130.27,14.83 130.21,14.84 130.16,14.84 130.1,14.82 130.05,14.81 130,14.78 129.96,14.75 129.92,14.71 129.88,14.67 129.85,14.62 129.83,14.57 129.82,14.51 129.82,14.46 126.99,14.46 126.74,14.71 126.74,16.66 127.43,17.36 127.43,17.83 127.95,18.35 133.26,18.35
+VCCGT on TOP (solid shape): outline of 3621 points within 104.23,60.51 144.53,87.1
+VCCGT on BOTTOM (solid shape): outline of 2209 points within 111.73,62.31 144.42,89.31
+VCCGT on IN1 (solid shape): outline of 97 points within 140.19,66.98 145.32,76.16
+VCCGT on IN1 (solid shape): outline of 4081 points within 104.06,60.99 124.09,81.08
+VCCGT on IN2 (solid shape): outline of 818 points within 118.19,70.06 145.44,85.17
+VCCGT on IN3 (solid shape): outline of 1486 points within 111.91,61.33 123.5,81.33
+VCCGT_BT_D on BOTTOM (solid shape): 160.78,67.77 160.78,65.36 160.76,65.33 160.58,65.33 160.53,65.38 160.53,65.94 160.02,66.45 160.02,67.75 160.1,67.82 160.73,67.82
+VCCGT_PHASE_D on BOTTOM (solid shape): 157.06,73.07 157.06,72.42 156.43,71.78 154.43,71.78 154.39,71.82 154.39,72.57 155.32,72.57 155.85,73.1 157.02,73.1
+VCCGT_PHASE_D on BOTTOM (solid shape): 157.86,64.9 158.95,64.9 159.33,64.52 159.34,64.52 159.84,64.01 160.2,64.01 160.28,63.93 160.28,63.48 160.2,63.4 159.26,63.4 159.08,63.58 159.08,63.81 158.9,63.99 157.4,63.99 157,64.39 157,64.98 157.2,65.18 157.58,65.18
+VCCGT_R_BT_D on BOTTOM (solid shape): 158.98,67.74 158.98,66.3 158.89,66.21 158.89,65.39 158.8,65.31 158.02,65.31 157.94,65.38 157.94,65.71 157.94,65.71 157.86,65.79 157.86,67.31 158.35,67.8 158.93,67.8
+VCCGT_R_HG_D on BOTTOM (solid shape): 158.83,73.67 158.83,73.15 158.72,73.05 157.53,73.05 157.4,73.18 157.4,73.32 157.2,73.53 155.56,73.53 155.19,73.15 154.41,73.15 154.41,73.73 155.23,73.73 155.59,74.09 155.6,74.09 156.5,74.98 157.52,74.98
+VCCGT_R_LG_D on TOP (solid shape): 149.85,74.37 149.85,72.66 149.58,72.39 148.01,72.39 147.85,72.54 147.85,73.69 148.9,74.73 149.49,74.73
+VCCGT_R_LG_D on BOTTOM (solid shape): 149.07,74.73 149.19,74.68 149.33,74.67 149.7,74.67 150.44,73.92 150.44,73.18 150.17,72.9 148.54,72.9 148.36,73.08 148.36,74.5 148.59,74.73
+VCCGT_SN_C on TOP (solid shape): 148.69,71.96 148.69,71.2 148.87,71.02 149.23,71.02 149.38,70.87 149.38,70.08 149.17,69.88 147.8,69.88 147.4,70.28 147.4,71.94 147.55,72.09 148.56,72.09
+VCCIO on TOP (solid shape): 112.95,50.34 112.95,49.43 112.62,49.1 110.84,49.1 110.59,49.35 110.59,49.66 110.74,49.81 111.58,49.81 111.71,49.94 111.71,50.5 111.79,50.57 112.72,50.57
+VCCIO on BOTTOM (solid shape): 133.86,25 134.29,24.56 134.29,24.31 134.14,24.16 132.64,24.16 132.61,24.13 132.61,22.81 132.56,22.76 132.18,22.76 132.11,22.84 132.11,25.89 132.44,26.22 132.87,26.22 133.1,26.44 133.86,26.44
+VCCIO on BOTTOM (solid shape): 112.79,57.05 112.79,56.21 112.33,55.76 112.21,55.76 112.21,55.75 112.05,55.75 111.97,55.76 111.9,55.75 111.44,55.75 111.11,56.08 111.11,56.11 110.88,56.34 110.88,56.44 110.98,56.54 111.26,56.54 111.69,56.11 112.09,56.11 112.3,56.32 112.3,57.06 112.39,57.15 112.69,57.15
+VCCIO on BOTTOM (solid shape): 113.17,50.17 113.17,49.69 113.16,49.61 113.17,49.53 113.17,49.19 112.9,48.92 111.71,48.92 111.7,48.92 111.54,48.96 111.39,48.92 111.38,48.92 111.32,48.92 111.31,48.92 111.03,48.92 110.71,49.24 110.67,49.3 110.62,49.35 110.59,49.38 110.59,49.77 110.64,49.81 110.68,49.87 110.79,49.99 110.79,50 110.99,50.2 111.39,50.2 111.4,50.2 111.65,50.21 111.79,50.43 111.79,50.47 112.52,50.47 112.55,50.55 112.63,50.58 112.76,50.58
+VCCIO on IN1 (solid shape): outline of 233 points within 110.3,48.59 112.94,57.35
+VCCIO on VCC (solid shape): outline of 136 points within 102.79,22.56 136.68,57.3
+VCCIO on IN3 (solid shape): 112.19,57.47 112.41,57.25 112.81,57.25 112.98,57.09 112.98,56.34 112.7,56.06 111.94,56.06 111.18,56.82 111.18,57.61 111.35,57.79 112.19,57.79
+VCCIO on IN3 (solid shape): outline of 135 points within 122.81,60.73 125.02,62.16
+VCCPGPP on TOP (solid shape): outline of 776 points within 113.61,28.69 120.14,42.6
+VCCPLL_OC on TOP (solid shape): 112.68,47.53 112.68,45.89 112.64,45.82 112.62,45.73 112.13,45.73 111.98,45.88 112,46.16 111.86,46.4 111.86,47.54 111.97,47.65 112.55,47.65
+VCCPLL_OC on TOP (solid shape): 31.6,68.94 31.6,67.36 31.4,67.16 31.29,66.94 31.34,66.7 31.2,66.56 30.54,66.56 30.45,66.65 30.45,67.26 29.97,67.74 29.95,67.87 29.9,67.97 29.9,68.23 30.05,68.38 30.25,68.38 30.3,68.43 30.43,68.43 30.45,68.46 30.45,69.19 30.58,69.32 31.22,69.32
+VCCPLL_OC on BOTTOM (solid shape): 32.46,68.61 32.46,67.54 32.28,67.36 31.98,67.36 31.85,67.23 31.4,67.17 31.33,66.72 31.22,66.6 30.43,66.6 30,67.03 29.98,67.17 29.92,67.3 29.92,67.55 29.97,67.74 29.92,67.94 29.92,68.13 30.26,68.47 30.77,68.47 31.14,68.84 32.23,68.84
+VCCPLL_OC on IN1 (solid shape): outline of 1609 points within 91.44,33.78 112.63,47.68
+VCCPRIM_CORE on TOP (solid shape): outline of 653 points within 114.76,16.31 141.25,25.05
+VCCPRIM_CORE on BOTTOM (solid shape): 118.05,26.77 118.05,25.97 117.93,25.86 117.42,25.86 117.1,25.54 116.5,25.54 115.93,24.97 115.93,24.97 115.82,24.83 115.79,24.65 115.79,24.63 115.75,24.59 115.75,23.45 115.81,23.38 116.32,23.38 117.04,22.66 117.04,21.5 117.45,21.09 117.45,20.58 117.27,20.4 114.73,20.4 114.27,20.86 114.27,23.01 114.29,23.08 114.34,23.13 114.34,23.13 114.74,23.49 114.37,23.89 114.3,23.92 114.27,23.99 114.27,26.06 114.4,26.19 115.47,26.19 116.56,27.28 117.54,27.28
+VCCPRIM_CORE on BOTTOM (solid shape): 115.6,45.7 118,45.7 118.26,45.45 118.26,44.91 118.2,44.77 118.22,44.62 117.82,44.22 117.82,44.06 117.73,43.98 117.39,43.98 117.08,44.29 117.08,44.52 117.14,44.69 117.11,44.86 116.9,45.03 116.64,44.97 116.61,44.95 116.21,44.95 115.99,45.04 115.77,44.95 115.75,44.93 115.39,44.93 115.37,44.95 115.15,45.04 114.93,44.95 114.74,44.95 114.7,44.94 114.65,44.93 114.54,44.93 114.42,45 114.27,45.02 114.27,45.01 113.99,45.01 113.75,45.25 113.75,45.56 113.75,45.56 113.75,45.7 115.6,45.7
+VCCPRIM_CORE on IN2 (solid shape): outline of 2188 points within 111.11,25.15 118.08,45.7
+VCCSA on TOP (solid shape): outline of 1402 points within 112.86,33.71 143.82,50.95
+VCCSA on BOTTOM (solid shape): 143.92,39.06 143.92,35.21 143.53,34.82 142.1,34.82 142.09,34.83 140.18,34.83 139.57,35.44 139.57,39.32 140.01,39.75 143.23,39.75
+VCCSA on BOTTOM (solid shape): 113.32,47.65 113.32,47.14 113.26,47.08 113.26,46.23 113.24,46.2 113.17,46.21 113.1,46.2 112.68,46.2 112.39,46.28 112.14,46.11 111.72,46.11 111.69,46.13 111.66,46.15 111.61,46.22 111.62,46.3 111.62,46.49 111.65,46.5 111.81,46.77 111.65,47.04 111.62,47.06 111.62,47.4 111.65,47.42 111.76,47.52 111.81,47.66 111.84,47.72 111.9,47.75 112.33,47.75 112.44,47.86 113.11,47.86
+VCCSA on BOTTOM (solid shape): 122.77,49.9 122.77,49.82 122.69,49.79 121.98,49.79 121.31,49.54 121.98,49.28 122.69,49.28 122.7,49.28 122.91,49.28 123.06,49.42 123.13,49.47 123.22,49.44 123.45,49.22 123.4,49.17 123.4,49.08 123.38,49.02 123.34,48.97 123.24,48.91 123.24,48.34 123.4,48.17 123.24,48 123.24,47.96 122.93,47.96 122.92,47.97 122.53,47.71 122.92,47.45 122.93,47.46 123.35,47.46 123.48,47.32 123.53,47.32 123.53,46.4 123.39,46.26 123.35,46.22 123.31,46.17 123.27,46.14 123.23,46.1 122.91,45.77 122.4,45.77 121.84,46.33 120.97,46.33 120.89,46.41 120.89,48.14 120.91,48.25 120.89,48.35 120.89,49.24 120.89,49.24 120.89,49.92 121.1,50.13 122.54,50.13
+VCCSA on IN1 (solid shape): outline of 385 points within 112.81,45.98 122.74,49.19
+VCCSA on VCC (solid shape): 138.47,42.74 138.51,42.71 138.56,42.7 141.76,42.7 141.76,36.15 141.2,35.59 136.32,35.59 128.36,43.55 128.32,43.58 128.27,43.59 115.9,43.59 112.73,46.77 112.73,48.51 113.18,48.97 132.23,48.97
+VCCSA on IN2 (solid shape): outline of 2048 points within 112.89,35.77 141.5,48.52
+VCCSA on IN3 (solid shape): outline of 639 points within 112.48,44.33 122.52,49.02
+VCCSA_LG_D on BOTTOM (solid shape): 145.63,28.87 145.63,28.21 144.82,27.41 144.25,27.41 144.15,27.51 144.15,28.26 144.83,28.95 145.55,28.95
+VCCSA_PHASE_D on BOTTOM (solid shape): 150.01,40.95 150.01,38.61 150.01,38.18 150.47,37.72 153.95,37.72 154.05,37.62 154.05,36.73 153.95,36.63 150.95,36.63 150.17,35.85 150.17,35.12 149.47,34.42 149.47,33.75 147.58,33.75 147.65,35.48 147.65,41.38 149.58,41.38
+VCCSA_R_HG_D on TOP (solid shape): 152.22,37.67 150.5,37.67 150.32,37.85 149.94,37.85 149.89,37.9 149.89,39.32 152.22,39.32
+VCCSA_R_HG_D on BOTTOM (solid shape): 152.05,39.25 152.05,38.86 151.97,38.79 151.36,38.79 151.03,38.46 150.75,38.46 150.57,38.64 150.57,39.12 150.75,39.3 152,39.3
+VCCSA_R_LG_D on BOTTOM (solid shape): 152.02,36.38 152.02,34.04 152.02,32.55 150.68,32.55 150.61,32.58 150.58,32.65 150.61,34.06 150.61,35.58 151.49,36.45 151.94,36.45
+VCCST on IN1 (solid shape): 125.14,45.71 125.16,45.7 125.18,45.69 125.44,45.43 125.42,45.4 125.52,44.94 125.99,44.99 126.86,44.99 127.3,44.54 128.05,44.54 128.27,44.33 128.27,43.9 128.21,43.83 128.21,43.58 128.19,43.57 128.19,43.05 128.09,42.95 127.71,42.95 127.43,43.24 125.14,43.24 125.01,43.4 124.81,43.46 124.79,43.46 123.85,44.4 123.16,44.4 123.1,44.41 123.03,44.4 121.64,44.4 121.11,44.94 121.11,45.33 121.37,45.59 121.5,45.58 121.63,45.62 123.48,45.62 123.72,45.54 123.95,45.65 124.01,45.68 124.08,45.66 124.3,45.6 124.51,45.68 124.57,45.7 124.64,45.68 124.87,45.6 125.11,45.69
+VCCSTG on IN3 (solid shape): 124.46,44.48 124.46,44.03 123.82,43.39 123.8,43.4 123.75,43.43 123.7,43.45 123.65,43.46 123.6,43.46 123.55,43.46 123.5,43.45 123.45,43.43 123.4,43.4 123.36,43.37 123.34,43.34 123.32,43.37 123.29,43.41 123.25,43.44 123.21,43.47 123.17,43.5 123.12,43.51 123.07,43.52 123.01,43.52 122.96,43.52 122.94,43.51 122.9,43.55 122.9,44.02 123.33,44.02 123.33,43.97 123.34,43.92 123.36,43.87 123.39,43.82 123.42,43.78 123.46,43.74 123.51,43.71 123.56,43.69 123.61,43.67 123.66,43.66 123.71,43.66 123.76,43.67 123.82,43.69 123.86,43.71 123.91,43.74 123.95,43.78 123.98,43.82 124.01,43.87 124.03,43.92 124.04,43.97 124.04,44.02 124.04,44.07 124.03,44.13 124.01,44.18 123.98,44.22 123.95,44.26 123.91,44.3 123.86,44.33 123.82,44.35 123.76,44.37 123.71,44.38 123.66,44.38 123.61,44.37 123.56,44.35 123.51,44.33 123.46,44.3 123.42,44.26 123.39,44.22 123.36,44.18 123.34,44.13 123.33,44.07 123.33,44.02 122.9,44.02 122.9,44.26 123.37,44.73 124.21,44.73
+VDDC_HG1_2_D on BOTTOM (solid shape): 128.68,98.61 128.68,98.33 129.06,97.94 129.82,97.94 130.28,97.49 130.28,95.25 130.2,95.18 129.79,95.18 129.49,94.87 129.13,94.87 128.93,95.07 128.93,96.29 128.68,96.55 128.02,96.55 127.91,96.65 127.91,98.66 128.02,98.76 128.52,98.76
+VDDC_HG2_2_D on BOTTOM (solid shape): 121.06,107.01 121.06,106.2 120.85,106 120.16,106 119.68,105.51 118.26,105.51 118.08,105.69 118.08,106.96 118.26,107.14 120.93,107.14
+VDDC_LG1_2_D on BOTTOM (solid shape): 134.54,98.73 134.54,96.52 134.47,96.45 134.19,96.45 133.99,96.65 132.64,96.65 132.51,96.78 132.51,97.41 132.69,97.59 133.73,97.59 133.83,97.69 133.83,97.92 133.71,98.05 132.92,98.05 132.66,98.3 132.66,98.68 132.79,98.81 134.47,98.81
+VDDC_LG2_2_D on BOTTOM (solid shape): 126.8,106.99 126.8,106.33 127.15,105.97 127.15,104.52 126.95,104.32 125.81,104.32 125.6,104.52 125.6,105.23 124.92,105.92 124.92,106.96 124.99,107.04 126.75,107.04
+VDDC_SN1_A on TOP (solid shape): 138.61,103.91 138.61,100.69 138.15,100.23 136.32,100.23 135.89,100.66 135.89,102.77 136.17,103.05 137.36,103.05 137.57,103.25 137.57,103.96 137.69,104.09 138.43,104.09
+VDDC_SN2_A on TOP (solid shape): 130.25,109.48 130.25,107.65 129.92,107.32 128.24,107.32 127.99,107.57 127.99,109.76 128.32,110.09 129.64,110.09
+VDDC_VGA on TOP (solid shape): 148.31,102.67 148.31,100.76 143.94,96.4 142.01,96.4 141.67,96.74 141.67,99.1 141.96,99.39 143.64,99.39 143.87,99.62 143.87,103.13 144.35,103.61 147.37,103.61
+VDDC_VGA on TOP (solid shape): outline of 515 points within 156.57,83.29 166.81,93.78
+VDDC_VGA on BOTTOM (solid shape): 142.65,113.41 142.65,111.08 143.21,110.52 150.75,110.52 152.68,108.59 154.97,108.59 155.17,108.38 155.17,106.15 155.04,106.02 152.48,106.02 152.1,105.64 152.1,103.08 151.97,102.95 150.5,102.95 150.29,103.15 150.29,105.56 150.06,105.79 147.63,105.79 147.5,105.67 147.5,95.4 147.42,95.33 141.35,95.33 140.97,95.71 140.97,102.21 141.17,102.42 141.17,105.67 140.3,106.54 135.67,106.54 135.08,105.95 133.86,105.95 133.35,106.45 133.35,113.11 133.99,113.74 135.53,113.74 136.07,114.28 141.78,114.28
+VDDC_VGA on BOTTOM (solid shape): outline of 1803 points within 156.9,81.89 167.18,93.07
+VDDC_VGA on VCC (solid shape): outline of 91 points within 133.12,81.05 167.79,111.99
+VDDC_VGA on IN2 (solid shape): outline of 6444 points within 133.3,78.34 166.47,112.04
+VDDC_VGA on IN3 (solid shape): outline of 6456 points within 133.3,78.34 166.47,112.04
+VDDC_VIN on BOTTOM (solid shape): 122.4,110.52 122.4,106.3 122.71,106 123.06,106 123.65,105.41 123.65,102.97 123.98,102.64 129.95,102.64 130.15,102.44 130.15,98.58 129.95,98.38 129.95,98.33 129.26,98.33 129.11,98.48 129.11,99.39 129.13,99.42 129.13,100.21 128.85,100.48 127.29,100.48 126.01,99.2 125.26,99.2 125.25,99.21 124.34,99.21 123.62,99.4 122.89,99.45 122.89,105.26 122.81,105.34 122.66,105.34 122.56,105.44 122.56,105.69 121.36,106.89 121.36,108.23 121.13,108.46 116.97,108.46 116.59,108.84 116.59,110.82 116.84,111.08 121.84,111.08
+VDDC_VIN on IN2 (solid shape): outline of 668 points within 116.46,99.06 128.7,111.97
AGND on TOP (solid shape): 15.62,26.39 15.62,25.69 15.74,25.12 16.29,25.33 16.3,25.34 16.35,25.35 16.38,25.3 16.38,24.34 15.54,23.5 13,23.5 12.85,23.65 12.85,24.07 12.98,24.2 15.07,24.2 15.07,25.37 15.06,25.37 14.83,25.61 14.83,26.54 14.99,26.7 15.32,26.7
AGND on TOP (solid shape): 13.11,55.22 13.19,55.18 13.2,55.09 13.19,54.88 13.29,54.7 13.31,54.66 13.29,54.63 13.56,53.98 13.83,54.63 13.82,54.66 13.83,54.7 13.94,54.88 13.93,55.09 13.94,55.18 14.02,55.22 14.5,55.22 14.66,55.07 14.66,53.6 14.35,53.29 12.75,53.29 12.14,53.9 12.14,54.79 12.57,55.22
AGND on TOP (solid shape): outline of 185 points within 4.29,22.53 12.86,28.3
AGND on BOTTOM (solid shape): 13.84,34.65 13.84,33.31 13.7,33.14 13.67,32.92 13.67,32.9 13.56,32.79 12.52,32.79 12.47,32.84 12.47,33.78 13.44,34.75 13.74,34.75
AGND on BOTTOM (solid shape): 3.27,42.49 3.33,42.58 3.43,42.57 3.57,42.48 3.73,42.44 3.77,42.44 3.77,37.49 3.27,37.49
AGND on BOTTOM (solid shape): 16.15,24.11 15.54,23.5 12.45,23.5 12.45,23.64 15.3,23.64 15.3,24.32 13.4,24.32 13.4,23.64 12.45,23.64 12.45,23.95 12.51,23.97 12.57,23.98 12.62,24.01 12.66,24.04 12.7,24.08 12.74,24.13 12.76,24.18 12.78,24.21 13.06,24.5 16.15,24.5
AGND on BOTTOM (solid shape): 9.37,43.34 9.46,43.3 9.47,43.2 9.43,43.08 9.43,42.95 9.43,42.91 9.41,42.87 9.41,41.74 9.22,41.55 5.15,41.55 4.85,41.86 4.85,42.37 4.83,42.46 4.87,42.52 4.97,42.61 5.05,42.71 5.14,42.76 5.22,42.72 6.01,42.34 6.78,42.77 6.99,42.53 7.29,42.44 8.08,42.44 8.52,42.66 8.62,43.14 8.58,43.25 8.52,43.34
AGND on BOTTOM (solid shape): 9.11,52.77 8.85,52.3 9.3,52.03 9.39,52 9.41,51.91 9.41,51.75 9.44,51.6 9.43,51.5 9.34,51.46 8.54,51.46 8.54,51.53 8.54,51.55 7.58,52.46 6.63,51.55 6.62,51.53 6.62,51.46 6.39,51.46 6.31,51.5 6.3,51.6 6.33,51.75 6.32,51.91 6.22,52.14 6.03,52.3 6.03,52.61 6.35,52.92 9.11,52.92
AGND on BOTTOM (solid shape): 12.88,51.99 12.89,51.99 13.43,51.45 13.43,49.05 13.11,48.73 13.11,42.72 13.02,42.62 12.79,42.51 12.68,42.28 12.56,42.16 10.59,42.16 10.59,42.44 10.78,42.44 11.11,42.55 11.31,42.83 11.36,42.9 11.44,42.9 12.64,43.31 12.49,44.57 12.39,44.65 12.29,44.72 12.29,50.08 12.59,50.34 12.76,50.7 12.5,51.66 11.53,51.93 11.46,51.91 11.39,51.91 11.33,51.97 11.25,52.15 11.1,52.29 11.07,52.4 11.17,52.46 12.41,52.46
AGND on BOTTOM (solid shape): outline of 197 points within 4.29,22.53 13.13,28.9
AGND on GND1 (solid shape): outline of 382 points within 1.87,22.53 16.38,55.22
AGND on IN1 (solid shape): 7.87,54.82 7.96,54.77 7.97,54.68 7.95,54.57 7.96,54.46 7.95,54.37 7.87,54.33 6.24,54.33 4.46,52.55 4.46,51.97 4.45,51.96 4.43,51.8 4.45,51.64 4.46,51.63 4.46,51.46 3.99,51.46 3.91,51.51 3.9,51.6 3.87,52.07 3.5,52.35 3.42,52.42 3.45,52.52 3.63,52.7 3.63,53.69 3.69,53.75 4.4,53.75 4.8,54.15 4.8,54.74 4.88,54.82
AGND on IN1 (solid shape): 9.21,52.99 9.21,52.84 9.15,52.78 8.85,52.33 9.29,52.03 9.36,52.02 9.41,51.97 9.43,51.97 9.41,51.7 9.51,51.46 8.54,51.46 8.54,51.51 8,52.36 7,52.26 6.74,51.95 6.63,51.55 6.62,51.46 6.27,51.46 6.27,51.54 6.28,51.55 6.34,51.81 6.27,52.06 6.27,52.57 6.77,53.06 9.14,53.06
AGND on IN1 (solid shape): outline of 867 points within 3.27,22.53 16.38,52.42
AGND on VCC (solid shape): outline of 382 points within 1.87,22.53 16.38,55.22
AGND on IN2 (solid shape): 13.11,55.22 13.19,55.18 13.2,55.09 13.19,54.88 13.29,54.7 13.31,54.66 13.29,54.63 13.56,53.98 13.83,54.63 13.82,54.66 13.83,54.7 13.94,54.88 13.93,55.09 13.94,55.18 14.02,55.22 14.53,55.22 14.71,55.04 14.71,52.58 14.64,52.49 14.53,52.51 13.09,53.95 10.73,53.95 10.65,53.99 10.63,54.08 10.55,54.43 10.22,54.56 10.18,54.57 10.16,54.6 10.15,54.64 10.14,54.68 10.16,54.77 10.24,54.82 12.17,54.82 12.58,55.22
AGND on IN2 (solid shape): 7.86,53.82 8.22,53.46 8.28,53.46 8.94,52.8 8.96,52.77 8.97,52.74 8.96,52.7 8.94,52.66 8.89,52.22 9.29,52.03 9.36,52.02 9.41,51.97 9.42,51.94 9.41,51.85 9.4,51.78 9.42,51.65 9.44,51.6 9.43,51.5 9.35,51.46 8.54,51.46 8.54,51.51 8.03,52.35 7.05,52.3 6.75,51.98 6.63,51.55 6.62,51.46 6.39,51.46 6.31,51.5 6.24,52.12 5.78,52.36 4.99,52.36 4.53,52.12 4.46,51.5 4.37,51.46 3.99,51.46 3.91,51.5 3.9,51.6 3.87,52.07 3.49,52.35 3.42,52.42 3.45,52.52 3.63,52.7 3.63,53.69 3.69,53.75 4.4,53.75 4.8,54.15 4.8,54.74 4.88,54.82 7.86,54.82
AGND on IN2 (solid shape): outline of 408 points within 3.27,35.17 13.51,52.68
AGND on IN2 (solid shape): outline of 733 points within 4.29,22.53 16.38,50.33
AGND on IN3 (solid shape): 14.72,50.28 14.78,50.38 14.9,50.36 15.42,49.83 15.42,36.58 15.24,36.41 15.24,33.71 15.09,33.55 15.06,33.56 14.68,33.31 14.81,32.87 14.83,32.84 14.83,32.21 14.71,32.08 14.1,32.08 13.97,32.21 13.97,32.24 13.77,32.63 13.34,32.58 13.27,32.55 13.21,32.58 13.04,32.66 12.84,32.65 12.75,32.67 12.71,32.75 12.71,34.5 12.75,34.58 12.85,34.59 13.33,34.8 13.14,35.3 13.09,35.37 13.12,35.46 14.94,37.28 14.94,39.71 14.72,39.93
AGND on IN3 (solid shape): outline of 477 points within 4.29,22.53 16.38,28.46
AGND on IN3 (solid shape): outline of 661 points within 3.27,31.72 13.45,55.22
AGND on GND2 (solid shape): outline of 382 points within 1.87,22.53 16.38,55.22
GND on TOP (solid shape): 10.03,28.2 3.63,28.2 3.63,29.01 10.03,29.01
GND on TOP (solid shape): 80.06,34.67 72.97,27.58 71.27,29.28 78.36,36.37
GND on TOP (solid shape): 118.25,86 115.45,86 115.45,88.51 118.25,88.51
GND on TOP (solid shape): 129.83,112.8 125.13,112.8 125.13,115.29 129.83,115.29
GND on TOP (solid shape): 133.38,86 130.58,86 130.58,88.51 133.38,88.51
GND on TOP (solid shape): 147.66,32.8 145.26,32.8 145.26,44.8 147.66,44.8
GND on TOP (solid shape): 183.86,52.17 181.46,52.17 181.46,57.67 183.86,57.67
GND on TOP (solid shape): 20.14,88.57 20.14,87.99 19.69,87.53 17.09,87.53 16.69,87.94 16.69,88.67 20.04,88.67
GND on TOP (solid shape): 47,85.51 47,84.42 46.61,84.03 43.96,84.03 43.96,85.9 44.07,86.01 46.51,86.01
GND on TOP (solid shape): 17.21,74.23 17.21,73.6 16.88,73.27 15.52,73.27 15.1,73.69 15.1,74.19 15.28,74.37 17.07,74.37
GND on TOP (solid shape): 30.05,101.32 30.05,100.38 29.92,100.26 28.75,100.26 28.47,100.54 28.47,101.22 28.7,101.45 29.92,101.45
GND on TOP (solid shape): 51.08,91.32 51.08,89.77 51,89.69 49.53,89.69 49.43,89.79 49.43,91.26 49.61,91.44 50.95,91.44
GND on TOP (solid shape): 111.33,50.68 111.33,50.09 111.23,49.99 110.13,49.99 109.88,50.24 109.88,50.55 110.11,50.78 111.23,50.78
GND on TOP (solid shape): 124.61,53.39 124.61,53.09 124.54,53.01 121.97,53.01 121.84,53.14 121.84,53.42 121.92,53.49 124.51,53.49
GND on TOP (solid shape): 134.42,102.29 134.42,100.08 134.39,100.05 132.74,100.05 132.54,100.26 132.54,102.39 132.69,102.54 134.16,102.54
GND on TOP (solid shape): 201.73,105.06 201.73,103.05 201.55,102.87 200.69,102.87 200.61,102.95 200.61,105.13 200.66,105.18 201.6,105.18
GND on TOP (solid shape): 201.77,74.14 201.77,73.17 201.4,72.8 200.61,72.8 200.48,72.93 200.48,74.35 200.61,74.48 201.42,74.48
GND on TOP (solid shape): 201.96,95.38 201.96,93.45 201.7,93.2 200.56,93.2 200.36,93.4 200.36,95.56 200.51,95.71 201.63,95.71
GND on TOP (solid shape): 8.92,21.72 8.92,20.2 8.79,20.07 8.01,20.07 7.89,19.94 4.22,19.94 4.22,21.72 4.41,22.02 8.61,22.02
GND on TOP (solid shape): 105.51,53.95 105.39,53.83 103.69,53.83 103.62,53.91 103.62,54.21 103.97,54.56 105.51,54.56
GND on TOP (solid shape): 130.45,88.86 130.45,87.73 130.38,87.66 118.47,87.66 118.42,87.7 118.42,88.79 118.57,88.94 130.38,88.94
GND on TOP (solid shape): 120.93,80.6 120.93,77.02 120.9,76.99 120.9,76.02 120.8,75.92 119.84,75.92 119.71,76.05 119.71,80.72 120.8,80.72
GND on TOP (solid shape): 174.24,50.66 174.24,50.27 174.15,50.19 171.69,50.19 171.63,50.24 171.63,50.55 171.69,50.61 173.21,50.61 173.39,50.79 174.12,50.79
GND on TOP (solid shape): 202.11,85.24 202.11,82.5 201.35,81.74 200.97,81.74 200.91,81.79 200.91,85.17 201.09,85.35 202.01,85.35
GND on TOP (solid shape): 50.11,67.85 50.11,65.2 49.86,64.95 46.81,64.95 46.25,65.51 46.25,67.94 46.92,68.61 48.44,68.61 48.49,68.66 49.3,68.66
GND on TOP (solid shape): 126.92,110.82 126.92,107.19 126.57,106.83 123.37,106.83 122.86,107.34 122.86,112.17 123.19,112.5 125.25,112.5
GND on TOP (solid shape): 184.18,86.69 184.18,84.71 184.07,84.61 183.16,84.61 183.03,84.74 183.03,86.77 183.08,86.82 184.05,86.82
GND on TOP (solid shape): 47.98,31.17 47.98,30.58 47.65,30.25 47.27,30.25 46.91,29.9 46.51,29.9 46.36,30.05 46.36,31.09 46.51,31.24 47.09,31.24 47.22,31.37 47.78,31.37
GND on TOP (solid shape): 121.11,65.41 121.11,63.99 120.85,63.73 113.64,63.73 113.51,63.86 113.51,65.33 113.68,65.5 121.02,65.5
GND on TOP (solid shape): 125.04,77.03 125.01,77.01 124.98,77 124.96,76.98 124.82,76.84 124.71,76.84 124.18,76.3 124,76.3 123.85,76.46 123.85,80.83 125.04,80.83
GND on TOP (solid shape): 158.15,90.06 158.15,89.91 157.53,89.28 157.53,89.04 157.51,89.01 157.48,88.98 157.07,88.98 157.02,89.03 157.02,89.51 157.71,90.2 158.01,90.2
GND on TOP (solid shape): 165.71,98.05 165.71,94.8 165.51,94.59 165.3,94.59 165.2,94.69 165.2,95.15 164.85,95.51 164.85,97.94 165.07,98.17 165.58,98.17
GND on TOP (solid shape): 166.75,89.59 166.75,88.24 166.98,88.01 166.98,87.76 166.73,87.51 166.73,86.97 166.65,86.9 166.27,86.9 166.14,87.02 166.14,89.61 166.27,89.74 166.6,89.74
GND on TOP (solid shape): 176.48,49.18 176.48,47.87 176.64,47.71 176.64,47.45 176.5,47.3 175.74,47.3 175.57,47.47 175.57,47.77 176.08,48.28 176.08,49.18 176.11,49.21 176.44,49.21
GND on TOP (solid shape): 184.56,77.78 184.56,74.73 184.38,74.55 183.34,74.55 183.08,74.81 183.08,77.65 183.41,77.98 184.35,77.98
GND on TOP (solid shape): 82.17,109.88 82.17,108.59 82.02,108.44 77.33,108.44 76.89,108.88 76.89,109.55 76.89,109.55 76.89,109.73 77.06,109.91 80.92,109.91 81.18,110.16 81.89,110.16
GND on TOP (solid shape): 156.06,21.29 156.06,19.84 155.78,19.56 153.72,19.56 153.52,19.76 153.52,20.17 155.19,20.17 155.22,20.2 155.22,21.39 155.26,21.43 155.92,21.43
GND on TOP (solid shape): 176.68,50.65 176.68,50.4 176.49,50.2 176.49,49.63 176.41,49.56 176.12,49.56 176.06,49.62 176.06,50.04 176,50.11 175.74,50.11 175.5,50.36 175.5,50.74 175.57,50.82 176.51,50.82
GND on TOP (solid shape): 185.27,104.73 185.27,104.29 185.18,104.21 183.77,104.21 183.24,103.68 183.01,103.68 182.85,103.84 182.85,104.02 183.67,104.83 185.17,104.83
GND on TOP (solid shape): 49.53,54.87 49.53,52.17 49.33,51.97 48.79,51.97 48.79,53.24 47.98,54.05 47.88,54.05 47.63,54.31 47.63,55.37 47.7,55.45 48.95,55.45
GND on TOP (solid shape): 160.27,91.9 160.27,90.93 160.17,90.83 159.72,90.83 159.33,91.21 158.93,91.21 158.83,91.32 158.83,91.62 158.9,91.7 159.36,91.7 159.77,92.1 160.07,92.1
GND on TOP (solid shape): 62.26,110.64 62.26,109.55 62.15,109.45 58.42,109.45 58.27,109.3 57.46,109.3 57.4,109.35 57.4,109.52 57.4,109.53 57.4,110.46 57.79,110.85 62.05,110.85
GND on TOP (solid shape): 67.15,106.83 67.62,106.83 67.77,106.68 67.77,105.56 67.56,105.36 65.56,105.36 65.3,105.62 65.3,106.66 65.53,106.89 67.15,106.89
GND on TOP (solid shape): 186.28,94.59 186.28,93.06 186.28,93.05 186.26,92.92 186.28,92.79 186.28,92.78 186.28,92.59 185.85,92.59 185.55,92.89 185.55,94.72 185.78,94.95 185.93,94.95
GND on TOP (solid shape): 43.23,83.34 43.23,81.94 43.1,81.82 42.62,81.82 42.32,81.51 42.32,81.08 42.16,80.93 42.01,80.93 41.86,81.08 41.86,82.35 42.01,82.5 42.42,82.5 42.49,82.58 42.49,83.39 42.62,83.52 43.05,83.52
GND on TOP (solid shape): 96.09,96.01 96.09,95.28 96.19,95.18 97.23,95.18 97.31,95.25 97.31,95.43 97.38,95.51 97.66,95.51 97.71,95.46 97.71,93.91 97.61,93.8 97.05,93.8 96.72,94.13 95.73,94.13 95.56,94.31 95.56,95.99 95.63,96.07 96.04,96.07
GND on TOP (solid shape): 118.8,60.2 118.8,57.47 118.69,57.37 113.9,57.37 113.61,57.66 113.61,59.61 113.66,59.71 113.67,59.82 113.67,59.93 113.67,60.07 113.92,60.33 118.67,60.33
GND on TOP (solid shape): 152.15,8.74 151.93,8.58 151.74,8.37 151.57,8.23 151.35,8.17 147.65,8.17 147.65,9.67 152.15,9.67
GND on TOP (solid shape): 162.33,89.72 162.33,87.3 162.28,87.25 161.75,87.25 161.67,87.33 161.67,88.17 161.42,88.42 161.26,88.42 161.19,88.5 161.19,89.03 161.24,89.08 161.52,89.08 161.72,89.28 161.72,89.84 161.8,89.92 162.13,89.92
GND on TOP (solid shape): 165.1,89.05 165.1,87.35 164.9,87.15 163.2,87.15 163.17,87.18 163.17,87.53 163.45,87.81 163.45,88.17 163.6,88.32 164.29,88.32 164.41,88.45 164.41,89.08 164.52,89.18 164.97,89.18
GND on TOP (solid shape): 57.18,69.42 57.18,67.49 57.07,67.39 55.58,67.39 55.34,67.62 55.42,67.89 55.3,68.14 55.3,69.32 55.47,69.5 57.1,69.5
GND on TOP (solid shape): 111.18,55.22 111.18,51.41 110.97,51.21 109.96,51.21 109.83,51.34 109.83,54.28 109.19,54.92 109.21,55.08 109.18,55.23 109.32,55.37 111.02,55.37
GND on TOP (solid shape): 168.1,84.71 168.33,84.71 168.64,84.39 168.64,83.99 168.39,83.73 167.36,83.73 167.36,83.62 167.16,83.42 167.16,82.17 167.01,82.02 166.75,82.02 166.65,82.12 166.65,83.59 166.73,83.67 166.88,83.67 167.28,84.08 167.28,84.65 167.37,84.74 168.07,84.74
GND on TOP (solid shape): 105.41,48.9 105.41,48.8 105.36,48.75 104.5,48.75 104.46,48.71 103.62,48.71 103.49,48.84 103.49,49.04 103.94,49.49 104.77,49.49 104.78,49.48 104.83,49.48 104.84,49.49 104.95,49.49 104.95,49.94 104.97,49.95 105.41,49.95
GND on TOP (solid shape): 168.91,98.68 169.37,98.68 169.52,98.53 169.52,97.54 169.24,97.26 168.22,97.26 168,97.03 168,96.57 167.84,96.42 167.39,96.42 167.23,96.57 167.23,97.79 167.31,97.87 167.95,97.87 168.05,97.97 168.05,98.66 168.2,98.81 168.78,98.81
GND on TOP (solid shape): 17.48,31.93 18.52,31.93 18.72,32.13 19.61,32.13 20.37,31.37 20.37,26.88 20.07,26.57 17.36,26.57 17.05,26.88 14.88,26.88 14.66,27.1 14.66,31.4 14.81,31.55 16.51,31.55 16.51,32.01 16.66,32.16 17.25,32.16
GND on TOP (solid shape): 122.86,31.24 122.86,30.92 122.78,30.69 122.86,30.45 122.86,29.42 122.76,29.31 122.33,29.31 122.23,29.42 122.23,29.95 121.89,30.28 121.89,31.37 121.92,31.4 122.71,31.4
GND on TOP (solid shape): 123.95,48.75 123.95,48.7 123.92,48.56 123.95,48.42 123.95,47.83 123.92,47.71 123.94,47.59 123.71,47.36 122.92,47.36 122.89,47.4 122.89,48.92 122.94,48.97 123.72,48.97
GND on TOP (solid shape): 58.55,52.86 58.55,51.44 58.7,51.29 58.98,51.29 59.2,51.06 59.2,51.03 59.18,50.9 59.21,50.77 59.25,50.72 59.28,50.67 59.28,49.74 59.27,49.73 58.62,49.73 58.62,49.56 57.84,49.56 57.66,49.74 57.66,53.09 58.32,53.09
GND on TOP (solid shape): 111.84,48.82 111.84,47.98 111.59,47.74 111.59,46.78 111.3,46.49 110.57,46.49 110.39,46.66 110.39,46.72 110.42,46.84 110.39,46.97 110.39,48.5 110.4,48.54 110.39,48.59 110.39,48.77 110.55,48.92 111.73,48.92
GND on TOP (solid shape): 172.37,100.68 172.38,100.67 172.48,100.49 172.65,100.4 172.66,100.39 172.69,100.36 172.69,100.08 172.44,99.82 170.94,99.82 170.71,99.6 170.71,99.01 170.61,98.91 170.1,98.91 170.03,98.99 170.03,100.31 170.49,100.76 172.29,100.76
GND on TOP (solid shape): 106.78,44.27 110.19,44.27 110.31,44.15 110.31,43.18 109.73,43.18 109.65,43.26 109.65,43.44 109.5,43.59 105.33,43.59 104.57,42.83 104.29,42.83 104.22,42.9 104.19,42.95 104.16,42.99 104.16,43.4 105.16,44.4 106.65,44.4
GND on TOP (solid shape): 124.92,46.64 124.92,46.41 124.82,46.31 124.32,46.31 124.28,46.31 124.23,46.31 124,46.31 123.9,46.21 123.9,45.8 123.77,45.67 123.55,45.67 123.47,45.75 123.47,45.94 123.47,45.94 123.47,46.18 123.39,46.26 121.92,46.26 121.84,46.33 121.84,46.56 121.95,46.66 123.42,46.66 123.6,46.84 124.71,46.84
GND on TOP (solid shape): 36.25,72.8 36.25,68.63 36.47,68.4 36.47,67.41 36.42,67.36 35.43,67.36 35.33,67.46 35.33,68.73 35.43,68.84 35.43,69.98 35.41,70 34.44,70 34.37,70.08 34.37,70.18 34.44,70.26 35.41,70.26 35.43,70.28 35.43,71.45 34.82,72.06 34.82,72.88 35,73.05 35.99,73.05
GND on TOP (solid shape): 1.5,55.48 1.5,54.92 1.58,54.84 1.98,54.84 2.08,54.74 2.08,54.33 2.01,54.26 0.97,54.26 0.82,54.41 0.82,55 0.95,55.34 1.28,55.49 1.37,55.5 1.47,55.5
GND on TOP (solid shape): 10.63,73.9 9.95,73.9 9.65,74.3 9.18,74.45 4.74,74.45 4.74,75.11 4.89,75.55 4.74,75.99 4.74,79.8 10.63,79.8
GND on TOP (solid shape): 153.01,72.37 153.01,42.32 153.75,41.58 153.75,39.91 153.52,39.68 150.53,39.68 150.24,39.97 150.24,48.14 151,48.9 151,49.76 151.35,50.1 151.88,50.1 152.15,50.37 152.15,51.77 151.42,52.49 148.99,52.49 148.6,52.49 147.7,53.39 147.7,55.96 149.58,57.84 149.58,71.05 149.35,71.27 149.02,71.27 148.87,71.43 148.87,71.88 149.02,72.04 149.63,72.04 150.11,72.52 150.11,72.88 150.27,73.03 152.35,73.03
GND on TOP (solid shape): 123.83,51.54 123.83,51.19 123.75,51.11 122.71,51.11 122.53,50.94 122.53,49.91 121.88,49.26 121.36,49.26 120.99,48.9 120.99,47.41 120.91,47.32 113.54,47.32 112.9,47.96 112.9,48.77 113.04,48.92 113.08,49.11 113.08,49.16 113.11,49.2 120.69,49.2 120.9,49.41 120.9,50.29 121.06,50.45 121.84,50.45 122.07,50.68 122.07,51.06 121.87,51.26 121.87,51.46 122.25,51.84 123.52,51.84
GND on TOP (solid shape): 128.4,56.09 128.4,55.51 128.39,55.43 128.4,55.34 128.4,55.2 128.52,55.07 128.72,55.07 128.85,55.07 128.96,54.97 128.96,54.71 128.85,54.61 128.42,54.61 128.37,54.66 128.37,54.84 127.74,55.48 127.57,55.48 127.42,55.51 127.26,55.48 126.11,55.48 125.92,55.29 125.92,55.23 125.93,55.23 125.93,54.94 125.76,54.76 121.97,54.76 121.82,54.92 121.82,55.22 121.95,55.35 125.45,55.35 125.93,55.83 125.93,56.11 126.01,56.19 128.3,56.19
GND on TOP (solid shape): 163.17,97.82 163.17,93.96 163.42,93.7 164.59,93.7 165.3,92.99 165.3,91.67 165.41,91.57 165.41,90.99 165.25,90.83 164.03,90.83 164.01,90.86 164.01,91.42 164.03,91.44 164.34,91.44 164.47,91.57 164.47,92.74 164.08,93.12 163.3,93.12 163.17,92.99 163.17,92.56 162.99,92.38 162.56,92.38 162.43,92.26 162.43,91.52 162.61,91.34 162.64,91.32 162.83,91.32 162.88,91.26 162.88,90.95 162.84,90.91 161.33,90.91 161.15,91.09 161.15,91.46 161.49,91.8 161.49,92.81 161.8,93.12 161.8,93.6 162.43,94.24 162.43,97.77 162.61,97.94 163.04,97.94
GND on TOP (solid shape): 128.04,53.9 128.04,53.52 127.94,53.42 127.16,53.42 127.1,53.37 126.49,53.37 126.19,53.06 126.19,52.2 126.29,52.1 126.62,52.1 126.75,51.97 126.75,51.34 127.1,50.98 127.89,50.98 127.94,50.98 128.12,50.98 128.24,51.11 128.24,51.2 128.25,51.21 128.27,51.34 128.25,51.46 128.24,51.47 128.24,51.51 128.37,51.64 128.37,52.1 128.55,52.28 129.18,52.28 129.51,51.95 129.51,50.45 129.29,50.22 126.34,50.22 126.09,50.47 125.73,50.47 125.58,50.62 125.58,51.23 125.55,51.26 125.55,53.44 125.98,53.88 127.33,53.88 127.41,53.95 127.99,53.95
GND on TOP (solid shape): 7.67,99.85 7.67,99.8 7.68,99.75 7.68,97.47 7.85,96.53 8.34,95.69 8.34,94.55 3.03,94.55 3.03,94.67 3.33,95.07 3.46,95.56 3.46,95.63 3.34,96.15 3.03,96.57 3.03,99.85
GND on TOP (solid shape): 159.92,89.11 159.92,88.42 159.94,88.39 159.94,88.28 160.06,88.28 160.25,88.09 160.25,87.66 159.94,87.35 159.91,87.35 159.79,87.34 159.67,87.3 159.49,87.01 159.61,86.69 159.61,86.34 159.51,86.24 158.78,86.24 158.52,86.49 157.86,86.49 157.76,86.59 157.76,87.04 157.97,87.25 158.73,87.25 158.74,87.25 158.9,87.25 158.92,87.25 159.03,87.37 159.03,88.18 159.18,88.18 159.18,89.07 159.32,89.21 159.82,89.21
GND on TOP (solid shape): 154.97,90.91 154.97,87.43 154.74,87.2 154.51,87.2 153.77,87.94 153.77,88.46 153.81,88.5 153.84,88.49 154.3,88.84 153.88,89.24 153.81,89.27 153.77,89.34 153.77,89.79 153.85,89.87 153.87,89.87 153.97,89.88 154.06,89.91 154.07,89.92 154.13,89.92 154.34,90.13 154.34,90.92 154.41,90.99 154.89,90.99
GND on TOP (solid shape): 42.82,104.27 42.82,102.26 42.49,101.93 42.14,101.93 41.15,100.94 41.15,98.77 40.91,98.53 40.47,98.53 40.46,98.53 40.31,98.56 40.16,98.53 40.15,98.53 38.47,98.53 38.33,98.39 38.33,96.96 38.31,96.9 38.3,96.83 38.05,96.57 36.68,96.57 36.58,96.67 36.58,98.91 36.65,98.99 38.23,98.99 38.74,99.49 38.74,100.5 39.03,100.5 39.03,102.28 38.95,102.28 38.95,102.35 38.97,102.37 39.14,102.69 38.96,103.01 38.96,103.25 39.04,103.25 39.04,104.22 39.68,104.85 42.24,104.85
GND on TOP (solid shape): 111.58,65.92 111.58,60.3 111.61,60.28 111.61,58.52 111.53,58.45 111.13,58.45 111,58.57 111,59.06 110.39,59.67 110.39,62.04 110.57,62.35 110.39,62.66 110.39,63.86 110.56,64.16 110.39,64.46 110.11,64.75 110.11,64.8 110.25,65.02 110.2,65.28 110.3,65.37 110.34,65.5 110.34,66.27 111.23,66.27
GND on TOP (solid shape): 159.61,95.3 159.61,94.13 159.53,94.05 159.49,94.09 159.16,94.21 158.87,94.01 158.86,93.98 157.2,93.98 157.18,94.01 157.18,94.57 158.03,95.42 158.09,95.36 158.08,95.33 158.46,94.82 158.87,95.31 158.89,95.39 158.97,95.43 159.49,95.43
GND on TOP (solid shape): 119.61,54.43 119.61,53.9 119.71,53.8 120.66,53.8 120.72,53.75 120.72,52.8 120.52,52.61 119.65,52.61 119.55,52.62 119.47,52.61 119.04,52.61 118.94,52.62 118.86,52.61 118.43,52.61 118.32,52.62 118.22,52.61 118.21,52.61 117.72,52.61 117.62,52.62 117.54,52.61 117.08,52.61 116.99,52.62 116.9,52.61 116.47,52.61 116.38,52.62 116.29,52.61 115.85,52.61 115.75,52.62 115.67,52.61 115.06,52.61 114.97,52.62 114.88,52.61 114.45,52.61 114.36,52.62 114.27,52.61 113.84,52.61 113.75,52.62 113.66,52.61 113.64,52.61 113.49,52.76 113.49,54.36 113.61,54.49 119.56,54.49
GND on TOP (solid shape): 213.26,7.51 214.09,4.43 214.08,4.28 214.08,1.02 220.3,1.02 220.64,0.67 221.1,0.51 214.07,0.51 213.72,0.65 213.58,1 213.58,4.28 213.58,4.43 212.73,7.4 210.43,9.44 210.7,9.58 210.96,9.74
GND on TOP (solid shape): 123.22,65.25 123.22,64.98 123.24,64.95 123.24,64.57 123.34,64.47 123.65,64.47 123.85,64.26 123.85,63.91 123.64,63.69 123.36,63.69 123.24,63.58 123.24,62.89 123.37,62.77 124.31,62.77 124.46,62.61 124.46,62.13 124.46,61.03 124.43,60.95 124.35,60.93 124.18,60.91 124.03,60.81 123.95,60.79 123.89,60.82 123.54,60.93 123.28,60.67 123.44,60.19 123.92,60.36 123.97,60.37 124.02,60.34 124.27,60.22 124.52,60.3 124.58,60.34 124.61,60.31 124.73,60.24 124.86,60.22 124.93,60.23 124.99,60.24 125.1,60.32 125.18,60.43 125.22,60.47 125.22,60.89 125.43,61.09 126.47,61.09 126.59,60.96 126.59,60.3 127.13,59.77 127.13,59.39 127.03,59.29 124.94,59.29 124.61,58.96 124.04,58.96 123.83,58.74 123.83,57.45 123.75,57.37 122.44,57.37 122.3,57.51 122.3,58.4 122.35,58.45 122.5,58.45 122.64,58.59 122.64,60.16 122.63,60.18 122.63,65.21 122.73,65.31 123.16,65.31
GND on TOP (solid shape): 168.31,93.74 168.54,93.75 168.68,93.67 168.68,93.41 168.45,93.19 168.42,92.87 168.41,92.79 168.35,92.74 168.29,92.71 168.22,92.66 168.19,92.65 168.15,92.67 168.14,92.67 168.02,92.76 167.87,92.79 167.59,92.67 167.49,92.38 167.49,92.37 167.6,92.14 167.83,92.03 167.85,92.03 168.19,91.68 168.22,91.6 168.18,91.52 168.1,90.98 168.64,90.91 168.67,90.94 169.42,90.2 169.42,89.92 169.27,89.77 168.98,89.77 168.9,89.81 168.88,89.89 168.83,90.2 168.56,90.36 168.4,90.35 168.26,90.27 168.19,90.25 168.12,90.27 167.9,90.37 167.66,90.3 167.49,90.48 167.49,91.52 166.88,92.13 166.88,93.4 166.92,93.44 167.3,93.44 167.48,93.27 167.95,93.27 168.13,93.35 168.2,93.54
GND on TOP (solid shape): outline of 177 points within 138.15,32.21 145.95,51.08
GND on TOP (solid shape): outline of 97 points within 113.46,42.04 120.85,45.75
GND on TOP (solid shape): outline of 180 points within 2.71,56.72 14.06,60.89
GND on TOP (solid shape): outline of 274 points within 112.12,74.27 115.93,82.96
GND on TOP (solid shape): outline of 84 points within 0.52,76.08 10.52,84.23
GND on TOP (solid shape): 3.78,36.08 10.03,36.08 10.03,35.28 3.78,35.28 3.78,10.65 4.06,9.95 4.76,9.67 12.03,9.67 14.32,9.11 16.1,7.58 20.01,4.22 25.02,3.02 103.52,3.02 103.52,6.35 104.4,8.48 106.53,9.37 108.88,9.37 109.79,9.28 110.66,9.03 111.56,8.77 112.49,8.68 151.34,8.68 152.05,9.27 152.95,9.48 202.68,9.48 204.3,9.63 205.87,10.06 206.12,10.31 210.34,10.31 210.97,9.68 210.97,9.55 210.72,9.3 210.71,9.3 208.44,9.96 206.1,9.61 206.04,9.59 205.79,9.5 205.54,9.41 205.54,9.41 204.13,9.08 202.68,8.97 152.95,8.97 152.27,8.81 151.57,8.23 151.35,8.17 112.49,8.17 111.46,8.27 110.48,8.56 109.69,8.78 108.88,8.86 106.53,8.86 104.76,8.12 104.02,6.35 104.02,3 103.88,2.65 103.53,2.51 25.02,2.51 19.78,3.77 15.69,7.28 14.09,8.66 12.03,9.16 4.76,9.16 3.7,9.59 3.27,10.65 3.27,36.98 3.78,36.98
GND on TOP (solid shape): outline of 1553 points within 0.51,0.51 226.32,115.29
GND on BOTTOM (solid shape): 162.13,8.77 155.63,8.77 155.63,9.67 162.13,9.67
GND on BOTTOM (solid shape): 120.9,80.65 120.9,77.04 119.84,77.04 119.69,77.19 119.69,80.57 119.81,80.7 120.85,80.7
GND on BOTTOM (solid shape): 23.19,91.8 23.19,90.93 23.09,90.83 20.68,90.83 20.6,90.91 20.6,91.39 21.29,92.08 22.91,92.08
GND on BOTTOM (solid shape): 93.04,10.87 93.04,8.51 92.81,8.28 90.98,8.28 90.42,8.84 90.42,11.03 90.78,11.38 92.53,11.38
GND on BOTTOM (solid shape): 110.69,17.17 110.69,16.59 110.44,16.33 107.26,16.33 107.14,16.46 107.14,16.84 107.57,17.27 110.59,17.27
GND on BOTTOM (solid shape): 184.51,104.22 184.51,102.77 184.46,102.72 183.11,102.72 182.85,102.97 182.85,104.29 183.06,104.5 184.23,104.5
GND on BOTTOM (solid shape): 199.57,69.95 199.57,69.42 199.42,69.27 198.22,69.27 198.17,69.32 198.17,69.98 198.3,70.11 199.42,70.11
GND on BOTTOM (solid shape): 201.7,105.08 201.7,102.97 201.57,102.85 200.74,102.85 200.63,102.95 200.63,105.16 200.69,105.21 201.57,105.21
GND on BOTTOM (solid shape): 206.02,80.32 206.02,79.4 205.79,79.17 204.08,79.17 203.82,79.43 203.82,80.42 204,80.6 205.74,80.6
GND on BOTTOM (solid shape): 210.01,80.57 210.01,79.53 209.8,79.33 208.46,79.33 208.2,79.58 208.2,80.57 208.38,80.75 209.83,80.75
GND on BOTTOM (solid shape): 1.17,99.57 1.17,98.33 1.07,98.23 0.51,98.23 0.51,99.78 0.96,99.78
GND on BOTTOM (solid shape): 122.3,85.98 122.3,85.17 122.12,84.99 118.54,84.99 118.43,85.11 118.43,86.08 118.48,86.13 122.15,86.13
GND on BOTTOM (solid shape): 132.94,32.79 132.94,31.98 132.84,31.88 131.72,31.88 131.62,31.98 131.62,32.82 131.72,32.92 132.82,32.92
GND on BOTTOM (solid shape): 150.49,23.08 150.49,22.63 150.04,22.18 149.12,22.18 149,22.3 149,22.99 149.19,23.18 150.39,23.18
GND on BOTTOM (solid shape): 201.78,74.42 201.78,73 201.65,72.88 200.63,72.88 200.51,73 200.51,74.55 200.56,74.6 200.56,74.63 201.57,74.63
GND on BOTTOM (solid shape): 80.59,94.44 80.59,88.66 80.23,88.31 73.81,88.31 73.38,88.74 73.38,92.2 75.92,94.74 80.29,94.74
GND on BOTTOM (solid shape): 100.15,114.94 100.15,114.15 100.08,114.07 97.28,114.07 97.08,114.28 97.08,114.96 97.21,115.09 100,115.09
GND on BOTTOM (solid shape): 134.26,23.88 134.26,22.94 134.14,22.81 132.92,22.81 132.77,22.96 132.77,24 134.14,24
GND on BOTTOM (solid shape): 142.44,33.12 142.44,32.52 142.12,32.19 141.45,32.19 141.3,32.34 141.3,32.46 139.93,33.84 139.93,34.26 140.06,34.39 141.17,34.39
GND on BOTTOM (solid shape): 184.3,86.87 184.3,84.94 183.95,84.58 183.16,84.58 182.98,84.76 182.98,86.92 183.08,87.02 184.15,87.02
GND on BOTTOM (solid shape): 139.78,31.55 139.78,30.51 139.66,30.39 139.41,30.39 138.71,31.09 138.71,31.85 138.79,31.92 139.4,31.92
GND on BOTTOM (solid shape): 201.85,95.53 201.85,91.65 201.57,91.37 200.66,91.37 200.58,91.44 200.58,95.66 200.63,95.71 201.68,95.71
GND on BOTTOM (solid shape): 52.22,21.47 52.22,20.86 51.79,20.42 49.66,20.42 49.48,20.6 48.49,20.6 48.39,20.7 48.39,21.44 48.44,21.49 49.28,21.49 49.48,21.69 51.99,21.69
GND on BOTTOM (solid shape): 115.16,85.65 115.16,81.84 115.34,81.66 115.34,80.37 114.99,80.01 113.69,80.01 112.42,81.28 112.42,82.73 113.21,83.52 113.21,85.14 113.92,85.85 114.96,85.85
GND on BOTTOM (solid shape): 134.63,29.87 134.77,29.87 134.82,29.82 134.82,29.09 134.8,29.06 133.63,29.06 133.58,29.11 133.58,30.03 133.65,30.1 134.16,30.1 134.41,30.1
GND on BOTTOM (solid shape): 167.46,106.56 167.46,105.36 167.08,104.98 165.81,104.98 165.68,105.11 165.68,105.34 166.01,105.67 166.01,106.63 166.09,106.71 167.31,106.71
GND on BOTTOM (solid shape): 194.74,71.86 194.74,70.74 194.51,70.51 193.12,70.51 193.01,70.61 193.01,71.15 192.94,71.22 192.94,71.96 193.12,72.14 194.46,72.14
GND on BOTTOM (solid shape): 195.67,55.84 195.67,55.29 194.92,54.54 193.75,54.54 193.4,54.89 193.4,55.45 193.52,55.58 194.97,55.58 195.12,55.73 195.12,55.88 195.22,55.98 195.53,55.98
GND on BOTTOM (solid shape): 202.08,85.85 202.08,82.93 201.85,82.7 201.68,82.7 201.36,83.02 200.72,83.02 200.61,83.14 200.61,86.11 200.66,86.16 201.78,86.16
GND on BOTTOM (solid shape): 66.47,10.04 66.47,9.69 66.42,9.63 66.42,9.12 66.17,8.87 65.56,8.87 65.08,8.38 64.31,8.38 63.88,8.82 63.88,10.14 64.19,10.44 66.07,10.44
GND on BOTTOM (solid shape): 80.46,26.55 80.46,23.7 80.2,23.44 75.46,23.44 74.44,24.45 74.44,26.47 74.8,26.82 80.19,26.82
GND on BOTTOM (solid shape): 99.59,111.1 99.59,110.87 99.94,110.53 99.94,109.97 99.87,109.91 97.97,109.91 97.84,110.04 97.84,111.03 97.99,111.18 98.98,111.18 99.01,111.2 99.49,111.2
GND on BOTTOM (solid shape): 175.87,66.73 180.75,66.73 180.82,66.65 180.82,65.18 180.54,64.9 175.08,64.9 174.9,65.08 174.9,66.93 175.08,67.11 175.49,67.11
GND on BOTTOM (solid shape): 196.8,56.77 196.8,55.43 196.7,55.32 196.42,55.32 196.24,55.5 196.24,55.88 196.01,56.11 195.53,56.11 195.17,56.47 195.17,56.77 195.38,56.97 196.6,56.97
GND on BOTTOM (solid shape): 113.46,113.69 113.46,110.49 113.35,110.38 112.45,110.38 112.29,110.54 112.29,112.07 111.33,113.03 110.85,113.03 110.78,113.1 110.78,113.48 110.95,113.48 110.92,113.5 110.92,113.9 111.28,114.25 112.9,114.25
GND on BOTTOM (solid shape): 172.77,111.64 176.38,111.64 176.58,111.43 176.58,110.59 175.92,109.93 175.92,109.91 175.54,109.53 173.2,109.53 171.76,110.98 169.37,110.98 169.14,111.2 169.14,112.42 169.34,112.63 171.78,112.63
GND on BOTTOM (solid shape): 203.07,52.73 203.48,52.33 204.8,52.33 204.95,52.17 204.95,51.41 204.75,51.21 203.61,51.21 203.25,50.85 202.84,50.85 202.67,51.03 202.67,53.04 202.82,53.19 203.07,53.19
GND on BOTTOM (solid shape): 11.71,91.82 11.71,91.68 11.76,91.68 11.76,91.67 12.19,91.24 12.19,89.13 12.09,89.03 11.74,89.03 11.07,89.69 10.8,89.69 10.39,90.1 10.39,91.19 10.52,91.32 10.52,91.87 10.67,92.03 11.51,92.03
GND on BOTTOM (solid shape): 102.11,106.99 102.11,102.31 101.07,101.27 101.07,100.56 100.27,99.76 98.9,99.76 98.73,99.93 98.73,100.66 99.14,101.07 99.14,103.61 99.73,104.21 99.73,107 100.05,107.32 101.78,107.32
GND on BOTTOM (solid shape): 23.14,95.76 23.14,94.82 23.11,94.8 17.98,94.8 17.88,94.9 17.88,95.43 18.16,95.71 18.49,95.71 18.59,95.81 18.59,95.94 18.72,96.07 18.85,96.12 22.78,96.12
GND on BOTTOM (solid shape): 31.42,98.99 31.42,98 31.29,97.87 30.05,97.87 29.07,96.89 29.04,96.87 29.01,96.85 28.97,96.82 28.93,96.78 28.68,96.78 28.5,96.95 28.5,98.19 29.45,99.14 31.27,99.14
GND on BOTTOM (solid shape): 163.41,44.31 162.94,43.84 162.15,43.84 162,44 162,45.15 162.26,45.41 162.26,45.99 162.24,46.03 162.24,46.18 162.26,46.21 162.26,46.97 162.88,47.59 162.88,50.19 162.9,50.22 163.41,50.22
GND on BOTTOM (solid shape): 99.31,97.87 99.31,96.98 99.85,96.45 99.85,95.05 99.49,94.69 96.04,94.69 95.73,95 95.73,95.4 95.94,95.61 97.26,95.61 98.32,96.67 98.32,97.94 98.37,98 99.19,98
GND on BOTTOM (solid shape): 137.86,56.28 137.86,55.79 138.15,55.5 139.12,55.5 139.17,55.45 139.17,54.71 139.12,54.66 137.11,54.66 136.98,54.79 136.98,56.42 137.06,56.49 137.64,56.49
GND on BOTTOM (solid shape): 155.12,114.4 155.12,112.32 155.13,112.31 155.13,111.25 155.47,110.91 155.47,110.19 155.38,110.1 151.9,110.1 151.16,110.85 143.66,110.85 143.31,111.2 143.31,114.07 143.87,114.63 154.89,114.63
GND on BOTTOM (solid shape): 165.98,112.92 165.98,112.49 166.24,112.22 167.77,112.22 168.22,111.76 168.22,111.31 168.12,111.2 165.99,111.2 165.43,111.76 163.4,111.76 163.32,111.84 163.32,112.78 163.53,112.98 165.91,112.98
GND on BOTTOM (solid shape): 125.4,80.37 129.34,80.37 129.43,80.28 129.43,80.1 129.46,80.06 129.46,79.12 129.44,79.1 125.65,79.1 125.05,78.49 125.05,76.99 124.33,76.28 123.98,76.28 123.85,76.4 123.85,80.73 123.89,80.76 125.01,80.76
GND on BOTTOM (solid shape): 168.3,25.33 168.3,24.28 168.4,24.18 168.61,24.18 168.78,24.01 168.78,23.32 169.01,23.09 169.16,23.09 169.39,22.86 169.39,22.46 169.24,22.3 166.27,22.3 165.89,22.68 165.89,23.6 166.52,24.23 166.52,25.33 166.68,25.48 168.15,25.48
GND on BOTTOM (solid shape): 188.95,28.02 188.95,26.52 189.8,25.67 189.8,25.05 189.74,24.98 189.74,24.27 189.8,24.21 189.8,21.63 189.71,21.54 188.37,21.54 188.19,21.72 188.19,28.04 188.34,28.2 188.77,28.2
GND on BOTTOM (solid shape): 205.21,56.9 205.21,56.09 205,55.88 204.44,55.88 204.32,55.76 204.32,55.25 204.17,55.1 203.84,55.1 203.66,55.27 203.66,55.65 203.53,55.78 203.01,55.78 202.95,55.84 202.95,56.19 203,56.24 203.56,56.24 203.66,56.34 203.66,56.92 203.71,56.97 205.13,56.97
GND on BOTTOM (solid shape): 83.67,104.37 83.67,103.08 84.1,102.64 84.96,102.64 85.06,102.54 85.06,102.16 85.09,102.14 88.72,102.14 89,101.96 89,99.75 88.83,99.57 84.79,99.57 84.46,99.9 84.46,101.39 84.39,101.46 83.25,101.46 82.91,101.81 82.91,104.7 82.93,104.73 83.31,104.73
GND on BOTTOM (solid shape): 161.75,27.56 161.75,26.53 161.7,26.49 161.7,25.15 159.46,22.91 155.37,22.91 154.56,23.73 154.56,24.79 154.64,24.87 155.52,24.87 155.93,25.28 155.93,26.6 156.21,26.88 157.35,26.88 158.32,27.84 161.47,27.84
GND on BOTTOM (solid shape): 190.61,56.51 191.96,56.51 192.02,56.44 192.02,55.53 191.95,55.45 191.54,55.45 191.54,55.91 191.49,55.96 191.39,55.96 191.34,55.91 191.34,55.45 190.91,55.45 190.91,55.93 190.88,55.96 190.73,55.96 190.68,55.91 190.68,55.45 189.71,55.45 189.28,55.88 189.28,56.31 189.48,56.52 190.61,56.52
GND on BOTTOM (solid shape): 155.47,38.23 155.63,38.2 155.79,38.23 155.81,38.23 155.89,38.15 155.89,34.97 156.87,33.98 156.87,31.8 156.7,31.63 152.63,31.63 152.25,32.02 152.25,33.4 152.2,33.45 152.2,36.43 152.22,36.45 154.26,36.45 154.55,36.75 154.55,37.77 155.01,38.23
GND on BOTTOM (solid shape): 190.3,62.15 190.3,61.57 190.59,61.28 191.24,61.28 191.43,61.09 191.43,60.49 191.36,60.43 190.86,60.43 190.73,60.3 190.73,59.26 190.83,59.16 192.66,59.16 192.85,58.97 192.85,58.23 192.49,57.88 188.38,57.88 187.66,58.6 186,58.6 185.74,58.87 185.74,61.8 186.43,62.48 189.97,62.48
GND on BOTTOM (solid shape): 191.49,50.02 191.49,49.38 191.69,49.18 192.53,49.18 193.24,48.47 193.24,44.91 192.84,44.5 187.68,44.5 187.3,44.88 187.3,47.12 187,47.42 185.39,47.42 185.11,47.7 185.11,48.49 185.37,48.75 185.37,49.91 185.73,50.27 191.24,50.27
GND on BOTTOM (solid shape): 139.6,26.8 139.6,25.94 138.96,25.3 138.96,22.35 139.14,22.18 140.26,22.18 140.46,21.97 141.05,21.97 141.2,21.82 141.2,21.19 141,20.98 138.13,20.98 138.02,21.08 138.02,21.62 138.15,21.74 138.15,25.45 138.35,25.66 138.35,26.82 138.46,26.93 139.47,26.93
